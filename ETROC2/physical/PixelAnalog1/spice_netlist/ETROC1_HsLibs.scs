
// Library name: lpGbtxHsLib
// Cell name: MAOI222BD1_LVT_ELT
// View name: calibre
subckt MAOI222BD1_LVT_ELT A B C ZN VDD VSS
    MMI1 (MMI1_d MMI1_g MMI1_s MMI1_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=2.4125e-13 as=9.4e-14 pd=3.55e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MMU6 (MMU6_d MMU6_g MMU6_s MMU6_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=2.4125e-13 as=9.4e-14 pd=3.55e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM1 (MM1_d MM1_g MM1_s MM1_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=2.4125e-13 as=9.4e-14 pd=3.55e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MMI5 (MMI5_d MMI5_g MMI5_s MMI5_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.4125e-13 pd=1.34e-06 ps=3.55e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MMI4 (MMI4_d MMI4_g MMI4_s MMI4_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.4125e-13 pd=1.34e-06 ps=3.55e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MMU9 (MMU9_d MMU9_g MMU9_s MMU9_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.4125e-13 pd=1.34e-06 ps=3.55e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MMU5 (MMU5_d MMU5_g MMU5_s MMU5_b) pch_lvt l=6e-08 w=3.74e-06 m=1 nf=1 \
        ad=4.8485e-13 as=3.26e-13 pd=6.64333e-06 ps=3.66e-06 nrd=0.026738 \
        nrs=0.026738 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MMI2 (MMI2_d MMI2_g MMI2_s MMI2_b) pch_lvt l=6e-08 w=3.74e-06 m=1 nf=1 \
        ad=4.8485e-13 as=3.26e-13 pd=6.64333e-06 ps=3.66e-06 nrd=0.026738 \
        nrs=0.026738 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM0 (MM0_d MM0_g MM0_s MM0_b) pch_lvt l=6e-08 w=3.74e-06 m=1 nf=1 \
        ad=4.8485e-13 as=3.26e-13 pd=6.64333e-06 ps=3.66e-06 nrd=0.026738 \
        nrs=0.026738 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MMI3 (MMI3_d MMI3_g MMI3_s MMI3_b) pch_lvt l=6e-08 w=3.74e-06 m=1 nf=1 \
        ad=3.26e-13 as=4.8485e-13 pd=3.66e-06 ps=6.64333e-06 nrd=0.026738 \
        nrs=0.026738 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MMU2 (MMU2_d MMU2_g MMU2_s MMU2_b) pch_lvt l=6e-08 w=3.74e-06 m=1 nf=1 \
        ad=3.26e-13 as=4.8485e-13 pd=3.66e-06 ps=6.64333e-06 nrd=0.026738 \
        nrs=0.026738 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MMU4 (MMU4_d MMU4_g MMU4_s MMU4_b) pch_lvt l=6e-08 w=3.74e-06 m=1 nf=1 \
        ad=3.26e-13 as=4.8485e-13 pd=3.66e-06 ps=6.64333e-06 nrd=0.026738 \
        nrs=0.026738 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    cinet33_5 (net33_3 VSS) capacitor c=1.87717e-16
    cinet33_4 (net33_4 VSS) capacitor c=3.37809e-16
    cinet33_3 (net33_12 VSS) capacitor c=3.36613e-16
    cinet33_2 (net33_13 VSS) capacitor c=1.8341e-17
    cinet33_1 (net33_16 VSS) capacitor c=1.93195e-16
    cinet33_0 (net33_17 VSS) capacitor c=3.30145e-16
    cinet5_5 (net5_3 VSS) capacitor c=6.19108e-17
    cinet5_4 (net5_4 VSS) capacitor c=1.13729e-16
    cinet5_3 (net5_6 VSS) capacitor c=3.41087e-16
    cinet5_2 (net5_7 VSS) capacitor c=2.08855e-17
    cinet5_1 (net5_10 VSS) capacitor c=5.5368e-17
    cinet5_0 (net5_11 VSS) capacitor c=1.08442e-16
    ciZN_38 (ZN_3 VSS) capacitor c=4.39407e-17
    ciZN_37 (ZN_4 VSS) capacitor c=6.20458e-17
    ciZN_36 (ZN_8 VSS) capacitor c=2.51757e-16
    ciZN_35 (ZN_15 VSS) capacitor c=3.80851e-16
    ciZN_34 (ZN_17 VSS) capacitor c=6.09389e-17
    ciZN_33 (ZN_18 VSS) capacitor c=1.65905e-17
    ciZN_32 (ZN_19 VSS) capacitor c=5.08472e-17
    ciZN_31 (ZN_20 VSS) capacitor c=1.51051e-17
    ciZN_30 (ZN_23 VSS) capacitor c=3.87935e-17
    ciZN_29 (ZN_24 VSS) capacitor c=5.98874e-17
    ciZN_28 (ZN_28 VSS) capacitor c=2.42436e-16
    ciZN_27 (ZN_35 VSS) capacitor c=3.78963e-16
    ciZN_26 (ZN_37 VSS) capacitor c=5.02389e-17
    ciZN_25 (ZN_39 VSS) capacitor c=4.85055e-17
    ciZN_24 (ZN VSS) capacitor c=2.82944e-17
    ciZN_23 (ZN_45 VSS) capacitor c=9.67559e-18
    ciZN_22 (ZN_46 VSS) capacitor c=9.68526e-18
    ciZN_21 (MM1_d VSS) capacitor c=1.05855e-17
    ciZN_20 (ZN_50 VSS) capacitor c=9.51084e-19
    ciZN_19 (ZN_51 VSS) capacitor c=2.23104e-18
    ciZN_18 (ZN_53 VSS) capacitor c=4.88313e-18
    ciZN_17 (ZN_57 VSS) capacitor c=4.09419e-18
    ciZN_16 (ZN_59 VSS) capacitor c=2.26328e-19
    ciZN_15 (ZN_63 VSS) capacitor c=5.86191e-18
    ciZN_14 (ZN_70 VSS) capacitor c=1.40317e-18
    ciZN_13 (ZN_72 VSS) capacitor c=8.02277e-17
    ciZN_12 (ZN_74 VSS) capacitor c=2.21501e-18
    ciZN_11 (ZN_76 VSS) capacitor c=7.83411e-17
    ciZN_10 (MM0_d VSS) capacitor c=3.20675e-17
    ciZN_9 (ZN_80 VSS) capacitor c=1.41789e-18
    ciZN_8 (ZN_81 VSS) capacitor c=4.63285e-18
    ciZN_7 (ZN_83 VSS) capacitor c=5.97266e-18
    ciZN_6 (ZN_87 VSS) capacitor c=4.63285e-18
    ciZN_5 (ZN_89 VSS) capacitor c=1.07074e-18
    ciZN_4 (ZN_93 VSS) capacitor c=7.01981e-18
    ciZN_3 (ZN_95 VSS) capacitor c=1.07074e-18
    ciZN_2 (ZN_98 VSS) capacitor c=1.32762e-17
    ciZN_1 (ZN_102 VSS) capacitor c=2.21501e-18
    ciZN_0 (ZN_106 VSS) capacitor c=2.21501e-18
    cinet18_5 (net18_3 VSS) capacitor c=1.97677e-16
    cinet18_4 (net18_4 VSS) capacitor c=3.29935e-16
    cinet18_3 (net18_12 VSS) capacitor c=3.46274e-16
    cinet18_2 (net18_13 VSS) capacitor c=1.48783e-17
    cinet18_1 (net18_16 VSS) capacitor c=1.967e-16
    cinet18_0 (net18_17 VSS) capacitor c=3.37805e-16
    cinet19_5 (net19_3 VSS) capacitor c=6.31062e-17
    cinet19_4 (net19_4 VSS) capacitor c=1.11634e-16
    cinet19_3 (net19_6 VSS) capacitor c=3.22397e-16
    cinet19_2 (net19_7 VSS) capacitor c=1.48783e-17
    cinet19_1 (net19_10 VSS) capacitor c=6.85304e-17
    cinet19_0 (net19_11 VSS) capacitor c=1.10137e-16
    ciC_27 (C_42 VSS) capacitor c=5.61112e-18
    ciC_26 (C_45 VSS) capacitor c=5.40259e-18
    ciC_25 (C_48 VSS) capacitor c=1.89327e-16
    ciC_24 (C_50 VSS) capacitor c=6.1179e-18
    ciC_23 (C_53 VSS) capacitor c=4.18458e-18
    ciC_22 (C_56 VSS) capacitor c=5.84451e-16
    ciC_21 (C_58 VSS) capacitor c=2.97813e-17
    ciC_20 (C_66 VSS) capacitor c=2.02965e-17
    ciC_19 (C_74 VSS) capacitor c=1.45985e-17
    ciC_18 (C_82 VSS) capacitor c=2.19253e-17
    ciC_17 (C_90 VSS) capacitor c=5.25571e-18
    ciC_16 (C_113 VSS) capacitor c=5.28257e-18
    ciC_15 (C_118 VSS) capacitor c=7.34816e-18
    ciC_14 (C_124 VSS) capacitor c=1.67994e-16
    ciC_13 (C_135 VSS) capacitor c=5.79813e-16
    ciC_12 (C_141 VSS) capacitor c=6.6995e-18
    ciC_11 (C_146 VSS) capacitor c=3.25456e-17
    ciC_10 (C_154 VSS) capacitor c=2.73745e-17
    ciC_9 (C_162 VSS) capacitor c=2.1989e-17
    ciC_8 (C_170 VSS) capacitor c=2.64018e-17
    ciC_7 (C_178 VSS) capacitor c=1.04273e-17
    ciC_6 (C_181 VSS) capacitor c=3.07936e-17
    ciC_5 (C_186 VSS) capacitor c=7.7531e-18
    ciC_4 (C_189 VSS) capacitor c=9.69957e-18
    ciC_3 (C_381 VSS) capacitor c=5.80587e-18
    ciC_2 (C_386 VSS) capacitor c=3.48587e-17
    ciC_1 (C_387 VSS) capacitor c=1.12979e-17
    ciC_0 (C VSS) capacitor c=2.12254e-16
    ciVDD_20 (VDD_2 VSS) capacitor c=6.33967e-17
    ciVDD_19 (VDD_11 VSS) capacitor c=2.44357e-16
    ciVDD_18 (VDD_19 VSS) capacitor c=2.81314e-17
    ciVDD_17 (VDD_20 VSS) capacitor c=3.17816e-17
    ciVDD_16 (VDD_27 VSS) capacitor c=2.63885e-16
    ciVDD_15 (VDD_35 VSS) capacitor c=2.55709e-17
    ciVDD_14 (VDD_47 VSS) capacitor c=3.19789e-16
    ciVDD_13 (VDD_50 VSS) capacitor c=3.58509e-18
    ciVDD_12 (VDD_51 VSS) capacitor c=3.58509e-18
    ciVDD_11 (VDD_57 VSS) capacitor c=1.32762e-17
    ciVDD_10 (VDD_59 VSS) capacitor c=7.73228e-18
    ciVDD_9 (VDD_62 VSS) capacitor c=1.11099e-18
    ciVDD_8 (VDD_66 VSS) capacitor c=1.11099e-18
    ciVDD_7 (VDD_68 VSS) capacitor c=1.08849e-17
    ciVDD_6 (MMI3_s VSS) capacitor c=3.20675e-17
    ciVDD_5 (VDD_71 VSS) capacitor c=1.46342e-17
    ciVDD_4 (VDD_72 VSS) capacitor c=1.41789e-18
    ciVDD_3 (VDD_74 VSS) capacitor c=4.62042e-18
    ciVDD_2 (VDD_77 VSS) capacitor c=3.65898e-16
    ciVDD_1 (VDD_79 VSS) capacitor c=9.06822e-18
    ciVDD_0 (VDD_81 VSS) capacitor c=3.67456e-16
    ciVSS_17 (VSS_2 VSS) capacitor c=6.27326e-17
    ciVSS_16 (VSS_11 VSS) capacitor c=8.01242e-17
    ciVSS_15 (VSS_12 VSS) capacitor c=1.27629e-16
    ciVSS_14 (VSS_14 VSS) capacitor c=3.07439e-17
    ciVSS_13 (VSS_21 VSS) capacitor c=1.00356e-16
    ciVSS_12 (VSS_22 VSS) capacitor c=1.2068e-16
    ciVSS_11 (VSS_35 VSS) capacitor c=3.10385e-16
    ciVSS_10 (VSS_38 VSS) capacitor c=3.58509e-18
    ciVSS_9 (VSS_39 VSS) capacitor c=3.58509e-18
    ciVSS_8 (VSS_48 VSS) capacitor c=6.23154e-18
    ciVSS_7 (VSS_52 VSS) capacitor c=2.52314e-18
    ciVSS_6 (VSS_54 VSS) capacitor c=6.80447e-18
    ciVSS_5 (MMI5_s VSS) capacitor c=1.05855e-17
    ciVSS_4 (VSS_56 VSS) capacitor c=9.51084e-19
    ciVSS_3 (VSS_58 VSS) capacitor c=4.06022e-18
    ciVSS_2 (VSS_60 VSS) capacitor c=1.29859e-17
    ciVSS_1 (VSS_65 VSS) capacitor c=1.71694e-18
    ciVSS_0 (VSS_67 VSS) capacitor c=9.36738e-18
    cinet28_15 (net28_3 VSS) capacitor c=1.22966e-16
    cinet28_14 (net28_4 VSS) capacitor c=3.65301e-16
    cinet28_13 (net28_6 VSS) capacitor c=9.05039e-18
    cinet28_12 (net28_8 VSS) capacitor c=2.85821e-17
    cinet28_11 (net28_13 VSS) capacitor c=1.23007e-16
    cinet28_10 (net28_14 VSS) capacitor c=3.65457e-16
    cinet28_9 (net28_16 VSS) capacitor c=9.2564e-18
    cinet28_8 (net28_18 VSS) capacitor c=3.17002e-17
    cinet28_7 (net28_21 VSS) capacitor c=6.49826e-18
    cinet28_6 (net28_23 VSS) capacitor c=6.46703e-18
    cinet28_5 (net28_27 VSS) capacitor c=4.32573e-17
    cinet28_4 (net28_30 VSS) capacitor c=1.79706e-16
    cinet28_3 (net28_31 VSS) capacitor c=1.45668e-17
    cinet28_2 (net28_34 VSS) capacitor c=4.2906e-17
    cinet28_1 (net28_43 VSS) capacitor c=3.57109e-17
    cinet28_0 (net28 VSS) capacitor c=3.57109e-17
    cinet13_10 (net13_5 VSS) capacitor c=2.72147e-17
    cinet13_9 (net13_7 VSS) capacitor c=7.8743e-17
    cinet13_8 (net13_8 VSS) capacitor c=1.22817e-16
    cinet13_7 (net13_11 VSS) capacitor c=4.12824e-17
    cinet13_6 (net13_12 VSS) capacitor c=7.48028e-17
    cinet13_5 (net13_14 VSS) capacitor c=1.56282e-16
    cinet13_4 (net13_15 VSS) capacitor c=1.04481e-17
    cinet13_3 (net13_16 VSS) capacitor c=1.08172e-17
    cinet13_2 (net13_22 VSS) capacitor c=1.60794e-17
    cinet13_1 (net13_25 VSS) capacitor c=1.86992e-17
    cinet13_0 (net13_27 VSS) capacitor c=1.12435e-16
    ciB_35 (B_42 VSS) capacitor c=2.97045e-18
    ciB_34 (B_48 VSS) capacitor c=2.73932e-16
    ciB_33 (B_59 VSS) capacitor c=8.08169e-16
    ciB_32 (B_65 VSS) capacitor c=3.00043e-18
    ciB_31 (B_70 VSS) capacitor c=2.74329e-17
    ciB_30 (B_78 VSS) capacitor c=1.83939e-17
    ciB_29 (B_86 VSS) capacitor c=1.39213e-17
    ciB_28 (B_94 VSS) capacitor c=1.71585e-17
    ciB_27 (B_102 VSS) capacitor c=4.37679e-18
    ciB_26 (B_105 VSS) capacitor c=4.23564e-18
    ciB_25 (B_110 VSS) capacitor c=6.1176e-18
    ciB_24 (B_113 VSS) capacitor c=2.95937e-18
    ciB_23 (B_118 VSS) capacitor c=8.9547e-18
    ciB_22 (B_124 VSS) capacitor c=2.14616e-16
    ciB_21 (B_135 VSS) capacitor c=5.73292e-16
    ciB_20 (B_141 VSS) capacitor c=9.09614e-18
    ciB_19 (B_146 VSS) capacitor c=3.06573e-17
    ciB_18 (B_154 VSS) capacitor c=2.00069e-17
    ciB_17 (B_162 VSS) capacitor c=1.27806e-17
    ciB_16 (B_170 VSS) capacitor c=2.31483e-17
    ciB_15 (B_178 VSS) capacitor c=2.15225e-18
    ciB_14 (B_181 VSS) capacitor c=1.72402e-18
    ciB_13 (B_186 VSS) capacitor c=1.72402e-18
    ciB_12 (B_189 VSS) capacitor c=2.22299e-18
    ciB_11 (B_261 VSS) capacitor c=4.44408e-17
    ciB_10 (B_267 VSS) capacitor c=6.421e-18
    ciB_9 (B_268 VSS) capacitor c=1.92814e-16
    ciB_8 (B_269 VSS) capacitor c=8.122e-18
    ciB_7 (B_271 VSS) capacitor c=1.5071e-17
    ciB_6 (B_275 VSS) capacitor c=2.89069e-17
    ciB_5 (B_276 VSS) capacitor c=1.12879e-16
    ciB_4 (B_388 VSS) capacitor c=8.14199e-18
    ciB_3 (B_397 VSS) capacitor c=4.66203e-17
    ciB_2 (B_398 VSS) capacitor c=9.67305e-18
    ciB_1 (B_406 VSS) capacitor c=3.65366e-17
    ciB_0 (B VSS) capacitor c=1.02213e-16
    ciA_34 (A_42 VSS) capacitor c=2.22299e-18
    ciA_33 (A_48 VSS) capacitor c=1.94514e-16
    ciA_32 (A_53 VSS) capacitor c=2.22299e-18
    ciA_31 (A_56 VSS) capacitor c=5.76269e-16
    ciA_30 (A_58 VSS) capacitor c=2.2416e-17
    ciA_29 (A_66 VSS) capacitor c=2.08837e-17
    ciA_28 (A_74 VSS) capacitor c=1.44392e-17
    ciA_27 (A_82 VSS) capacitor c=1.51948e-17
    ciA_26 (A_90 VSS) capacitor c=4.2527e-18
    ciA_25 (A_113 VSS) capacitor c=4.28147e-18
    ciA_24 (A_118 VSS) capacitor c=8.14476e-18
    ciA_23 (A_124 VSS) capacitor c=2.83081e-16
    ciA_22 (A_135 VSS) capacitor c=7.92052e-16
    ciA_21 (A_141 VSS) capacitor c=9.69957e-18
    ciA_20 (A_146 VSS) capacitor c=3.10047e-17
    ciA_19 (A_154 VSS) capacitor c=2.03469e-17
    ciA_18 (A_162 VSS) capacitor c=1.35583e-17
    ciA_17 (A_170 VSS) capacitor c=2.77357e-17
    ciA_16 (A_178 VSS) capacitor c=8.66992e-18
    ciA_15 (A_181 VSS) capacitor c=3.04199e-17
    ciA_14 (A_186 VSS) capacitor c=6.88708e-18
    ciA_13 (A_189 VSS) capacitor c=1.14125e-17
    ciA_12 (A_261 VSS) capacitor c=1.80363e-17
    ciA_11 (A_267 VSS) capacitor c=6.99619e-18
    ciA_10 (A_268 VSS) capacitor c=2.07186e-16
    ciA_9 (A_269 VSS) capacitor c=6.39804e-18
    ciA_8 (A_270 VSS) capacitor c=1.27229e-17
    ciA_7 (A_271 VSS) capacitor c=7.18851e-18
    ciA_6 (A_275 VSS) capacitor c=3.22732e-17
    ciA_5 (A_276 VSS) capacitor c=9.53059e-17
    ciA_4 (A_391 VSS) capacitor c=2.63299e-17
    ciA_3 (A_392 VSS) capacitor c=8.72335e-18
    ciA_2 (A_397 VSS) capacitor c=5.57597e-17
    ciA_1 (A_398 VSS) capacitor c=7.09625e-18
    ciA_0 (A VSS) capacitor c=6.09007e-17
    rnet33_27 (MMU5_s net33) resistor r=0.01
    rnet33_26 (net33_1 net33_10) resistor r=0.277258
    rnet33_25 (net33_1 net33_13) resistor r=0.0961393
    rnet33_24 (net33_3 net33_4) resistor r=8.66667
    rnet33_23 (net33_3 net33_7) resistor r=0.639827
    rnet33_22 (net33_4 MMI3_d) resistor r=32.3614
    rnet33_21 (net33_7 net33_8) resistor r=8.66667
    rnet33_20 (net33_7 net33_10) resistor r=0.426551
    rnet33_19 (net33_8 MMI3_d) resistor r=16.1807
    rnet33_18 (net33_8 net33_11) resistor r=32.3614
    rnet33_17 (net33_10 net33_11) resistor r=26
    rnet33_16 (net33_12 net33_13) resistor r=2.73411
    rnet33_15 (net33_12 net33_14) resistor r=0.0961393
    rnet33_14 (net33_14 net33_23) resistor r=0.277258
    rnet33_13 (net33_16 net33_17) resistor r=8.66667
    rnet33_12 (net33_16 net33_20) resistor r=0.639827
    rnet33_11 (net33_17 net33) resistor r=32.3614
    rnet33_10 (net33_20 net33_21) resistor r=8.66667
    rnet33_9 (net33_20 net33_23) resistor r=0.426551
    rnet33_8 (net33_21 net33) resistor r=16.1807
    rnet33_7 (net33_21 net33_24) resistor r=32.3614
    rnet33_6 (net33_23 net33_24) resistor r=26
    rnet5_15 (MMI1_s net5) resistor r=0.01
    rnet5_14 (net5_1 net5_3) resistor r=0.191948
    rnet5_13 (net5_1 net5_7) resistor r=0.0961393
    rnet5_12 (net5_3 net5_4) resistor r=13
    rnet5_11 (net5_4 MMI5_d) resistor r=8.44
    rnet5_10 (net5_6 net5_7) resistor r=2.70042
    rnet5_9 (net5_6 net5_8) resistor r=0.0961393
    rnet5_8 (net5_8 net5_10) resistor r=0.175757
    rnet5_7 (net5_10 net5_11) resistor r=13
    rnet5_6 (net5_11 net5) resistor r=8.44
    rZN_160 (ZN_1 ZN_3) resistor r=0.259001
    rZN_159 (ZN_1 ZN_18) resistor r=0.0961393
    rZN_158 (ZN_3 ZN_4) resistor r=13
    rZN_157 (ZN_4 MMU6_d) resistor r=4.22001
    rZN_156 (ZN_4 ZN_71) resistor r=4.22001
    rZN_155 (ZN_4 MM1_d) resistor r=4.22001
    rZN_154 (ZN_4 ZN_69) resistor r=4.22001
    rZN_153 (ZN_6 ZN_8) resistor r=0.439039
    rZN_152 (ZN_6 ZN_20) resistor r=0.0961393
    rZN_151 (ZN_8 ZN_15) resistor r=8.66667
    rZN_150 (ZN_8 ZN_11) resistor r=0.702463
    rZN_149 (ZN_11 ZN_15) resistor r=8.66667
    rZN_148 (ZN_11 ZN_14) resistor r=0.4744
    rZN_147 (ZN_14 ZN_15) resistor r=13
    rZN_146 (ZN_15 MMI2_d) resistor r=4.04518
    rZN_145 (ZN_15 ZN_101) resistor r=4.04518
    rZN_144 (ZN_15 MM0_d) resistor r=4.04518
    rZN_143 (ZN_15 ZN_99) resistor r=4.04518
    rZN_142 (ZN_17 ZN_18) resistor r=0.694153
    rZN_141 (ZN_17 ZN_45) resistor r=0.0728613
    rZN_140 (ZN_19 ZN_20) resistor r=0.610018
    rZN_139 (ZN_19 ZN_46) resistor r=0.0728613
    rZN_138 (ZN_21 ZN_23) resistor r=0.252834
    rZN_137 (ZN_21 ZN_45) resistor r=0.0189354
    rZN_136 (ZN_23 ZN_24) resistor r=13
    rZN_135 (ZN_24 MMI1_d) resistor r=4.22001
    rZN_134 (ZN_24 ZN_75) resistor r=4.22001
    rZN_133 (ZN_24 MMU6_d) resistor r=4.22001
    rZN_132 (ZN_24 ZN_73) resistor r=4.22001
    rZN_131 (ZN_26 ZN_28) resistor r=0.439039
    rZN_130 (ZN_26 ZN_46) resistor r=0.0189354
    rZN_129 (ZN_28 ZN_35) resistor r=8.66667
    rZN_128 (ZN_28 ZN_31) resistor r=0.702463
    rZN_127 (ZN_31 ZN_35) resistor r=8.66667
    rZN_126 (ZN_31 ZN_34) resistor r=0.4744
    rZN_125 (ZN_34 ZN_35) resistor r=13
    rZN_124 (ZN_35 MMU5_d) resistor r=4.04518
    rZN_123 (ZN_35 ZN_105) resistor r=4.04518
    rZN_122 (ZN_35 MMI2_d) resistor r=4.04518
    rZN_121 (ZN_35 ZN_103) resistor r=4.04518
    rZN_120 (ZN_37 ZN_38) resistor r=0.597295
    rZN_119 (ZN_37 ZN_41) resistor r=0.0961393
    rZN_118 (ZN_38 ZN_45) resistor r=0.0728613
    rZN_117 (ZN_39 ZN_40) resistor r=0.5249
    rZN_116 (ZN_39 ZN_42) resistor r=0.0961393
    rZN_115 (ZN_40 ZN_46) resistor r=0.0728613
    rZN_114 (ZN_41 ZN) resistor r=0.180843
    rZN_113 (ZN_42 ZN) resistor r=0.180843
    rZN_112 (MM1_d ZN_48) resistor r=18.0507
    rZN_111 (MM1_d ZN_51) resistor r=2.67027
    rZN_110 (MM1_d ZN_53) resistor r=12.8495
    rZN_109 (MM1_d ZN_53) resistor r=1.69926
    rZN_108 (ZN_48 ZN_50) resistor r=9.43134
    rZN_107 (ZN_49 ZN_51) resistor r=15.1041
    rZN_106 (ZN_49 ZN_70) resistor r=11.0157
    rZN_105 (ZN_50 ZN_51) resistor r=15.1041
    rZN_104 (ZN_52 ZN_53) resistor r=12.8495
    rZN_103 (ZN_52 ZN_72) resistor r=10.6787
    rZN_102 (MMU6_d ZN_57) resistor r=2.67027
    rZN_101 (MMU6_d ZN_59) resistor r=12.8495
    rZN_100 (MMU6_d ZN_59) resistor r=1.69926
    rZN_99 (MMU6_d ZN_72) resistor r=10.6787
    rZN_98 (ZN_55 ZN_57) resistor r=15.1041
    rZN_97 (ZN_55 ZN_74) resistor r=11.0157
    rZN_96 (ZN_56 ZN_57) resistor r=15.1041
    rZN_95 (ZN_56 ZN_70) resistor r=11.0157
    rZN_94 (ZN_58 ZN_59) resistor r=12.8495
    rZN_93 (ZN_58 ZN_76) resistor r=10.6787
    rZN_92 (MMI1_d ZN_63) resistor r=2.67027
    rZN_91 (MMI1_d ZN_65) resistor r=12.8495
    rZN_90 (MMI1_d ZN_65) resistor r=1.69926
    rZN_89 (MMI1_d ZN_68) resistor r=4.557
    rZN_88 (MMI1_d ZN_76) resistor r=10.6787
    rZN_87 (ZN_61 ZN_63) resistor r=15.1041
    rZN_86 (ZN_61 ZN_66) resistor r=9.43134
    rZN_85 (ZN_62 ZN_63) resistor r=15.1041
    rZN_84 (ZN_62 ZN_74) resistor r=11.0157
    rZN_83 (ZN_64 ZN_65) resistor r=12.8495
    rZN_82 (ZN_64 ZN_67) resistor r=9.4369
    rZN_81 (ZN_66 ZN_68) resistor r=21.1301
    rZN_80 (ZN_67 ZN_68) resistor r=21.1301
    rZN_79 (ZN_69 ZN_70) resistor r=0.762262
    rZN_78 (ZN_71 ZN_72) resistor r=0.57282
    rZN_77 (ZN_73 ZN_74) resistor r=0.762262
    rZN_76 (ZN_75 ZN_76) resistor r=0.57282
    rZN_75 (MM0_d ZN_78) resistor r=25.7298
    rZN_74 (MM0_d ZN_81) resistor r=2.55965
    rZN_73 (MM0_d ZN_83) resistor r=12.3172
    rZN_72 (MM0_d ZN_83) resistor r=1.62887
    rZN_71 (ZN_78 ZN_80) resistor r=9.04062
    rZN_70 (ZN_79 ZN_81) resistor r=14.4784
    rZN_69 (ZN_79 ZN_102) resistor r=10.5593
    rZN_68 (ZN_80 ZN_81) resistor r=14.4784
    rZN_67 (ZN_82 ZN_83) resistor r=12.3172
    rZN_66 (ZN_82 ZN_100) resistor r=10.2363
    rZN_65 (MMI2_d ZN_87) resistor r=2.55965
    rZN_64 (MMI2_d ZN_89) resistor r=12.3172
    rZN_63 (MMI2_d ZN_89) resistor r=1.62887
    rZN_62 (MMI2_d ZN_100) resistor r=10.2363
    rZN_61 (ZN_85 ZN_87) resistor r=14.4784
    rZN_60 (ZN_85 ZN_106) resistor r=10.5593
    rZN_59 (ZN_86 ZN_87) resistor r=14.4784
    rZN_58 (ZN_86 ZN_102) resistor r=10.5593
    rZN_57 (ZN_88 ZN_89) resistor r=12.3172
    rZN_56 (ZN_88 ZN_104) resistor r=10.2363
    rZN_55 (MMU5_d ZN_93) resistor r=2.55965
    rZN_54 (MMU5_d ZN_95) resistor r=12.3172
    rZN_53 (MMU5_d ZN_95) resistor r=1.62887
    rZN_52 (MMU5_d ZN_98) resistor r=6.12113
    rZN_51 (MMU5_d ZN_104) resistor r=10.2363
    rZN_50 (ZN_91 ZN_93) resistor r=14.4784
    rZN_49 (ZN_91 ZN_97) resistor r=9.04062
    rZN_48 (ZN_92 ZN_93) resistor r=14.4784
    rZN_47 (ZN_92 ZN_106) resistor r=10.5593
    rZN_46 (ZN_94 ZN_95) resistor r=12.3172
    rZN_45 (ZN_94 ZN_96) resistor r=9.04595
    rZN_44 (ZN_96 ZN_98) resistor r=31.2341
    rZN_43 (ZN_97 ZN_98) resistor r=31.2341
    rZN_42 (ZN_99 ZN_100) resistor r=0.549089
    rZN_41 (ZN_101 ZN_102) resistor r=0.730683
    rZN_40 (ZN_103 ZN_104) resistor r=0.549089
    rZN_39 (ZN_105 ZN_106) resistor r=0.730683
    rnet18_27 (MM0_s net18) resistor r=0.01
    rnet18_26 (net18_1 net18_3) resistor r=0.522525
    rnet18_25 (net18_1 net18_13) resistor r=0.0961393
    rnet18_24 (net18_3 net18_4) resistor r=8.66667
    rnet18_23 (net18_3 net18_6) resistor r=0.639827
    rnet18_22 (net18_4 MMU4_d) resistor r=32.3614
    rnet18_21 (net18_6 net18_7) resistor r=8.66667
    rnet18_20 (net18_6 net18_9) resistor r=0.426551
    rnet18_19 (net18_7 MMU4_d) resistor r=16.1807
    rnet18_18 (net18_7 net18_10) resistor r=32.3614
    rnet18_17 (net18_9 net18_10) resistor r=26
    rnet18_16 (net18_12 net18_13) resistor r=2.73411
    rnet18_15 (net18_12 net18_14) resistor r=0.0961393
    rnet18_14 (net18_14 net18_16) resistor r=0.522525
    rnet18_13 (net18_16 net18_17) resistor r=8.66667
    rnet18_12 (net18_16 net18_19) resistor r=0.639827
    rnet18_11 (net18_17 net18) resistor r=32.3614
    rnet18_10 (net18_19 net18_20) resistor r=8.66667
    rnet18_9 (net18_19 net18_22) resistor r=0.426551
    rnet18_8 (net18_20 net18) resistor r=16.1807
    rnet18_7 (net18_20 net18_23) resistor r=32.3614
    rnet18_6 (net18_22 net18_23) resistor r=26
    rnet19_15 (MM1_s net19) resistor r=0.01
    rnet19_14 (net19_1 net19_3) resistor r=0.437215
    rnet19_13 (net19_1 net19_7) resistor r=0.0961393
    rnet19_12 (net19_3 net19_4) resistor r=13
    rnet19_11 (net19_4 MMU9_d) resistor r=8.44
    rnet19_10 (net19_6 net19_7) resistor r=2.63133
    rnet19_9 (net19_6 net19_8) resistor r=0.0961393
    rnet19_8 (net19_8 net19_10) resistor r=0.437215
    rnet19_7 (net19_10 net19_11) resistor r=13
    rnet19_6 (net19_11 net19) resistor r=8.44
    rC_188 (C_42 C_48) resistor r=58.3583
    rC_187 (C_42 C_48) resistor r=4.16253
    rC_186 (C_42 C_48) resistor r=58.3583
    rC_185 (C_42 C_48) resistor r=4.16253
    rC_184 (C_45 C_48) resistor r=58.3583
    rC_183 (C_45 C_48) resistor r=4.16253
    rC_182 (C_45 C_48) resistor r=58.3583
    rC_181 (C_45 C_48) resistor r=4.16253
    rC_180 (C_48 C_61) resistor r=24.8333
    rC_179 (C_48 C_58) resistor r=24.8333
    rC_178 (C_48 C_69) resistor r=24.8333
    rC_177 (C_48 C_66) resistor r=24.8333
    rC_176 (C_48 C_90) resistor r=58.3583
    rC_175 (C_48 C_93) resistor r=58.3583
    rC_174 (C_48 C_98) resistor r=14.9
    rC_173 (C_48 C_61) resistor r=4.16253
    rC_172 (C_48 C_69) resistor r=4.16253
    rC_171 (C_48 C_58) resistor r=4.16253
    rC_170 (C_48 C_90) resistor r=4.16253
    rC_169 (C_48 C_98) resistor r=6.30933
    rC_168 (C_48 C_93) resistor r=6.30933
    rC_167 (C_48 C_66) resistor r=1.63969
    rC_166 (C_48 C_61) resistor r=24.8333
    rC_165 (C_48 C_58) resistor r=24.8333
    rC_164 (C_48 C_69) resistor r=24.8333
    rC_163 (C_48 C_66) resistor r=24.8333
    rC_162 (C_48 C_90) resistor r=58.3583
    rC_161 (C_48 MMI5_g) resistor r=22.35
    rC_160 (C_48 C_98) resistor r=14.9
    rC_159 (C_48 C_330) resistor r=40.975
    rC_158 (C_48 C_61) resistor r=4.16253
    rC_157 (C_48 C_69) resistor r=4.16253
    rC_156 (C_48 C_58) resistor r=4.16253
    rC_155 (C_48 C_90) resistor r=4.16253
    rC_154 (C_48 C_98) resistor r=6.30933
    rC_153 (C_48 C_93) resistor r=6.30933
    rC_152 (C_48 C_66) resistor r=1.63969
    rC_151 (C_50 C_56) resistor r=202.392
    rC_150 (C_50 C_56) resistor r=4.16253
    rC_149 (C_50 C_56) resistor r=202.392
    rC_148 (C_50 C_56) resistor r=4.16253
    rC_147 (C_53 C_56) resistor r=202.392
    rC_146 (C_53 C_56) resistor r=4.16253
    rC_145 (C_53 C_56) resistor r=202.392
    rC_144 (C_53 C_56) resistor r=4.16253
    rC_143 (C_56 C_77) resistor r=24.8333
    rC_142 (C_56 C_74) resistor r=24.8333
    rC_141 (C_56 C_85) resistor r=24.8333
    rC_140 (C_56 C_82) resistor r=24.8333
    rC_139 (C_56 C_104) resistor r=14.9
    rC_138 (C_56 C_110) resistor r=202.392
    rC_137 (C_56 C_113) resistor r=202.392
    rC_136 (C_56 C_77) resistor r=4.16253
    rC_135 (C_56 C_85) resistor r=4.16253
    rC_134 (C_56 C_110) resistor r=6.30933
    rC_133 (C_56 C_104) resistor r=6.30933
    rC_132 (C_56 C_74) resistor r=1.63969
    rC_131 (C_56 C_82) resistor r=4.16253
    rC_130 (C_56 C_113) resistor r=4.16253
    rC_129 (C_56 C_77) resistor r=24.8333
    rC_128 (C_56 C_74) resistor r=24.8333
    rC_127 (C_56 C_85) resistor r=24.8333
    rC_126 (C_56 C_82) resistor r=24.8333
    rC_125 (C_56 C_332) resistor r=40.975
    rC_124 (C_56 C_104) resistor r=14.9
    rC_123 (C_56 C_110) resistor r=202.392
    rC_122 (C_56 MMI3_g) resistor r=7.45
    rC_121 (C_56 C_77) resistor r=4.16253
    rC_120 (C_56 C_85) resistor r=4.16253
    rC_119 (C_56 C_110) resistor r=6.30933
    rC_118 (C_56 C_104) resistor r=6.30933
    rC_117 (C_56 C_74) resistor r=1.63969
    rC_116 (C_56 C_82) resistor r=4.16253
    rC_115 (C_56 C_113) resistor r=4.16253
    rC_114 (C_93 MMI5_g) resistor r=36.0083
    rC_113 (C_113 MMI3_g) resistor r=194.942
    rC_112 (C_118 C_124) resistor r=58.3583
    rC_111 (C_118 C_124) resistor r=4.16253
    rC_110 (C_118 C_124) resistor r=58.3583
    rC_109 (C_118 C_124) resistor r=4.16253
    rC_108 (C_121 C_124) resistor r=58.3583
    rC_107 (C_121 C_124) resistor r=6.30933
    rC_106 (C_121 C_124) resistor r=58.3583
    rC_105 (C_121 C_124) resistor r=6.30933
    rC_104 (C_124 C_126) resistor r=14.9
    rC_103 (C_124 C_149) resistor r=24.8333
    rC_102 (C_124 C_146) resistor r=24.8333
    rC_101 (C_124 C_157) resistor r=24.8333
    rC_100 (C_124 C_154) resistor r=24.8333
    rC_99 (C_124 C_178) resistor r=58.3583
    rC_98 (C_124 C_181) resistor r=58.3583
    rC_97 (C_124 C_149) resistor r=4.16253
    rC_96 (C_124 C_126) resistor r=6.30933
    rC_95 (C_124 C_157) resistor r=1.63969
    rC_94 (C_124 C_146) resistor r=4.16253
    rC_93 (C_124 C_178) resistor r=4.16253
    rC_92 (C_124 C_154) resistor r=4.16253
    rC_91 (C_124 C_181) resistor r=4.16253
    rC_90 (C_124 C_126) resistor r=14.9
    rC_89 (C_124 C_344) resistor r=40.975
    rC_88 (C_124 C_149) resistor r=24.8333
    rC_87 (C_124 C_146) resistor r=24.8333
    rC_86 (C_124 C_157) resistor r=24.8333
    rC_85 (C_124 C_154) resistor r=24.8333
    rC_84 (C_124 C_178) resistor r=58.3583
    rC_83 (C_124 MM1_g) resistor r=7.45
    rC_82 (C_124 C_149) resistor r=4.16253
    rC_81 (C_124 C_126) resistor r=6.30933
    rC_80 (C_124 C_157) resistor r=1.63969
    rC_79 (C_124 C_146) resistor r=4.16253
    rC_78 (C_124 C_178) resistor r=4.16253
    rC_77 (C_124 C_154) resistor r=4.16253
    rC_76 (C_124 C_181) resistor r=4.16253
    rC_75 (C_132 C_135) resistor r=14.9
    rC_74 (C_132 C_135) resistor r=6.30933
    rC_73 (C_132 C_135) resistor r=14.9
    rC_72 (C_132 C_135) resistor r=6.30933
    rC_71 (C_135 C_138) resistor r=202.392
    rC_70 (C_135 C_141) resistor r=202.392
    rC_69 (C_135 C_165) resistor r=24.8333
    rC_68 (C_135 C_162) resistor r=24.8333
    rC_67 (C_135 C_173) resistor r=24.8333
    rC_66 (C_135 C_170) resistor r=24.8333
    rC_65 (C_135 C_186) resistor r=202.392
    rC_64 (C_135 C_189) resistor r=202.392
    rC_63 (C_135 C_138) resistor r=6.30933
    rC_62 (C_135 C_165) resistor r=1.63969
    rC_61 (C_135 C_173) resistor r=4.16253
    rC_60 (C_135 C_141) resistor r=4.16253
    rC_59 (C_135 C_162) resistor r=4.16253
    rC_58 (C_135 C_186) resistor r=4.16253
    rC_57 (C_135 C_170) resistor r=4.16253
    rC_56 (C_135 C_189) resistor r=4.16253
    rC_55 (C_135 C_346) resistor r=40.975
    rC_54 (C_135 C_138) resistor r=202.392
    rC_53 (C_135 C_141) resistor r=202.392
    rC_52 (C_135 C_165) resistor r=24.8333
    rC_51 (C_135 C_162) resistor r=24.8333
    rC_50 (C_135 C_173) resistor r=24.8333
    rC_49 (C_135 C_170) resistor r=24.8333
    rC_48 (C_135 C_186) resistor r=202.392
    rC_47 (C_135 MM0_g) resistor r=7.45
    rC_46 (C_135 C_138) resistor r=6.30933
    rC_45 (C_135 C_165) resistor r=1.63969
    rC_44 (C_135 C_173) resistor r=4.16253
    rC_43 (C_135 C_141) resistor r=4.16253
    rC_42 (C_135 C_162) resistor r=4.16253
    rC_41 (C_135 C_186) resistor r=4.16253
    rC_40 (C_135 C_170) resistor r=4.16253
    rC_39 (C_135 C_189) resistor r=4.16253
    rC_38 (C_181 MM1_g) resistor r=50.9083
    rC_37 (C_189 MM0_g) resistor r=194.942
    rC_36 (C_330 C_381) resistor r=10.0997
    rC_35 (C_332 C_381) resistor r=10.0997
    rC_34 (C_344 C_387) resistor r=10.0997
    rC_33 (C_346 C_387) resistor r=10.0997
    rC_32 (C_380 C_381) resistor r=0.877078
    rC_31 (C_380 C_395) resistor r=10.1591
    rC_30 (C_386 C_387) resistor r=0.877078
    rC_29 (C_386 C_395) resistor r=38.6045
    rC_28 (C_395 C) resistor r=10
    rVDD_101 (MMU2_b MMU4_b) resistor r=0.01
    rVDD_100 (MMI3_b MMU4_b) resistor r=0.01
    rVDD_99 (MM0_b MMU4_b) resistor r=0.01
    rVDD_98 (MMI2_b MMU4_b) resistor r=0.01
    rVDD_97 (MMU5_b MMU4_b) resistor r=0.01
    rVDD_96 (MMU4_b VDD_41) resistor r=8.66667
    rVDD_95 (MMU4_b VDD_44) resistor r=8.66667
    rVDD_94 (MMU4_b VDD_47) resistor r=8.66667
    rVDD_93 (MMU4_b VDD_39) resistor r=33.76
    rVDD_92 (VDD_2 VDD_7) resistor r=0.114693
    rVDD_91 (VDD_2 VDD_50) resistor r=0.0221659
    rVDD_90 (VDD VDD_7) resistor r=0.102828
    rVDD_89 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_88 (VDD_8 VDD_24) resistor r=67.52
    rVDD_87 (VDD_9 VDD_18) resistor r=0.415624
    rVDD_86 (VDD_9 VDD_50) resistor r=0.0882796
    rVDD_85 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_84 (VDD_11 VDD_15) resistor r=0.702463
    rVDD_83 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_82 (VDD_15 VDD_18) resistor r=0.7116
    rVDD_81 (VDD_18 VDD_19) resistor r=8.66667
    rVDD_80 (VDD_19 MMU2_s) resistor r=0.850556
    rVDD_79 (VDD_19 MMU4_s) resistor r=0.850556
    rVDD_78 (VDD_19 VDD_76) resistor r=13.0961
    rVDD_77 (VDD_20 VDD_23) resistor r=0.0830533
    rVDD_76 (VDD_20 VDD_51) resistor r=0.0221659
    rVDD_75 (VDD_21 VDD_23) resistor r=0.0870082
    rVDD_74 (VDD_21 VDD_50) resistor r=0.0221659
    rVDD_73 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_72 (VDD_24 VDD_39) resistor r=67.52
    rVDD_71 (VDD_25 VDD_34) resistor r=0.415624
    rVDD_70 (VDD_25 VDD_51) resistor r=0.0882796
    rVDD_69 (VDD_27 VDD_35) resistor r=8.66667
    rVDD_68 (VDD_27 VDD_31) resistor r=0.702463
    rVDD_67 (VDD_31 VDD_35) resistor r=8.66667
    rVDD_66 (VDD_31 VDD_34) resistor r=0.7116
    rVDD_65 (VDD_34 VDD_35) resistor r=8.66667
    rVDD_64 (VDD_35 MMI3_s) resistor r=4.04518
    rVDD_63 (VDD_35 VDD_80) resistor r=4.04518
    rVDD_62 (VDD_35 MMU2_s) resistor r=4.04518
    rVDD_61 (VDD_35 VDD_78) resistor r=4.04518
    rVDD_60 (VDD_36 VDD_38) resistor r=0.118818
    rVDD_59 (VDD_36 VDD_51) resistor r=0.0221659
    rVDD_58 (VDD_38 VDD_39) resistor r=8.66667
    rVDD_57 (VDD_38 VDD_41) resistor r=0.237637
    rVDD_56 (VDD_41 VDD_44) resistor r=0.237637
    rVDD_55 (VDD_44 VDD_47) resistor r=0.237637
    rVDD_54 (VDD_54 VDD_57) resistor r=31.2341
    rVDD_53 (VDD_54 VDD_58) resistor r=9.04595
    rVDD_52 (VDD_55 VDD_57) resistor r=31.2341
    rVDD_51 (VDD_55 VDD_61) resistor r=9.04062
    rVDD_50 (MMU4_s VDD_57) resistor r=6.12113
    rVDD_49 (MMU4_s VDD_59) resistor r=12.3172
    rVDD_48 (MMU4_s VDD_59) resistor r=1.62887
    rVDD_47 (MMU4_s VDD_62) resistor r=2.55965
    rVDD_46 (VDD_58 VDD_59) resistor r=12.3172
    rVDD_45 (VDD_60 VDD_62) resistor r=14.4784
    rVDD_44 (VDD_60 VDD_77) resistor r=10.5593
    rVDD_43 (VDD_61 VDD_62) resistor r=14.4784
    rVDD_42 (MMU2_s VDD_66) resistor r=2.55965
    rVDD_41 (MMU2_s VDD_68) resistor r=12.3172
    rVDD_40 (MMU2_s VDD_68) resistor r=1.62887
    rVDD_39 (VDD_64 VDD_66) resistor r=14.4784
    rVDD_38 (VDD_64 VDD_81) resistor r=10.5593
    rVDD_37 (VDD_65 VDD_66) resistor r=14.4784
    rVDD_36 (VDD_65 VDD_77) resistor r=10.5593
    rVDD_35 (VDD_67 VDD_68) resistor r=12.3172
    rVDD_34 (VDD_67 VDD_79) resistor r=10.2363
    rVDD_33 (MMI3_s VDD_71) resistor r=12.3172
    rVDD_32 (MMI3_s VDD_71) resistor r=1.62887
    rVDD_31 (MMI3_s VDD_74) resistor r=2.55965
    rVDD_30 (MMI3_s VDD_75) resistor r=25.7298
    rVDD_29 (VDD_70 VDD_71) resistor r=12.3172
    rVDD_28 (VDD_70 VDD_79) resistor r=10.2363
    rVDD_27 (VDD_72 VDD_74) resistor r=14.4784
    rVDD_26 (VDD_72 VDD_75) resistor r=9.04062
    rVDD_25 (VDD_73 VDD_74) resistor r=14.4784
    rVDD_24 (VDD_73 VDD_81) resistor r=10.5593
    rVDD_23 (VDD_76 VDD_77) resistor r=0.730683
    rVDD_22 (VDD_78 VDD_79) resistor r=0.549089
    rVDD_21 (VDD_80 VDD_81) resistor r=0.730683
    rVSS_90 (MMI4_b MMU9_b) resistor r=0.01
    rVSS_89 (MMI5_b MMU9_b) resistor r=0.01
    rVSS_88 (MM1_b MMU9_b) resistor r=0.01
    rVSS_87 (MMU6_b MMU9_b) resistor r=0.01
    rVSS_86 (MMI1_b MMU9_b) resistor r=0.01
    rVSS_85 (MMU9_b VSS_29) resistor r=8.66667
    rVSS_84 (MMU9_b VSS_32) resistor r=8.66667
    rVSS_83 (MMU9_b VSS_35) resistor r=8.66667
    rVSS_82 (MMU9_b VSS_27) resistor r=32.3614
    rVSS_81 (VSS_2 VSS_7) resistor r=0.114693
    rVSS_80 (VSS_2 VSS_38) resistor r=0.0221659
    rVSS_79 (VSS VSS_7) resistor r=0.10085
    rVSS_78 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_77 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_76 (VSS_9 VSS_11) resistor r=0.468669
    rVSS_75 (VSS_9 VSS_38) resistor r=0.0882796
    rVSS_74 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_73 (VSS_12 MMI4_s) resistor r=2.27123
    rVSS_72 (VSS_12 MMU9_s) resistor r=2.27123
    rVSS_71 (VSS_12 VSS_62) resistor r=8.4738
    rVSS_70 (VSS_14 VSS_17) resistor r=0.0830533
    rVSS_69 (VSS_14 VSS_39) resistor r=0.0221659
    rVSS_68 (VSS_15 VSS_17) resistor r=0.0870082
    rVSS_67 (VSS_15 VSS_38) resistor r=0.0221659
    rVSS_66 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_65 (VSS_18 VSS_27) resistor r=64.7228
    rVSS_64 (VSS_19 VSS_21) resistor r=0.468669
    rVSS_63 (VSS_19 VSS_39) resistor r=0.0882796
    rVSS_62 (VSS_21 VSS_22) resistor r=8.66667
    rVSS_61 (VSS_22 MMI5_s) resistor r=4.22001
    rVSS_60 (VSS_22 VSS_66) resistor r=4.22001
    rVSS_59 (VSS_22 MMI4_s) resistor r=4.22001
    rVSS_58 (VSS_22 VSS_64) resistor r=4.22001
    rVSS_57 (VSS_24 VSS_26) resistor r=0.118818
    rVSS_56 (VSS_24 VSS_39) resistor r=0.0221659
    rVSS_55 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_54 (VSS_26 VSS_29) resistor r=0.237637
    rVSS_53 (VSS_29 VSS_32) resistor r=0.237637
    rVSS_52 (VSS_32 VSS_35) resistor r=0.237637
    rVSS_51 (VSS_40 VSS_43) resistor r=21.1301
    rVSS_50 (VSS_40 VSS_45) resistor r=9.43134
    rVSS_49 (VSS_41 VSS_43) resistor r=21.1301
    rVSS_48 (VSS_41 VSS_47) resistor r=9.4369
    rVSS_47 (MMU9_s VSS_43) resistor r=4.557
    rVSS_46 (MMU9_s VSS_46) resistor r=2.67027
    rVSS_45 (MMU9_s VSS_48) resistor r=12.8495
    rVSS_44 (MMU9_s VSS_48) resistor r=1.69926
    rVSS_43 (VSS_44 VSS_46) resistor r=15.1041
    rVSS_42 (VSS_44 VSS_63) resistor r=11.0157
    rVSS_41 (VSS_45 VSS_46) resistor r=15.1041
    rVSS_40 (VSS_47 VSS_48) resistor r=12.8495
    rVSS_39 (MMI4_s VSS_52) resistor r=2.67027
    rVSS_38 (MMI4_s VSS_54) resistor r=12.8495
    rVSS_37 (MMI4_s VSS_54) resistor r=1.69926
    rVSS_36 (VSS_50 VSS_52) resistor r=15.1041
    rVSS_35 (VSS_50 VSS_65) resistor r=11.0157
    rVSS_34 (VSS_51 VSS_52) resistor r=15.1041
    rVSS_33 (VSS_51 VSS_63) resistor r=11.0157
    rVSS_32 (VSS_53 VSS_54) resistor r=12.8495
    rVSS_31 (VSS_53 VSS_67) resistor r=10.6787
    rVSS_30 (MMI5_s VSS_58) resistor r=2.67027
    rVSS_29 (MMI5_s VSS_60) resistor r=12.8495
    rVSS_28 (MMI5_s VSS_60) resistor r=1.69926
    rVSS_27 (MMI5_s VSS_61) resistor r=18.0507
    rVSS_26 (VSS_56 VSS_58) resistor r=15.1041
    rVSS_25 (VSS_56 VSS_61) resistor r=9.43134
    rVSS_24 (VSS_57 VSS_58) resistor r=15.1041
    rVSS_23 (VSS_57 VSS_65) resistor r=11.0157
    rVSS_22 (VSS_59 VSS_60) resistor r=12.8495
    rVSS_21 (VSS_59 VSS_67) resistor r=10.6787
    rVSS_20 (VSS_62 VSS_63) resistor r=0.762262
    rVSS_19 (VSS_64 VSS_65) resistor r=0.762262
    rVSS_18 (VSS_66 VSS_67) resistor r=0.57282
    rnet28_46 (net28_1 net28_3) resistor r=0.632217
    rnet28_45 (net28_1 net28_21) resistor r=0.0582836
    rnet28_44 (net28_3 net28_4) resistor r=8.66667
    rnet28_43 (net28_4 MMU2_d) resistor r=32.3614
    rnet28_42 (net28_6 net28_8) resistor r=0.0936617
    rnet28_41 (net28_6 net28_22) resistor r=0.0582836
    rnet28_40 (net28_8 net28_9) resistor r=26
    rnet28_39 (net28_9 net28_42) resistor r=32.3614
    rnet28_38 (net28_11 net28_13) resistor r=0.632217
    rnet28_37 (net28_11 net28_23) resistor r=0.0582836
    rnet28_36 (net28_13 net28_14) resistor r=8.66667
    rnet28_35 (net28_14 MMI2_s) resistor r=32.3614
    rnet28_34 (net28_16 net28_18) resistor r=0.0936617
    rnet28_33 (net28_16 net28_24) resistor r=0.0582836
    rnet28_32 (net28_18 net28_19) resistor r=26
    rnet28_31 (net28_19 net28_51) resistor r=32.3614
    rnet28_30 (net28_21 net28_43) resistor r=0.0115455
    rnet28_29 (net28_22 net28_43) resistor r=0.311729
    rnet28_28 (net28_23 net28) resistor r=0.0115455
    rnet28_27 (net28_24 net28) resistor r=0.311729
    rnet28_26 (net28_25 net28_27) resistor r=0.342335
    rnet28_25 (net28_25 net28_31) resistor r=0.0764339
    rnet28_24 (net28_27 net28_43) resistor r=0.75
    rnet28_23 (net28_30 net28_31) resistor r=1.26042
    rnet28_22 (net28_30 net28_32) resistor r=0.0764339
    rnet28_21 (net28_32 net28_34) resistor r=0.342335
    rnet28_20 (net28_34 net28) resistor r=0.75
    rnet28_19 (MMU2_d net28_42) resistor r=16.1807
    rnet28_18 (net28_42 net28_43) resistor r=8.66667
    rnet28_17 (MMI2_s net28_51) resistor r=16.1807
    rnet28_16 (net28_51 net28) resistor r=8.66667
    rnet13_27 (MMU6_s net13) resistor r=0.01
    rnet13_26 (net13_5 net13_7) resistor r=0.0900221
    rnet13_25 (net13_5 net13_19) resistor r=0.0421804
    rnet13_24 (net13_7 net13_8) resistor r=13
    rnet13_23 (net13_8 net13) resistor r=8.44
    rnet13_22 (net13_9 net13_11) resistor r=0.186728
    rnet13_21 (net13_9 net13_15) resistor r=0.0764339
    rnet13_20 (net13_11 net13_12) resistor r=0.75
    rnet13_19 (net13_12 net13_27) resistor r=13
    rnet13_18 (net13_14 net13_15) resistor r=1.37342
    rnet13_17 (net13_14 net13_21) resistor r=0.0764339
    rnet13_16 (net13_16 net13_18) resistor r=0.0423896
    rnet13_15 (net13_16 net13_25) resistor r=0.0579271
    rnet13_14 (net13_18 net13_19) resistor r=0.75
    rnet13_13 (net13_21 net13_22) resistor r=0.136156
    rnet13_12 (net13_22 net13_25) resistor r=0.0150543
    rnet13_11 (net13_27 MMI4_d) resistor r=8.44
    rB_208 (B_42 B_48) resistor r=58.3583
    rB_207 (B_42 B_48) resistor r=4.16253
    rB_206 (B_42 B_48) resistor r=58.3583
    rB_205 (B_42 B_48) resistor r=4.16253
    rB_204 (B_45 B_48) resistor r=58.3583
    rB_203 (B_45 B_48) resistor r=6.30933
    rB_202 (B_45 B_48) resistor r=58.3583
    rB_201 (B_45 B_48) resistor r=6.30933
    rB_200 (B_48 B_50) resistor r=14.9
    rB_199 (B_48 B_73) resistor r=24.8333
    rB_198 (B_48 B_70) resistor r=24.8333
    rB_197 (B_48 B_81) resistor r=24.8333
    rB_196 (B_48 B_78) resistor r=24.8333
    rB_195 (B_48 B_102) resistor r=58.3583
    rB_194 (B_48 B_105) resistor r=58.3583
    rB_193 (B_48 B_73) resistor r=4.16253
    rB_192 (B_48 B_50) resistor r=6.30933
    rB_191 (B_48 B_81) resistor r=1.63969
    rB_190 (B_48 B_70) resistor r=4.16253
    rB_189 (B_48 B_102) resistor r=4.16253
    rB_188 (B_48 B_78) resistor r=4.16253
    rB_187 (B_48 B_105) resistor r=4.16253
    rB_186 (B_48 B_50) resistor r=14.9
    rB_185 (B_48 B_321) resistor r=40.975
    rB_184 (B_48 B_73) resistor r=24.8333
    rB_183 (B_48 B_70) resistor r=24.8333
    rB_182 (B_48 B_81) resistor r=24.8333
    rB_181 (B_48 B_78) resistor r=24.8333
    rB_180 (B_48 B_102) resistor r=58.3583
    rB_179 (B_48 MMI4_g) resistor r=7.45
    rB_178 (B_48 B_73) resistor r=4.16253
    rB_177 (B_48 B_50) resistor r=6.30933
    rB_176 (B_48 B_81) resistor r=1.63969
    rB_175 (B_48 B_70) resistor r=4.16253
    rB_174 (B_48 B_102) resistor r=4.16253
    rB_173 (B_48 B_78) resistor r=4.16253
    rB_172 (B_48 B_105) resistor r=4.16253
    rB_171 (B_56 B_59) resistor r=14.9
    rB_170 (B_56 B_59) resistor r=6.30933
    rB_169 (B_56 B_59) resistor r=14.9
    rB_168 (B_56 B_59) resistor r=6.30933
    rB_167 (B_59 B_62) resistor r=202.392
    rB_166 (B_59 B_65) resistor r=202.392
    rB_165 (B_59 B_89) resistor r=24.8333
    rB_164 (B_59 B_86) resistor r=24.8333
    rB_163 (B_59 B_97) resistor r=24.8333
    rB_162 (B_59 B_94) resistor r=24.8333
    rB_161 (B_59 B_110) resistor r=202.392
    rB_160 (B_59 B_113) resistor r=202.392
    rB_159 (B_59 B_62) resistor r=6.30933
    rB_158 (B_59 B_89) resistor r=1.63969
    rB_157 (B_59 B_97) resistor r=4.16253
    rB_156 (B_59 B_65) resistor r=4.16253
    rB_155 (B_59 B_86) resistor r=4.16253
    rB_154 (B_59 B_110) resistor r=4.16253
    rB_153 (B_59 B_94) resistor r=4.16253
    rB_152 (B_59 B_113) resistor r=4.16253
    rB_151 (B_59 B_323) resistor r=40.975
    rB_150 (B_59 B_62) resistor r=202.392
    rB_149 (B_59 B_65) resistor r=202.392
    rB_148 (B_59 B_89) resistor r=24.8333
    rB_147 (B_59 B_86) resistor r=24.8333
    rB_146 (B_59 B_97) resistor r=24.8333
    rB_145 (B_59 B_94) resistor r=24.8333
    rB_144 (B_59 B_110) resistor r=202.392
    rB_143 (B_59 MMU2_g) resistor r=7.45
    rB_142 (B_59 B_62) resistor r=6.30933
    rB_141 (B_59 B_89) resistor r=1.63969
    rB_140 (B_59 B_97) resistor r=4.16253
    rB_139 (B_59 B_65) resistor r=4.16253
    rB_138 (B_59 B_86) resistor r=4.16253
    rB_137 (B_59 B_110) resistor r=4.16253
    rB_136 (B_59 B_94) resistor r=4.16253
    rB_135 (B_59 B_113) resistor r=4.16253
    rB_134 (B_105 MMI4_g) resistor r=50.9083
    rB_133 (B_113 MMU2_g) resistor r=194.942
    rB_132 (B_118 B_124) resistor r=58.3583
    rB_131 (B_118 B_124) resistor r=4.16253
    rB_130 (B_118 B_124) resistor r=58.3583
    rB_129 (B_118 B_124) resistor r=4.16253
    rB_128 (B_121 B_124) resistor r=58.3583
    rB_127 (B_121 B_124) resistor r=6.30933
    rB_126 (B_121 B_124) resistor r=58.3583
    rB_125 (B_121 B_124) resistor r=6.30933
    rB_124 (B_124 B_126) resistor r=14.9
    rB_123 (B_124 B_149) resistor r=24.8333
    rB_122 (B_124 B_146) resistor r=24.8333
    rB_121 (B_124 B_157) resistor r=24.8333
    rB_120 (B_124 B_154) resistor r=24.8333
    rB_119 (B_124 B_178) resistor r=58.3583
    rB_118 (B_124 B_181) resistor r=58.3583
    rB_117 (B_124 B_149) resistor r=4.16253
    rB_116 (B_124 B_126) resistor r=6.30933
    rB_115 (B_124 B_157) resistor r=1.63969
    rB_114 (B_124 B_146) resistor r=4.16253
    rB_113 (B_124 B_178) resistor r=4.16253
    rB_112 (B_124 B_154) resistor r=4.16253
    rB_111 (B_124 B_181) resistor r=4.16253
    rB_110 (B_124 B_126) resistor r=14.9
    rB_109 (B_124 B_355) resistor r=40.975
    rB_108 (B_124 B_149) resistor r=24.8333
    rB_107 (B_124 B_146) resistor r=24.8333
    rB_106 (B_124 B_157) resistor r=24.8333
    rB_105 (B_124 B_154) resistor r=24.8333
    rB_104 (B_124 B_178) resistor r=58.3583
    rB_103 (B_124 MMI1_g) resistor r=7.45
    rB_102 (B_124 B_149) resistor r=4.16253
    rB_101 (B_124 B_126) resistor r=6.30933
    rB_100 (B_124 B_157) resistor r=1.63969
    rB_99 (B_124 B_146) resistor r=4.16253
    rB_98 (B_124 B_178) resistor r=4.16253
    rB_97 (B_124 B_154) resistor r=4.16253
    rB_96 (B_124 B_181) resistor r=4.16253
    rB_95 (B_132 B_135) resistor r=14.9
    rB_94 (B_132 B_135) resistor r=6.30933
    rB_93 (B_132 B_135) resistor r=14.9
    rB_92 (B_132 B_135) resistor r=6.30933
    rB_91 (B_135 B_138) resistor r=202.392
    rB_90 (B_135 B_141) resistor r=202.392
    rB_89 (B_135 B_165) resistor r=24.8333
    rB_88 (B_135 B_162) resistor r=24.8333
    rB_87 (B_135 B_173) resistor r=24.8333
    rB_86 (B_135 B_170) resistor r=24.8333
    rB_85 (B_135 B_186) resistor r=202.392
    rB_84 (B_135 B_189) resistor r=202.392
    rB_83 (B_135 B_138) resistor r=6.30933
    rB_82 (B_135 B_165) resistor r=1.63969
    rB_81 (B_135 B_173) resistor r=4.16253
    rB_80 (B_135 B_141) resistor r=4.16253
    rB_79 (B_135 B_162) resistor r=4.16253
    rB_78 (B_135 B_186) resistor r=4.16253
    rB_77 (B_135 B_170) resistor r=4.16253
    rB_76 (B_135 B_189) resistor r=4.16253
    rB_75 (B_135 B_357) resistor r=40.975
    rB_74 (B_135 B_138) resistor r=202.392
    rB_73 (B_135 B_141) resistor r=202.392
    rB_72 (B_135 B_165) resistor r=24.8333
    rB_71 (B_135 B_162) resistor r=24.8333
    rB_70 (B_135 B_173) resistor r=24.8333
    rB_69 (B_135 B_170) resistor r=24.8333
    rB_68 (B_135 B_186) resistor r=202.392
    rB_67 (B_135 MMU5_g) resistor r=7.45
    rB_66 (B_135 B_138) resistor r=6.30933
    rB_65 (B_135 B_165) resistor r=1.63969
    rB_64 (B_135 B_173) resistor r=4.16253
    rB_63 (B_135 B_141) resistor r=4.16253
    rB_62 (B_135 B_162) resistor r=4.16253
    rB_61 (B_135 B_186) resistor r=4.16253
    rB_60 (B_135 B_170) resistor r=4.16253
    rB_59 (B_135 B_189) resistor r=4.16253
    rB_58 (B_181 MMI1_g) resistor r=50.9083
    rB_57 (B_189 MMU5_g) resistor r=194.942
    rB_56 (B_261 B_263) resistor r=0.170787
    rB_55 (B_261 B_267) resistor r=0.0764339
    rB_54 (B_263 B_264) resistor r=0.75
    rB_53 (B_264 B_406) resistor r=10
    rB_52 (B_264 B) resistor r=0.0491194
    rB_51 (B_266 B_267) resistor r=0.116705
    rB_50 (B_266 B_269) resistor r=0.0764339
    rB_49 (B_268 B_269) resistor r=1.38877
    rB_48 (B_268 B_270) resistor r=0.0764339
    rB_47 (B_270 B_271) resistor r=0.116705
    rB_46 (B_271 B_275) resistor r=0.0382169
    rB_45 (B_275 B_276) resistor r=0.75
    rB_44 (B_276 B_410) resistor r=10
    rB_43 (B_321 B_388) resistor r=10.0997
    rB_42 (B_323 B_388) resistor r=10.0997
    rB_41 (B_355 B_398) resistor r=10.0997
    rB_40 (B_357 B_398) resistor r=10.0997
    rB_39 (B_387 B_388) resistor r=0.877078
    rB_38 (B_387 B_406) resistor r=11.5136
    rB_37 (B_397 B_398) resistor r=0.877078
    rB_36 (B_397 B_410) resistor r=23.0273
    rA_206 (A_42 A_48) resistor r=58.3583
    rA_205 (A_42 A_48) resistor r=4.16253
    rA_204 (A_42 A_48) resistor r=58.3583
    rA_203 (A_42 A_48) resistor r=4.16253
    rA_202 (A_45 A_48) resistor r=58.3583
    rA_201 (A_45 A_48) resistor r=4.16253
    rA_200 (A_45 A_48) resistor r=58.3583
    rA_199 (A_45 A_48) resistor r=4.16253
    rA_198 (A_48 A_61) resistor r=24.8333
    rA_197 (A_48 A_58) resistor r=24.8333
    rA_196 (A_48 A_69) resistor r=24.8333
    rA_195 (A_48 A_66) resistor r=24.8333
    rA_194 (A_48 A_90) resistor r=58.3583
    rA_193 (A_48 A_93) resistor r=58.3583
    rA_192 (A_48 A_98) resistor r=14.9
    rA_191 (A_48 A_61) resistor r=4.16253
    rA_190 (A_48 A_69) resistor r=4.16253
    rA_189 (A_48 A_58) resistor r=4.16253
    rA_188 (A_48 A_90) resistor r=4.16253
    rA_187 (A_48 A_98) resistor r=6.30933
    rA_186 (A_48 A_93) resistor r=6.30933
    rA_185 (A_48 A_66) resistor r=1.63969
    rA_184 (A_48 A_61) resistor r=24.8333
    rA_183 (A_48 A_58) resistor r=24.8333
    rA_182 (A_48 A_69) resistor r=24.8333
    rA_181 (A_48 A_66) resistor r=24.8333
    rA_180 (A_48 A_90) resistor r=58.3583
    rA_179 (A_48 MMU9_g) resistor r=22.35
    rA_178 (A_48 A_98) resistor r=14.9
    rA_177 (A_48 A_341) resistor r=40.975
    rA_176 (A_48 A_61) resistor r=4.16253
    rA_175 (A_48 A_69) resistor r=4.16253
    rA_174 (A_48 A_58) resistor r=4.16253
    rA_173 (A_48 A_90) resistor r=4.16253
    rA_172 (A_48 A_98) resistor r=6.30933
    rA_171 (A_48 A_93) resistor r=6.30933
    rA_170 (A_48 A_66) resistor r=1.63969
    rA_169 (A_50 A_56) resistor r=202.392
    rA_168 (A_50 A_56) resistor r=4.16253
    rA_167 (A_50 A_56) resistor r=202.392
    rA_166 (A_50 A_56) resistor r=4.16253
    rA_165 (A_53 A_56) resistor r=202.392
    rA_164 (A_53 A_56) resistor r=4.16253
    rA_163 (A_53 A_56) resistor r=202.392
    rA_162 (A_53 A_56) resistor r=4.16253
    rA_161 (A_56 A_77) resistor r=24.8333
    rA_160 (A_56 A_74) resistor r=24.8333
    rA_159 (A_56 A_85) resistor r=24.8333
    rA_158 (A_56 A_82) resistor r=24.8333
    rA_157 (A_56 A_104) resistor r=14.9
    rA_156 (A_56 A_110) resistor r=202.392
    rA_155 (A_56 A_113) resistor r=202.392
    rA_154 (A_56 A_77) resistor r=4.16253
    rA_153 (A_56 A_85) resistor r=4.16253
    rA_152 (A_56 A_110) resistor r=6.30933
    rA_151 (A_56 A_104) resistor r=6.30933
    rA_150 (A_56 A_74) resistor r=1.63969
    rA_149 (A_56 A_82) resistor r=4.16253
    rA_148 (A_56 A_113) resistor r=4.16253
    rA_147 (A_56 A_77) resistor r=24.8333
    rA_146 (A_56 A_74) resistor r=24.8333
    rA_145 (A_56 A_85) resistor r=24.8333
    rA_144 (A_56 A_82) resistor r=24.8333
    rA_143 (A_56 A_343) resistor r=40.975
    rA_142 (A_56 A_104) resistor r=14.9
    rA_141 (A_56 A_110) resistor r=202.392
    rA_140 (A_56 MMU4_g) resistor r=7.45
    rA_139 (A_56 A_77) resistor r=4.16253
    rA_138 (A_56 A_85) resistor r=4.16253
    rA_137 (A_56 A_110) resistor r=6.30933
    rA_136 (A_56 A_104) resistor r=6.30933
    rA_135 (A_56 A_74) resistor r=1.63969
    rA_134 (A_56 A_82) resistor r=4.16253
    rA_133 (A_56 A_113) resistor r=4.16253
    rA_132 (A_93 MMU9_g) resistor r=36.0083
    rA_131 (A_113 MMU4_g) resistor r=194.942
    rA_130 (A_118 A_124) resistor r=58.3583
    rA_129 (A_118 A_124) resistor r=4.16253
    rA_128 (A_118 A_124) resistor r=58.3583
    rA_127 (A_118 A_124) resistor r=4.16253
    rA_126 (A_121 A_124) resistor r=58.3583
    rA_125 (A_121 A_124) resistor r=6.30933
    rA_124 (A_121 A_124) resistor r=58.3583
    rA_123 (A_121 A_124) resistor r=6.30933
    rA_122 (A_124 A_126) resistor r=14.9
    rA_121 (A_124 A_149) resistor r=24.8333
    rA_120 (A_124 A_146) resistor r=24.8333
    rA_119 (A_124 A_157) resistor r=24.8333
    rA_118 (A_124 A_154) resistor r=24.8333
    rA_117 (A_124 A_178) resistor r=58.3583
    rA_116 (A_124 A_181) resistor r=58.3583
    rA_115 (A_124 A_149) resistor r=4.16253
    rA_114 (A_124 A_126) resistor r=6.30933
    rA_113 (A_124 A_157) resistor r=1.63969
    rA_112 (A_124 A_146) resistor r=4.16253
    rA_111 (A_124 A_178) resistor r=4.16253
    rA_110 (A_124 A_154) resistor r=4.16253
    rA_109 (A_124 A_181) resistor r=4.16253
    rA_108 (A_124 A_126) resistor r=14.9
    rA_107 (A_124 A_355) resistor r=40.975
    rA_106 (A_124 A_149) resistor r=24.8333
    rA_105 (A_124 A_146) resistor r=24.8333
    rA_104 (A_124 A_157) resistor r=24.8333
    rA_103 (A_124 A_154) resistor r=24.8333
    rA_102 (A_124 A_178) resistor r=58.3583
    rA_101 (A_124 MMU6_g) resistor r=7.45
    rA_100 (A_124 A_149) resistor r=4.16253
    rA_99 (A_124 A_126) resistor r=6.30933
    rA_98 (A_124 A_157) resistor r=1.63969
    rA_97 (A_124 A_146) resistor r=4.16253
    rA_96 (A_124 A_178) resistor r=4.16253
    rA_95 (A_124 A_154) resistor r=4.16253
    rA_94 (A_124 A_181) resistor r=4.16253
    rA_93 (A_132 A_135) resistor r=14.9
    rA_92 (A_132 A_135) resistor r=6.30933
    rA_91 (A_132 A_135) resistor r=14.9
    rA_90 (A_132 A_135) resistor r=6.30933
    rA_89 (A_135 A_138) resistor r=202.392
    rA_88 (A_135 A_141) resistor r=202.392
    rA_87 (A_135 A_165) resistor r=24.8333
    rA_86 (A_135 A_162) resistor r=24.8333
    rA_85 (A_135 A_173) resistor r=24.8333
    rA_84 (A_135 A_170) resistor r=24.8333
    rA_83 (A_135 A_186) resistor r=202.392
    rA_82 (A_135 A_189) resistor r=202.392
    rA_81 (A_135 A_138) resistor r=6.30933
    rA_80 (A_135 A_165) resistor r=1.63969
    rA_79 (A_135 A_173) resistor r=4.16253
    rA_78 (A_135 A_141) resistor r=4.16253
    rA_77 (A_135 A_162) resistor r=4.16253
    rA_76 (A_135 A_186) resistor r=4.16253
    rA_75 (A_135 A_170) resistor r=4.16253
    rA_74 (A_135 A_189) resistor r=4.16253
    rA_73 (A_135 A_357) resistor r=40.975
    rA_72 (A_135 A_138) resistor r=202.392
    rA_71 (A_135 A_141) resistor r=202.392
    rA_70 (A_135 A_165) resistor r=24.8333
    rA_69 (A_135 A_162) resistor r=24.8333
    rA_68 (A_135 A_173) resistor r=24.8333
    rA_67 (A_135 A_170) resistor r=24.8333
    rA_66 (A_135 A_186) resistor r=202.392
    rA_65 (A_135 MMI2_g) resistor r=7.45
    rA_64 (A_135 A_138) resistor r=6.30933
    rA_63 (A_135 A_165) resistor r=1.63969
    rA_62 (A_135 A_173) resistor r=4.16253
    rA_61 (A_135 A_141) resistor r=4.16253
    rA_60 (A_135 A_162) resistor r=4.16253
    rA_59 (A_135 A_186) resistor r=4.16253
    rA_58 (A_135 A_170) resistor r=4.16253
    rA_57 (A_135 A_189) resistor r=4.16253
    rA_56 (A_181 MMU6_g) resistor r=50.9083
    rA_55 (A_189 MMI2_g) resistor r=194.942
    rA_54 (A_261 A_263) resistor r=0.147826
    rA_53 (A_261 A_266) resistor r=0.0764339
    rA_52 (A_263 A) resistor r=0.75
    rA_51 (A_266 A_267) resistor r=0.116705
    rA_50 (A_267 A_269) resistor r=0.0764339
    rA_49 (A_268 A_269) resistor r=1.42922
    rA_48 (A_268 A_271) resistor r=0.0764339
    rA_47 (A_270 A_271) resistor r=0.116705
    rA_46 (A_270 A_275) resistor r=0.0382169
    rA_45 (A_275 A_276) resistor r=0.75
    rA_44 (A_276 A_410) resistor r=10
    rA_43 (A_341 A_392) resistor r=10.0997
    rA_42 (A_343 A_392) resistor r=10.0997
    rA_41 (A_355 A_398) resistor r=10.0997
    rA_40 (A_357 A_398) resistor r=10.0997
    rA_39 (A_391 A_392) resistor r=0.877078
    rA_38 (A_391 A_406) resistor r=41.3136
    rA_37 (A_397 A_398) resistor r=0.877078
    rA_36 (A_397 A_410) resistor r=33.1864
    rA_35 (A_406 A) resistor r=10
ends MAOI222BD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DDFSND1_LVT_ELT
// View name: calibre
subckt DDFSND1_LVT_ELT CP D Q Qn SDN VDD VSS
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.0725e-13 pd=1.34e-06 \
        ps=4.81e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18 (MM18_d MM18_g MM18_s MM18_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=3.0725e-13 as=9.4e-14 pd=4.81e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM24 (MM24_d MM24_g MM24_s MM24_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM22_ELT (MM22_ELT_d MM22_ELT_g MM22_ELT_s MM22_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.93575e-13 pd=3.66e-06 \
        ps=7.295e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.93575e-13 pd=3.66e-06 \
        ps=7.295e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=6.4365e-13 as=3.26e-13 pd=9.45e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM20_ELT (MM20_ELT_d MM20_ELT_g MM20_ELT_s MM20_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.4365e-13 pd=3.66e-06 \
        ps=9.45e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=1.55675e-12 pd=3.66e-06 \
        ps=1.037e-05 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM25_ELT (MM25_ELT_d MM25_ELT_g MM25_ELT_s MM25_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM21_ELT (MM21_ELT_d MM21_ELT_g MM21_ELT_s MM21_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciQ_8 (Q_3 VSS) capacitor c=4.75044e-17
    ciQ_7 (Q_4 VSS) capacitor c=1.11576e-16
    ciQ_6 (Q_8 VSS) capacitor c=1.72599e-16
    ciQ_5 (Q_9 VSS) capacitor c=3.29378e-16
    ciQ_4 (Q_17 VSS) capacitor c=2.27486e-17
    ciQ_3 (Q_18 VSS) capacitor c=1.22499e-17
    ciQ_2 (Q_19 VSS) capacitor c=2.12404e-17
    ciQ_1 (Q_20 VSS) capacitor c=6.36473e-18
    ciQ_0 (Q VSS) capacitor c=7.1093e-17
    ciQn_28 (Qn_22 VSS) capacitor c=4.28147e-18
    ciQn_27 (Qn_28 VSS) capacitor c=1.85531e-16
    ciQn_26 (Qn_39 VSS) capacitor c=5.68706e-16
    ciQn_25 (Qn_45 VSS) capacitor c=5.13601e-18
    ciQn_24 (Qn_50 VSS) capacitor c=2.23559e-17
    ciQn_23 (Qn_58 VSS) capacitor c=1.51948e-17
    ciQn_22 (Qn_66 VSS) capacitor c=1.91248e-17
    ciQn_21 (Qn_74 VSS) capacitor c=9.56216e-18
    ciQn_20 (Qn_82 VSS) capacitor c=2.11871e-18
    ciQn_19 (Qn_85 VSS) capacitor c=2.742e-18
    ciQn_18 (Qn_90 VSS) capacitor c=2.43312e-19
    ciQn_17 (Qn_93 VSS) capacitor c=2.22299e-18
    ciQn_16 (Qn_133 VSS) capacitor c=1.82057e-16
    ciQn_15 (Qn_140 VSS) capacitor c=2.38981e-16
    ciQn_14 (Qn_142 VSS) capacitor c=1.17356e-16
    ciQn_13 (Qn_143 VSS) capacitor c=1.62665e-17
    ciQn_12 (Qn_146 VSS) capacitor c=5.6444e-17
    ciQn_11 (Qn_147 VSS) capacitor c=1.13486e-16
    ciQn_10 (Qn_149 VSS) capacitor c=3.56322e-17
    ciQn_9 (Qn_150 VSS) capacitor c=1.45488e-17
    ciQn_8 (Qn_152 VSS) capacitor c=2.74577e-18
    ciQn_7 (Qn_154 VSS) capacitor c=2.69177e-18
    ciQn_6 (Qn VSS) capacitor c=3.28878e-17
    ciQn_5 (Qn_219 VSS) capacitor c=2.27233e-17
    ciQn_4 (Qn_220 VSS) capacitor c=1.65685e-17
    ciQn_3 (MM5_ELT_d VSS) capacitor c=2.42698e-17
    ciQn_2 (Qn_229 VSS) capacitor c=2.73847e-18
    ciQn_1 (Qn_231 VSS) capacitor c=4.99435e-18
    ciQn_0 (Qn_233 VSS) capacitor c=4.09201e-18
    ciVDD_47 (VDD_4 VSS) capacitor c=1.32641e-16
    ciVDD_46 (VDD_13 VSS) capacitor c=4.72262e-17
    ciVDD_45 (VDD_14 VSS) capacitor c=2.63453e-17
    ciVDD_44 (VDD_20 VSS) capacitor c=1.86501e-16
    ciVDD_43 (VDD_28 VSS) capacitor c=2.82937e-18
    ciVDD_42 (VDD_32 VSS) capacitor c=1.08787e-16
    ciVDD_41 (VDD_39 VSS) capacitor c=1.26584e-16
    ciVDD_40 (VDD_48 VSS) capacitor c=2.90753e-17
    ciVDD_39 (VDD_52 VSS) capacitor c=1.35117e-16
    ciVDD_38 (VDD_60 VSS) capacitor c=2.27964e-16
    ciVDD_37 (VDD_61 VSS) capacitor c=2.16039e-16
    ciVDD_36 (VDD_77 VSS) capacitor c=2.41386e-16
    ciVDD_35 (VDD_85 VSS) capacitor c=3.73171e-16
    ciVDD_34 (VDD_91 VSS) capacitor c=7.74035e-17
    ciVDD_33 (VDD_99 VSS) capacitor c=3.58509e-18
    ciVDD_32 (VDD_102 VSS) capacitor c=3.58509e-18
    ciVDD_31 (VDD_104 VSS) capacitor c=3.58509e-18
    ciVDD_30 (VDD_105 VSS) capacitor c=3.58509e-18
    ciVDD_29 (VDD_111 VSS) capacitor c=1.11099e-18
    ciVDD_28 (VDD_112 VSS) capacitor c=3.16638e-18
    ciVDD_27 (VDD_113 VSS) capacitor c=2.30804e-18
    ciVDD_26 (VDD_116 VSS) capacitor c=1.7339e-17
    ciVDD_25 (VDD_120 VSS) capacitor c=1.71175e-18
    ciVDD_24 (MM25_ELT_s VSS) capacitor c=3.97088e-18
    ciVDD_23 (VDD_123 VSS) capacitor c=1.64973e-18
    ciVDD_22 (VDD_124 VSS) capacitor c=1.54316e-18
    ciVDD_21 (VDD_126 VSS) capacitor c=3.87173e-18
    ciVDD_20 (VDD_127 VSS) capacitor c=5.53407e-18
    ciVDD_19 (VDD_128 VSS) capacitor c=1.64973e-18
    ciVDD_18 (VDD_131 VSS) capacitor c=9.86014e-18
    ciVDD_17 (MM9_ELT_s VSS) capacitor c=5.95907e-17
    ciVDD_16 (VDD_135 VSS) capacitor c=1.4893e-17
    ciVDD_15 (VDD_136 VSS) capacitor c=2.14428e-18
    ciVDD_14 (VDD_137 VSS) capacitor c=4.29012e-18
    ciVDD_13 (VDD_138 VSS) capacitor c=2.85581e-17
    ciVDD_12 (VDD_139 VSS) capacitor c=7.64664e-18
    ciVDD_11 (MM8_ELT_s VSS) capacitor c=3.39123e-17
    ciVDD_10 (VDD_143 VSS) capacitor c=1.68965e-18
    ciVDD_9 (VDD_144 VSS) capacitor c=4.4658e-18
    ciVDD_8 (VDD_146 VSS) capacitor c=7.91512e-18
    ciVDD_7 (VDD_150 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_151 VSS) capacitor c=8.79289e-18
    ciVDD_5 (VDD_152 VSS) capacitor c=1.07074e-18
    ciVDD_4 (VDD_155 VSS) capacitor c=2.18215e-17
    ciVDD_3 (VDD_156 VSS) capacitor c=2.16736e-16
    ciVDD_2 (VDD_161 VSS) capacitor c=1.03674e-17
    ciVDD_1 (VDD_174 VSS) capacitor c=8.55782e-17
    ciVDD_0 (VDD_176 VSS) capacitor c=7.91131e-17
    ciVSS_31 (VSS_4 VSS) capacitor c=6.09416e-17
    ciVSS_30 (VSS_10 VSS) capacitor c=6.99796e-17
    ciVSS_29 (VSS_11 VSS) capacitor c=2.63453e-17
    ciVSS_28 (VSS_17 VSS) capacitor c=1.00255e-16
    ciVSS_27 (VSS_23 VSS) capacitor c=4.54969e-16
    ciVSS_26 (VSS_42 VSS) capacitor c=8.5505e-17
    ciVSS_25 (VSS_43 VSS) capacitor c=7.72665e-19
    ciVSS_24 (VSS_48 VSS) capacitor c=4.6113e-17
    ciVSS_23 (VSS_55 VSS) capacitor c=7.74096e-17
    ciVSS_22 (VSS_56 VSS) capacitor c=1.17581e-16
    ciVSS_21 (VSS_63 VSS) capacitor c=7.57014e-17
    ciVSS_20 (VSS_71 VSS) capacitor c=7.90598e-18
    ciVSS_19 (VSS_73 VSS) capacitor c=3.58509e-18
    ciVSS_18 (VSS_74 VSS) capacitor c=3.58509e-18
    ciVSS_17 (VSS_76 VSS) capacitor c=3.28682e-18
    ciVSS_16 (VSS_78 VSS) capacitor c=1.82623e-18
    ciVSS_15 (VSS_79 VSS) capacitor c=2.45965e-18
    ciVSS_14 (VSS_80 VSS) capacitor c=1.93794e-18
    ciVSS_13 (VSS_83 VSS) capacitor c=2.83254e-18
    ciVSS_12 (VSS_85 VSS) capacitor c=1.9009e-18
    ciVSS_11 (VSS_86 VSS) capacitor c=9.2063e-19
    ciVSS_10 (VSS_87 VSS) capacitor c=5.16132e-18
    ciVSS_9 (VSS_92 VSS) capacitor c=5.32905e-18
    ciVSS_8 (MM2_ELT_s VSS) capacitor c=1.01201e-17
    ciVSS_7 (VSS_99 VSS) capacitor c=4.18216e-18
    ciVSS_6 (VSS_106 VSS) capacitor c=4.00531e-18
    ciVSS_5 (VSS_111 VSS) capacitor c=7.37737e-18
    ciVSS_4 (VSS_115 VSS) capacitor c=6.23788e-18
    ciVSS_3 (VSS_116 VSS) capacitor c=6.9763e-17
    ciVSS_2 (VSS_117 VSS) capacitor c=7.92472e-17
    ciVSS_1 (VSS_122 VSS) capacitor c=1.05582e-17
    ciVSS_0 (VSS_129 VSS) capacitor c=7.16435e-17
    cinet032_5 (net032_3 VSS) capacitor c=1.64999e-16
    cinet032_4 (net032_4 VSS) capacitor c=3.35331e-16
    cinet032_3 (net032_12 VSS) capacitor c=1.21924e-16
    cinet032_2 (net032_13 VSS) capacitor c=1.82509e-17
    cinet032_1 (net032_16 VSS) capacitor c=1.71063e-16
    cinet032_0 (net032_17 VSS) capacitor c=3.39271e-16
    cinet040_6 (net040_3 VSS) capacitor c=1.93977e-17
    cinet040_5 (net040_4 VSS) capacitor c=1.22414e-16
    cinet040_4 (net040_8 VSS) capacitor c=9.33486e-17
    cinet040_3 (net040_12 VSS) capacitor c=1.86458e-17
    cinet040_2 (net040_13 VSS) capacitor c=1.20813e-16
    cinet040_1 (net040_17 VSS) capacitor c=2.64771e-17
    cinet040_0 (net040_18 VSS) capacitor c=2.60836e-17
    cinet031_10 (net031_3 VSS) capacitor c=1.76323e-16
    cinet031_9 (net031_4 VSS) capacitor c=3.34356e-16
    cinet031_8 (net031_12 VSS) capacitor c=1.37646e-16
    cinet031_7 (net031_13 VSS) capacitor c=1.09184e-17
    cinet031_6 (net031_18 VSS) capacitor c=2.23158e-16
    cinet031_5 (net031_25 VSS) capacitor c=2.70533e-16
    cinet031_4 (net031_27 VSS) capacitor c=2.96482e-17
    cinet031_3 (MM20_ELT_s VSS) capacitor c=2.44489e-17
    cinet031_2 (net031_30 VSS) capacitor c=4.71422e-18
    cinet031_1 (net031_32 VSS) capacitor c=3.55661e-18
    cinet031_0 (net031_33 VSS) capacitor c=5.91682e-18
    ciSDN_28 (SDN_32 VSS) capacitor c=3.36617e-18
    ciSDN_27 (SDN_35 VSS) capacitor c=3.00043e-18
    ciSDN_26 (SDN_38 VSS) capacitor c=2.17697e-16
    ciSDN_25 (SDN_40 VSS) capacitor c=1.57877e-17
    ciSDN_24 (SDN_48 VSS) capacitor c=2.5998e-17
    ciSDN_23 (SDN_65 VSS) capacitor c=4.15066e-18
    ciSDN_22 (SDN_70 VSS) capacitor c=8.95667e-18
    ciSDN_21 (SDN_73 VSS) capacitor c=5.1954e-18
    ciSDN_20 (SDN_76 VSS) capacitor c=1.95595e-16
    ciSDN_19 (SDN_78 VSS) capacitor c=2.83705e-17
    ciSDN_18 (SDN_86 VSS) capacitor c=1.64585e-17
    ciSDN_17 (SDN_94 VSS) capacitor c=4.08613e-18
    ciSDN_16 (SDN_108 VSS) capacitor c=5.58192e-18
    ciSDN_15 (SDN_114 VSS) capacitor c=2.56142e-16
    ciSDN_14 (SDN_122 VSS) capacitor c=2.6555e-17
    ciSDN_13 (SDN_130 VSS) capacitor c=2.17416e-17
    ciSDN_12 (SDN_138 VSS) capacitor c=5.77728e-18
    ciSDN_11 (SDN_141 VSS) capacitor c=5.75347e-18
    ciSDN_10 (SDN_196 VSS) capacitor c=6.82968e-17
    ciSDN_9 (SDN_202 VSS) capacitor c=1.39051e-16
    ciSDN_8 (SDN_203 VSS) capacitor c=1.78952e-16
    ciSDN_7 (SDN_204 VSS) capacitor c=1.86067e-17
    ciSDN_6 (SDN_206 VSS) capacitor c=8.34283e-18
    ciSDN_5 (SDN_207 VSS) capacitor c=1.21414e-17
    ciSDN_4 (SDN_211 VSS) capacitor c=6.66423e-17
    ciSDN_3 (SDN_299 VSS) capacitor c=2.5003e-17
    ciSDN_2 (SDN_300 VSS) capacitor c=1.91208e-17
    ciSDN_1 (SDN_307 VSS) capacitor c=1.00939e-17
    ciSDN_0 (SDN_310 VSS) capacitor c=6.38476e-17
    cinet033_5 (net033_3 VSS) capacitor c=5.58751e-17
    cinet033_4 (net033_4 VSS) capacitor c=1.12162e-16
    cinet033_3 (net033_6 VSS) capacitor c=2.1846e-16
    cinet033_2 (net033_7 VSS) capacitor c=1.80507e-17
    cinet033_1 (net033_10 VSS) capacitor c=5.72133e-17
    cinet033_0 (net033_11 VSS) capacitor c=1.12968e-16
    cinet037_10 (net037_3 VSS) capacitor c=1.17974e-16
    cinet037_9 (net037_9 VSS) capacitor c=8.40105e-18
    cinet037_8 (net037_11 VSS) capacitor c=1.9009e-18
    cinet037_7 (net037_12 VSS) capacitor c=4.55538e-18
    cinet037_6 (net037_13 VSS) capacitor c=3.81689e-18
    cinet037_5 (net037_14 VSS) capacitor c=1.97184e-18
    cinet037_4 (MM24_d VSS) capacitor c=6.11988e-18
    cinet037_3 (net037_16 VSS) capacitor c=1.53279e-18
    cinet037_2 (net037_18 VSS) capacitor c=5.92123e-18
    cinet037_1 (net037_23 VSS) capacitor c=2.15678e-18
    cinet037_0 (net037 VSS) capacitor c=1.19599e-16
    ciX_16 (X_15 VSS) capacitor c=6.04223e-16
    ciX_15 (X_21 VSS) capacitor c=5.10099e-18
    ciX_14 (X_26 VSS) capacitor c=1.55461e-17
    ciX_13 (X_34 VSS) capacitor c=1.81836e-17
    ciX_12 (X_42 VSS) capacitor c=3.78384e-18
    ciX_11 (X_45 VSS) capacitor c=4.65558e-18
    ciX_10 (X_68 VSS) capacitor c=2.18586e-17
    ciX_9 (X_71 VSS) capacitor c=4.236e-17
    ciX_8 (X_72 VSS) capacitor c=4.6015e-17
    ciX_7 (X_73 VSS) capacitor c=1.38306e-17
    ciX_6 (X_78 VSS) capacitor c=2.39732e-17
    ciX_5 (X_81 VSS) capacitor c=4.86891e-17
    ciX_4 (X_82 VSS) capacitor c=1.1375e-16
    ciX_3 (X_85 VSS) capacitor c=4.06209e-17
    ciX_2 (X_86 VSS) capacitor c=1.38072e-16
    ciX_1 (X_89 VSS) capacitor c=2.82867e-17
    ciX_0 (X_118 VSS) capacitor c=4.23094e-17
    ciY_36 (Y_22 VSS) capacitor c=3.33747e-18
    ciY_35 (Y_28 VSS) capacitor c=1.9442e-16
    ciY_34 (Y_39 VSS) capacitor c=6.12148e-16
    ciY_33 (Y_45 VSS) capacitor c=6.9891e-18
    ciY_32 (Y_50 VSS) capacitor c=2.24663e-17
    ciY_31 (Y_58 VSS) capacitor c=1.9028e-17
    ciY_30 (Y_66 VSS) capacitor c=1.09431e-17
    ciY_29 (Y_74 VSS) capacitor c=2.12292e-17
    ciY_28 (Y_82 VSS) capacitor c=2.96874e-18
    ciY_27 (Y_85 VSS) capacitor c=5.8959e-18
    ciY_26 (Y_90 VSS) capacitor c=5.15427e-18
    ciY_25 (Y_93 VSS) capacitor c=3.85496e-18
    ciY_24 (Y_131 VSS) capacitor c=1.23904e-17
    ciY_23 (Y_133 VSS) capacitor c=7.5875e-17
    ciY_22 (Y_136 VSS) capacitor c=1.69651e-16
    ciY_21 (Y_141 VSS) capacitor c=1.23101e-16
    ciY_20 (Y_142 VSS) capacitor c=3.38745e-16
    ciY_19 (Y_146 VSS) capacitor c=1.16705e-16
    ciY_18 (Y_147 VSS) capacitor c=1.6531e-17
    ciY_17 (Y_149 VSS) capacitor c=2.53406e-18
    ciY_16 (Y_151 VSS) capacitor c=1.10412e-17
    ciY_15 (Y_154 VSS) capacitor c=1.22532e-16
    ciY_14 (Y_160 VSS) capacitor c=4.00001e-18
    ciY_13 (Y_161 VSS) capacitor c=1.7219e-17
    ciY_12 (Y_164 VSS) capacitor c=3.36161e-17
    ciY_11 (Y_165 VSS) capacitor c=8.25697e-17
    ciY_10 (Y_167 VSS) capacitor c=1.79592e-16
    ciY_9 (Y_168 VSS) capacitor c=1.14477e-17
    ciY_8 (Y_171 VSS) capacitor c=3.69701e-17
    ciY_7 (Y_172 VSS) capacitor c=3.00057e-17
    ciY_6 (Y_239 VSS) capacitor c=4.05535e-19
    ciY_5 (Y_240 VSS) capacitor c=8.6656e-19
    ciY_4 (Y_241 VSS) capacitor c=2.18055e-18
    ciY_3 (Y_246 VSS) capacitor c=6.7325e-18
    ciY_2 (Y_247 VSS) capacitor c=1.27015e-16
    ciY_1 (Y_250 VSS) capacitor c=3.87212e-17
    ciY_0 (Y_253 VSS) capacitor c=1.22668e-16
    ciD_14 (D_22 VSS) capacitor c=4.24577e-18
    ciD_13 (D_28 VSS) capacitor c=2.03391e-16
    ciD_12 (D_39 VSS) capacitor c=2.20986e-16
    ciD_11 (D_45 VSS) capacitor c=3.36617e-18
    ciD_10 (D_50 VSS) capacitor c=2.79853e-17
    ciD_9 (D_58 VSS) capacitor c=1.59328e-17
    ciD_8 (D_66 VSS) capacitor c=1.59411e-17
    ciD_7 (D_74 VSS) capacitor c=2.71823e-17
    ciD_6 (D_82 VSS) capacitor c=7.1697e-18
    ciD_5 (D_85 VSS) capacitor c=1.84089e-18
    ciD_4 (D_90 VSS) capacitor c=3.1332e-18
    ciD_3 (D_93 VSS) capacitor c=5.67168e-18
    ciD_2 (D_132 VSS) capacitor c=5.19065e-17
    ciD_1 (D_194 VSS) capacitor c=3.76653e-17
    ciD_0 (D_195 VSS) capacitor c=8.81848e-18
    ciCPN_48 (CPN_42 VSS) capacitor c=8.42816e-18
    ciCPN_47 (CPN_45 VSS) capacitor c=8.00794e-18
    ciCPN_46 (CPN_48 VSS) capacitor c=2.02817e-16
    ciCPN_45 (CPN_50 VSS) capacitor c=3.20049e-17
    ciCPN_44 (CPN_58 VSS) capacitor c=2.44308e-17
    ciCPN_43 (CPN_66 VSS) capacitor c=1.07785e-17
    ciCPN_42 (CPN_80 VSS) capacitor c=2.91116e-17
    ciCPN_41 (CPN_83 VSS) capacitor c=4.73887e-18
    ciCPN_40 (CPN_86 VSS) capacitor c=6.05537e-16
    ciCPN_39 (CPN_88 VSS) capacitor c=2.15368e-17
    ciCPN_38 (CPN_96 VSS) capacitor c=1.98115e-17
    ciCPN_37 (CPN_113 VSS) capacitor c=2.4684e-18
    ciCPN_36 (CPN_118 VSS) capacitor c=3.79776e-18
    ciCPN_35 (CPN_124 VSS) capacitor c=2.22403e-16
    ciCPN_34 (CPN_135 VSS) capacitor c=5.7837e-16
    ciCPN_33 (CPN_141 VSS) capacitor c=2.49431e-18
    ciCPN_32 (CPN_146 VSS) capacitor c=2.24263e-17
    ciCPN_31 (CPN_154 VSS) capacitor c=2.13373e-17
    ciCPN_30 (CPN_162 VSS) capacitor c=2.37014e-17
    ciCPN_29 (CPN_170 VSS) capacitor c=2.1965e-17
    ciCPN_28 (CPN_178 VSS) capacitor c=3.00043e-18
    ciCPN_27 (CPN_181 VSS) capacitor c=3.01767e-18
    ciCPN_26 (CPN_186 VSS) capacitor c=3.74481e-18
    ciCPN_25 (CPN_189 VSS) capacitor c=6.9891e-18
    ciCPN_24 (CPN_263 VSS) capacitor c=1.62296e-16
    ciCPN_23 (CPN_264 VSS) capacitor c=3.34246e-16
    ciCPN_22 (CPN_273 VSS) capacitor c=9.14308e-17
    ciCPN_21 (CPN_277 VSS) capacitor c=2.92142e-17
    ciCPN_20 (CPN_281 VSS) capacitor c=2.28249e-17
    ciCPN_19 (CPN_285 VSS) capacitor c=3.83352e-17
    ciCPN_18 (CPN_288 VSS) capacitor c=1.61493e-16
    ciCPN_17 (CPN_289 VSS) capacitor c=1.16064e-17
    ciCPN_16 (CPN_290 VSS) capacitor c=1.15374e-17
    ciCPN_15 (CPN_293 VSS) capacitor c=8.14982e-17
    ciCPN_14 (CPN_296 VSS) capacitor c=7.04397e-17
    ciCPN_13 (CPN_297 VSS) capacitor c=1.37782e-16
    ciCPN_12 (CPN_301 VSS) capacitor c=1.16068e-17
    ciCPN_11 (CPN_304 VSS) capacitor c=9.78013e-17
    ciCPN_10 (CPN_307 VSS) capacitor c=6.96729e-17
    ciCPN_9 (CPN_310 VSS) capacitor c=5.4755e-18
    ciCPN_8 (CPN_311 VSS) capacitor c=1.16102e-17
    ciCPN_7 (CPN_312 VSS) capacitor c=1.85795e-17
    ciCPN_6 (CPN_368 VSS) capacitor c=1.89845e-17
    ciCPN_5 (CPN_429 VSS) capacitor c=1.61506e-17
    ciCPN_4 (CPN_434 VSS) capacitor c=3.88576e-17
    ciCPN_3 (CPN_435 VSS) capacitor c=7.94553e-18
    ciCPN_2 (CPN_446 VSS) capacitor c=4.39381e-17
    ciCPN_1 (CPN_449 VSS) capacitor c=1.11545e-16
    ciCPN_0 (CPN_450 VSS) capacitor c=3.68654e-17
    ciCP_14 (CP_22 VSS) capacitor c=3.00043e-18
    ciCP_13 (CP_28 VSS) capacitor c=2.11855e-16
    ciCP_12 (CP_39 VSS) capacitor c=6.29612e-16
    ciCP_11 (CP_45 VSS) capacitor c=3.44142e-18
    ciCP_10 (CP_50 VSS) capacitor c=2.58559e-17
    ciCP_9 (CP_58 VSS) capacitor c=2.05252e-17
    ciCP_8 (CP_66 VSS) capacitor c=1.20988e-17
    ciCP_7 (CP_74 VSS) capacitor c=1.51948e-17
    ciCP_6 (CP_82 VSS) capacitor c=3.24866e-18
    ciCP_5 (CP_85 VSS) capacitor c=4.90087e-18
    ciCP_4 (CP_90 VSS) capacitor c=5.17514e-18
    ciCP_3 (CP_93 VSS) capacitor c=3.35294e-18
    ciCP_2 (CP VSS) capacitor c=4.27881e-17
    ciCP_1 (CP_196 VSS) capacitor c=3.13771e-17
    ciCP_0 (CP_197 VSS) capacitor c=1.42463e-17
    rQ_28 (Q_1 Q_3) resistor r=0.30383
    rQ_27 (Q_1 Q_18) resistor r=0.0961114
    rQ_26 (Q_3 Q_4) resistor r=13
    rQ_25 (Q_4 MM4_ELT_d) resistor r=8.44
    rQ_24 (Q_6 Q_8) resistor r=0.341142
    rQ_23 (Q_6 Q_20) resistor r=0.0961114
    rQ_22 (Q_8 Q_9) resistor r=8.66667
    rQ_21 (Q_8 Q_11) resistor r=0.639641
    rQ_20 (Q_9 MM7_ELT_d) resistor r=32.3614
    rQ_19 (Q_11 Q_12) resistor r=8.66667
    rQ_18 (Q_11 Q_14) resistor r=0.426428
    rQ_17 (Q_12 MM7_ELT_d) resistor r=16.1807
    rQ_16 (Q_12 Q_15) resistor r=32.3614
    rQ_15 (Q_14 Q_15) resistor r=26
    rQ_14 (Q_17 Q_18) resistor r=0.13666
    rQ_13 (Q_17 Q_21) resistor r=0.0961114
    rQ_12 (Q_19 Q_20) resistor r=0.13666
    rQ_11 (Q_19 Q_22) resistor r=0.0961114
    rQ_10 (Q_21 Q) resistor r=0.156183
    rQ_9 (Q_22 Q) resistor r=0.536371
    rQn_141 (Qn_22 Qn_28) resistor r=58.3583
    rQn_140 (Qn_22 Qn_28) resistor r=4.16253
    rQn_139 (Qn_22 Qn_28) resistor r=58.3583
    rQn_138 (Qn_22 Qn_28) resistor r=4.16253
    rQn_137 (Qn_25 Qn_28) resistor r=58.3583
    rQn_136 (Qn_25 Qn_28) resistor r=5.53947
    rQn_135 (Qn_25 Qn_28) resistor r=58.3583
    rQn_134 (Qn_25 Qn_28) resistor r=5.53947
    rQn_133 (Qn_28 Qn_30) resistor r=11.175
    rQn_132 (Qn_28 Qn_53) resistor r=24.8333
    rQn_131 (Qn_28 Qn_50) resistor r=24.8333
    rQn_130 (Qn_28 Qn_69) resistor r=22.35
    rQn_129 (Qn_28 Qn_66) resistor r=22.35
    rQn_128 (Qn_28 Qn_82) resistor r=58.3583
    rQn_127 (Qn_28 Qn_85) resistor r=58.3583
    rQn_126 (Qn_28 Qn_53) resistor r=4.16253
    rQn_125 (Qn_28 Qn_30) resistor r=5.53947
    rQn_124 (Qn_28 Qn_69) resistor r=2.32428
    rQn_123 (Qn_28 Qn_50) resistor r=4.16253
    rQn_122 (Qn_28 Qn_82) resistor r=4.16253
    rQn_121 (Qn_28 Qn_66) resistor r=4.16253
    rQn_120 (Qn_28 Qn_85) resistor r=4.16253
    rQn_119 (Qn_28 Qn_30) resistor r=11.175
    rQn_118 (Qn_28 Qn_185) resistor r=29.8
    rQn_117 (Qn_28 Qn_53) resistor r=24.8333
    rQn_116 (Qn_28 Qn_50) resistor r=24.8333
    rQn_115 (Qn_28 Qn_69) resistor r=22.35
    rQn_114 (Qn_28 Qn_66) resistor r=22.35
    rQn_113 (Qn_28 Qn_82) resistor r=58.3583
    rQn_112 (Qn_28 MM4_ELT_g) resistor r=7.45
    rQn_111 (Qn_28 Qn_53) resistor r=4.16253
    rQn_110 (Qn_28 Qn_30) resistor r=5.53947
    rQn_109 (Qn_28 Qn_69) resistor r=2.32428
    rQn_108 (Qn_28 Qn_50) resistor r=4.16253
    rQn_107 (Qn_28 Qn_82) resistor r=4.16253
    rQn_106 (Qn_28 Qn_66) resistor r=4.16253
    rQn_105 (Qn_28 Qn_85) resistor r=4.16253
    rQn_104 (Qn_36 Qn_39) resistor r=11.175
    rQn_103 (Qn_36 Qn_39) resistor r=5.53947
    rQn_102 (Qn_36 Qn_39) resistor r=11.175
    rQn_101 (Qn_36 Qn_39) resistor r=5.53947
    rQn_100 (Qn_39 Qn_42) resistor r=202.392
    rQn_99 (Qn_39 Qn_45) resistor r=202.392
    rQn_98 (Qn_39 Qn_61) resistor r=24.8333
    rQn_97 (Qn_39 Qn_58) resistor r=24.8333
    rQn_96 (Qn_39 Qn_77) resistor r=22.35
    rQn_95 (Qn_39 Qn_74) resistor r=22.35
    rQn_94 (Qn_39 Qn_90) resistor r=202.392
    rQn_93 (Qn_39 Qn_93) resistor r=202.392
    rQn_92 (Qn_39 Qn_42) resistor r=5.53947
    rQn_91 (Qn_39 Qn_77) resistor r=2.32428
    rQn_90 (Qn_39 Qn_61) resistor r=4.16253
    rQn_89 (Qn_39 Qn_45) resistor r=4.16253
    rQn_88 (Qn_39 Qn_74) resistor r=4.16253
    rQn_87 (Qn_39 Qn_90) resistor r=4.16253
    rQn_86 (Qn_39 Qn_58) resistor r=4.16253
    rQn_85 (Qn_39 Qn_93) resistor r=4.16253
    rQn_84 (Qn_39 Qn_187) resistor r=31.6625
    rQn_83 (Qn_39 Qn_42) resistor r=202.392
    rQn_82 (Qn_39 Qn_45) resistor r=202.392
    rQn_81 (Qn_39 Qn_61) resistor r=24.8333
    rQn_80 (Qn_39 Qn_58) resistor r=24.8333
    rQn_79 (Qn_39 Qn_77) resistor r=22.35
    rQn_78 (Qn_39 Qn_74) resistor r=22.35
    rQn_77 (Qn_39 Qn_90) resistor r=202.392
    rQn_76 (Qn_39 MM7_ELT_g) resistor r=7.45
    rQn_75 (Qn_39 Qn_42) resistor r=5.53947
    rQn_74 (Qn_39 Qn_77) resistor r=2.32428
    rQn_73 (Qn_39 Qn_61) resistor r=4.16253
    rQn_72 (Qn_39 Qn_45) resistor r=4.16253
    rQn_71 (Qn_39 Qn_74) resistor r=4.16253
    rQn_70 (Qn_39 Qn_90) resistor r=4.16253
    rQn_69 (Qn_39 Qn_58) resistor r=4.16253
    rQn_68 (Qn_39 Qn_93) resistor r=4.16253
    rQn_67 (Qn_85 MM4_ELT_g) resistor r=50.9083
    rQn_66 (Qn_93 MM7_ELT_g) resistor r=194.942
    rQn_65 (Qn_131 Qn_133) resistor r=0.34538
    rQn_64 (Qn_131 Qn_143) resistor r=0.0961114
    rQn_63 (Qn_133 Qn_140) resistor r=8.66667
    rQn_62 (Qn_133 Qn_136) resistor r=0.639641
    rQn_61 (Qn_136 Qn_140) resistor r=8.66667
    rQn_60 (Qn_136 Qn_139) resistor r=0.426428
    rQn_59 (Qn_139 Qn_140) resistor r=13
    rQn_58 (Qn_140 Qn_235) resistor r=26.9476
    rQn_57 (Qn_140 Qn_234) resistor r=26.9476
    rQn_56 (Qn_140 MM5_ELT_d) resistor r=5.62434
    rQn_55 (Qn_142 Qn_143) resistor r=0.977888
    rQn_54 (Qn_142 Qn_154) resistor r=0.0961114
    rQn_53 (Qn_144 Qn_146) resistor r=0.421097
    rQn_52 (Qn_144 Qn_150) resistor r=0.0961114
    rQn_51 (Qn_146 Qn_147) resistor r=13
    rQn_50 (Qn_147 MM3_ELT_d) resistor r=8.44
    rQn_49 (Qn_149 Qn_150) resistor r=0.35172
    rQn_48 (Qn_149 Qn_151) resistor r=0.0961114
    rQn_47 (Qn_151 Qn_152) resistor r=0.0976143
    rQn_46 (Qn_152 Qn) resistor r=0.119098
    rQn_45 (Qn_153 Qn_154) resistor r=0.0976143
    rQn_44 (Qn_153 Qn) resistor r=0.119098
    rQn_43 (Qn Qn_160) resistor r=10
    rQn_42 (Qn_160 Qn_219) resistor r=7.45
    rQn_41 (Qn_185 Qn_220) resistor r=3.725
    rQn_40 (Qn_187 Qn_220) resistor r=3.725
    rQn_39 (Qn_219 Qn_220) resistor r=3.725
    rQn_38 (MM5_ELT_d Qn_228) resistor r=25.7298
    rQn_37 (MM5_ELT_d Qn_231) resistor r=2.55965
    rQn_36 (MM5_ELT_d Qn_233) resistor r=12.3172
    rQn_35 (MM5_ELT_d Qn_233) resistor r=1.62887
    rQn_34 (Qn_228 Qn_230) resistor r=9.04062
    rQn_33 (Qn_229 Qn_231) resistor r=14.4784
    rQn_32 (Qn_229 Qn_235) resistor r=9.55325
    rQn_31 (Qn_230 Qn_231) resistor r=14.4784
    rQn_30 (Qn_232 Qn_233) resistor r=12.3172
    rQn_29 (Qn_232 Qn_234) resistor r=9.45545
    rVDD_213 (MM11_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_212 (MM25_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_211 (MM9_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_210 (MM20_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_209 (MM5_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_208 (MM8_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_207 (MM7_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_206 (MM21_ELT_b VDD_67) resistor r=8.66667
    rVDD_205 (MM21_ELT_b VDD_70) resistor r=8.66667
    rVDD_204 (MM21_ELT_b VDD_73) resistor r=8.66667
    rVDD_203 (MM21_ELT_b VDD_88) resistor r=8.66667
    rVDD_202 (MM21_ELT_b VDD_91) resistor r=26
    rVDD_201 (MM21_ELT_b VDD_65) resistor r=11.2533
    rVDD_200 (VDD_2 VDD_11) resistor r=0.490392
    rVDD_199 (VDD_2 VDD_97) resistor r=0.119217
    rVDD_198 (VDD_4 VDD_12) resistor r=8.66667
    rVDD_197 (VDD_4 VDD_8) resistor r=0.639641
    rVDD_196 (VDD_8 VDD_12) resistor r=8.66667
    rVDD_195 (VDD_8 VDD_11) resistor r=0.639641
    rVDD_194 (VDD_11 VDD_12) resistor r=8.66667
    rVDD_193 (VDD_12 MM21_ELT_s) resistor r=1.847
    rVDD_192 (VDD_12 VDD_156) resistor r=20.317
    rVDD_191 (VDD_13 VDD_16) resistor r=0.2214
    rVDD_190 (VDD_13 VDD_99) resistor r=0.0221583
    rVDD_189 (VDD_14 VDD_16) resistor r=0.0336053
    rVDD_188 (VDD_14 VDD_97) resistor r=0.017791
    rVDD_187 (VDD_16 VDD_17) resistor r=8.66667
    rVDD_186 (VDD_17 VDD_100) resistor r=67.52
    rVDD_185 (VDD_18 VDD_30) resistor r=0.175706
    rVDD_184 (VDD_18 VDD_99) resistor r=0.0882546
    rVDD_183 (VDD_20 VDD_21) resistor r=8.66667
    rVDD_182 (VDD_20 VDD_24) resistor r=0.426428
    rVDD_181 (VDD_21 MM11_ELT_s) resistor r=2.78649
    rVDD_180 (VDD_21 VDD_174) resistor r=11.6377
    rVDD_179 (VDD_24 VDD_25) resistor r=26
    rVDD_178 (VDD_24 VDD_27) resistor r=0.824065
    rVDD_177 (VDD_25 VDD_119) resistor r=5.67797
    rVDD_176 (VDD_25 VDD_174) resistor r=3.80758
    rVDD_175 (VDD_27 VDD_28) resistor r=8.66667
    rVDD_174 (VDD_27 VDD_30) resistor r=0.484744
    rVDD_173 (VDD_28 VDD_176) resistor r=16.4995
    rVDD_172 (VDD_28 VDD_157) resistor r=16.4995
    rVDD_171 (VDD_28 MM25_ELT_s) resistor r=3.29107
    rVDD_170 (VDD_30 VDD_31) resistor r=26
    rVDD_169 (VDD_31 VDD_125) resistor r=5.67797
    rVDD_168 (VDD_31 VDD_176) resistor r=3.80758
    rVDD_167 (VDD_32 VDD_35) resistor r=0.2214
    rVDD_166 (VDD_32 VDD_102) resistor r=0.0221583
    rVDD_165 (VDD_33 VDD_35) resistor r=0.217446
    rVDD_164 (VDD_33 VDD_99) resistor r=0.0221583
    rVDD_163 (VDD_35 VDD_36) resistor r=8.66667
    rVDD_162 (VDD_36 VDD_100) resistor r=67.52
    rVDD_161 (VDD_36 VDD_103) resistor r=67.52
    rVDD_160 (VDD_37 VDD_46) resistor r=0.253797
    rVDD_159 (VDD_37 VDD_102) resistor r=0.0882546
    rVDD_158 (VDD_39 VDD_60) resistor r=8.66667
    rVDD_157 (VDD_39 VDD_43) resistor r=0.639641
    rVDD_156 (VDD_43 VDD_60) resistor r=8.66667
    rVDD_155 (VDD_43 VDD_46) resistor r=0.426428
    rVDD_154 (VDD_46 VDD_60) resistor r=26
    rVDD_153 (VDD_48 VDD_49) resistor r=0.144305
    rVDD_152 (VDD_48 VDD_104) resistor r=0.0221583
    rVDD_151 (VDD_49 VDD_102) resistor r=0.0221583
    rVDD_150 (VDD_50 VDD_59) resistor r=0.267642
    rVDD_149 (VDD_50 VDD_104) resistor r=0.0882546
    rVDD_148 (VDD_52 VDD_60) resistor r=8.66667
    rVDD_147 (VDD_52 VDD_56) resistor r=0.617635
    rVDD_146 (VDD_56 VDD_60) resistor r=8.66667
    rVDD_145 (VDD_56 VDD_59) resistor r=0.411756
    rVDD_144 (VDD_59 VDD_60) resistor r=26
    rVDD_143 (VDD_60 VDD_159) resistor r=14.3924
    rVDD_142 (VDD_60 VDD_158) resistor r=14.3924
    rVDD_141 (VDD_60 MM9_ELT_s) resistor r=2.52574
    rVDD_140 (VDD_61 VDD_73) resistor r=0.0950223
    rVDD_139 (VDD_61 VDD_105) resistor r=0.0221583
    rVDD_138 (VDD_62 VDD_64) resistor r=0.0375589
    rVDD_137 (VDD_62 VDD_104) resistor r=0.0221583
    rVDD_136 (VDD_64 VDD_65) resistor r=8.66667
    rVDD_135 (VDD_64 VDD_67) resistor r=0.237556
    rVDD_134 (VDD_65 VDD_103) resistor r=67.52
    rVDD_133 (VDD_67 VDD_70) resistor r=0.237556
    rVDD_132 (VDD_70 VDD_73) resistor r=0.237556
    rVDD_131 (VDD_75 VDD_84) resistor r=0.538399
    rVDD_130 (VDD_75 VDD_105) resistor r=0.0882546
    rVDD_129 (VDD_77 VDD_85) resistor r=8.66667
    rVDD_128 (VDD_77 VDD_81) resistor r=0.702259
    rVDD_127 (VDD_81 VDD_85) resistor r=8.66667
    rVDD_126 (VDD_81 VDD_84) resistor r=0.468173
    rVDD_125 (VDD_84 VDD_85) resistor r=13
    rVDD_124 (VDD_85 MM7_ELT_s) resistor r=4.04518
    rVDD_123 (VDD_85 VDD_162) resistor r=4.04518
    rVDD_122 (VDD_85 MM8_ELT_s) resistor r=4.04518
    rVDD_121 (VDD_85 VDD_160) resistor r=4.04518
    rVDD_120 (VDD_86 VDD_88) resistor r=0.106746
    rVDD_119 (VDD_86 VDD_105) resistor r=0.0221583
    rVDD_118 (VDD_88 VDD_91) resistor r=0.158143
    rVDD_117 (VDD VDD_97) resistor r=0.0513963
    rVDD_116 (VDD_99 VDD_100) resistor r=8.66667
    rVDD_115 (VDD_102 VDD_103) resistor r=8.66667
    rVDD_114 (MM21_ELT_s VDD_111) resistor r=2.55965
    rVDD_113 (MM21_ELT_s VDD_113) resistor r=12.3172
    rVDD_112 (MM21_ELT_s VDD_113) resistor r=1.62887
    rVDD_111 (MM21_ELT_s VDD_116) resistor r=6.12113
    rVDD_110 (VDD_109 VDD_111) resistor r=14.4784
    rVDD_109 (VDD_109 VDD_115) resistor r=9.04062
    rVDD_108 (VDD_110 VDD_111) resistor r=14.4784
    rVDD_107 (VDD_110 VDD_156) resistor r=9.48555
    rVDD_106 (VDD_112 VDD_113) resistor r=12.3172
    rVDD_105 (VDD_112 VDD_114) resistor r=9.04595
    rVDD_104 (VDD_114 VDD_116) resistor r=31.2341
    rVDD_103 (VDD_115 VDD_116) resistor r=31.2341
    rVDD_102 (MM11_ELT_s VDD_120) resistor r=2.55965
    rVDD_101 (MM11_ELT_s VDD_128) resistor r=12.3172
    rVDD_100 (MM11_ELT_s VDD_128) resistor r=1.62887
    rVDD_99 (MM11_ELT_s VDD_131) resistor r=4.36821
    rVDD_98 (VDD_118 VDD_120) resistor r=14.4784
    rVDD_97 (VDD_118 VDD_130) resistor r=9.04062
    rVDD_96 (VDD_119 VDD_120) resistor r=14.4784
    rVDD_95 (MM25_ELT_s VDD_123) resistor r=12.3172
    rVDD_94 (MM25_ELT_s VDD_123) resistor r=1.62887
    rVDD_93 (MM25_ELT_s VDD_126) resistor r=2.55965
    rVDD_92 (MM25_ELT_s VDD_132) resistor r=17.3029
    rVDD_91 (VDD_122 VDD_123) resistor r=12.3172
    rVDD_90 (VDD_122 VDD_157) resistor r=9.39461
    rVDD_89 (VDD_124 VDD_126) resistor r=14.4784
    rVDD_88 (VDD_124 VDD_132) resistor r=9.04062
    rVDD_87 (VDD_125 VDD_126) resistor r=14.4784
    rVDD_86 (VDD_127 VDD_128) resistor r=12.3172
    rVDD_85 (VDD_127 VDD_129) resistor r=9.04595
    rVDD_84 (VDD_129 VDD_131) resistor r=20.2547
    rVDD_83 (VDD_130 VDD_131) resistor r=20.2547
    rVDD_82 (MM9_ELT_s VDD_134) resistor r=25.7298
    rVDD_81 (MM9_ELT_s VDD_137) resistor r=2.55965
    rVDD_80 (MM9_ELT_s VDD_139) resistor r=12.3172
    rVDD_79 (MM9_ELT_s VDD_139) resistor r=1.62887
    rVDD_78 (VDD_134 VDD_136) resistor r=9.04062
    rVDD_77 (VDD_135 VDD_137) resistor r=14.4784
    rVDD_76 (VDD_135 VDD_159) resistor r=16.4401
    rVDD_75 (VDD_136 VDD_137) resistor r=14.4784
    rVDD_74 (VDD_138 VDD_139) resistor r=12.3172
    rVDD_73 (VDD_138 VDD_158) resistor r=16.1191
    rVDD_72 (MM8_ELT_s VDD_141) resistor r=25.7298
    rVDD_71 (MM8_ELT_s VDD_144) resistor r=2.55965
    rVDD_70 (MM8_ELT_s VDD_146) resistor r=12.3172
    rVDD_69 (MM8_ELT_s VDD_146) resistor r=1.62887
    rVDD_68 (VDD_141 VDD_143) resistor r=9.04062
    rVDD_67 (VDD_142 VDD_144) resistor r=14.4784
    rVDD_66 (VDD_142 VDD_163) resistor r=10.5593
    rVDD_65 (VDD_143 VDD_144) resistor r=14.4784
    rVDD_64 (VDD_145 VDD_146) resistor r=12.3172
    rVDD_63 (VDD_145 VDD_161) resistor r=10.2363
    rVDD_62 (MM7_ELT_s VDD_150) resistor r=2.55965
    rVDD_61 (MM7_ELT_s VDD_152) resistor r=11.6604
    rVDD_60 (MM7_ELT_s VDD_152) resistor r=1.30988
    rVDD_59 (MM7_ELT_s VDD_155) resistor r=6.12113
    rVDD_58 (MM7_ELT_s VDD_161) resistor r=10.2363
    rVDD_57 (VDD_148 VDD_150) resistor r=14.4784
    rVDD_56 (VDD_148 VDD_154) resistor r=9.04062
    rVDD_55 (VDD_149 VDD_150) resistor r=14.4784
    rVDD_54 (VDD_149 VDD_163) resistor r=10.5593
    rVDD_53 (VDD_151 VDD_152) resistor r=11.6604
    rVDD_52 (VDD_151 VDD_153) resistor r=9.04595
    rVDD_51 (VDD_153 VDD_155) resistor r=31.2341
    rVDD_50 (VDD_154 VDD_155) resistor r=31.2341
    rVDD_49 (VDD_160 VDD_161) resistor r=0.549089
    rVDD_48 (VDD_162 VDD_163) resistor r=0.730683
    rVSS_162 (MM1_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_161 (MM10_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_160 (MM24_b MM22_ELT_b) resistor r=0.01
    rVSS_159 (MM18_b MM22_ELT_b) resistor r=0.01
    rVSS_158 (MM2_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_157 (MM3_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_156 (MM4_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_155 (MM22_ELT_b VSS_35) resistor r=8.66667
    rVSS_154 (MM22_ELT_b VSS_38) resistor r=8.66667
    rVSS_153 (MM22_ELT_b VSS_51) resistor r=8.66667
    rVSS_152 (MM22_ELT_b VSS_60) resistor r=8.66667
    rVSS_151 (MM22_ELT_b VSS_63) resistor r=26
    rVSS_150 (MM22_ELT_b VSS_33) resistor r=10.7871
    rVSS_149 (VSS_2 VSS_4) resistor r=0.399776
    rVSS_148 (VSS_2 VSS_69) resistor r=0.119217
    rVSS_147 (VSS_4 VSS_8) resistor r=8.66667
    rVSS_146 (VSS_4 VSS_7) resistor r=0.426428
    rVSS_145 (VSS_7 VSS_8) resistor r=26
    rVSS_144 (VSS_8 MM22_ELT_s) resistor r=2.90692
    rVSS_143 (VSS_8 VSS_116) resistor r=12.1406
    rVSS_142 (VSS_10 VSS_13) resistor r=0.2214
    rVSS_141 (VSS_10 VSS_71) resistor r=0.0221583
    rVSS_140 (VSS_11 VSS_13) resistor r=0.0336053
    rVSS_139 (VSS_11 VSS_69) resistor r=0.017791
    rVSS_138 (VSS_13 VSS_14) resistor r=8.66667
    rVSS_137 (VSS_14 VSS_72) resistor r=64.7228
    rVSS_136 (VSS_15 VSS_17) resistor r=0.405106
    rVSS_135 (VSS_15 VSS_71) resistor r=0.0882546
    rVSS_134 (VSS_17 VSS_21) resistor r=8.66667
    rVSS_133 (VSS_17 VSS_20) resistor r=0.436059
    rVSS_132 (VSS_20 VSS_21) resistor r=26
    rVSS_131 (VSS_21 MM1_ELT_s) resistor r=2.90692
    rVSS_130 (VSS_21 VSS_117) resistor r=12.1406
    rVSS_129 (VSS_23 VSS_38) resistor r=0.0395356
    rVSS_128 (VSS_23 VSS_73) resistor r=0.0221583
    rVSS_127 (VSS_24 VSS_26) resistor r=0.217759
    rVSS_126 (VSS_24 VSS_71) resistor r=0.0221583
    rVSS_125 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_124 (VSS_26 VSS_29) resistor r=0.237556
    rVSS_123 (VSS_27 VSS_72) resistor r=64.7228
    rVSS_122 (VSS_27 VSS_30) resistor r=64.7228
    rVSS_121 (VSS_29 VSS_30) resistor r=8.66667
    rVSS_120 (VSS_29 VSS_32) resistor r=0.237556
    rVSS_119 (VSS_30 VSS_33) resistor r=64.7228
    rVSS_118 (VSS_32 VSS_33) resistor r=8.66667
    rVSS_117 (VSS_32 VSS_35) resistor r=0.237556
    rVSS_116 (VSS_35 VSS_38) resistor r=0.237214
    rVSS_115 (VSS_40 VSS_42) resistor r=0.399776
    rVSS_114 (VSS_40 VSS_73) resistor r=0.0882546
    rVSS_113 (VSS_42 VSS_43) resistor r=8.66667
    rVSS_112 (VSS_42 VSS_45) resistor r=0.426428
    rVSS_111 (VSS_43 VSS_129) resistor r=16.9307
    rVSS_110 (VSS_43 VSS_118) resistor r=16.9307
    rVSS_109 (VSS_43 MM2_ELT_s) resistor r=3.33844
    rVSS_108 (VSS_45 VSS_46) resistor r=26
    rVSS_107 (VSS_46 VSS_98) resistor r=5.83793
    rVSS_106 (VSS_46 VSS_129) resistor r=4.02616
    rVSS_105 (VSS_48 VSS_51) resistor r=0.0948855
    rVSS_104 (VSS_48 VSS_74) resistor r=0.0221583
    rVSS_103 (VSS_49 VSS_51) resistor r=0.162096
    rVSS_102 (VSS_49 VSS_73) resistor r=0.0221583
    rVSS_101 (VSS_53 VSS_55) resistor r=0.438912
    rVSS_100 (VSS_53 VSS_74) resistor r=0.0882546
    rVSS_99 (VSS_55 VSS_56) resistor r=8.66667
    rVSS_98 (VSS_56 MM4_ELT_s) resistor r=4.22001
    rVSS_97 (VSS_56 VSS_121) resistor r=4.22001
    rVSS_96 (VSS_56 MM3_ELT_s) resistor r=4.22001
    rVSS_95 (VSS_56 VSS_119) resistor r=4.22001
    rVSS_94 (VSS_58 VSS_60) resistor r=0.106746
    rVSS_93 (VSS_58 VSS_74) resistor r=0.0221583
    rVSS_92 (VSS_60 VSS_63) resistor r=0.158143
    rVSS_91 (VSS VSS_69) resistor r=0.0494196
    rVSS_90 (VSS_71 VSS_72) resistor r=8.66667
    rVSS_89 (MM22_ELT_s VSS_78) resistor r=2.67027
    rVSS_88 (MM22_ELT_s VSS_80) resistor r=12.8495
    rVSS_87 (MM22_ELT_s VSS_80) resistor r=1.69926
    rVSS_86 (MM22_ELT_s VSS_83) resistor r=4.557
    rVSS_85 (VSS_76 VSS_78) resistor r=15.1041
    rVSS_84 (VSS_76 VSS_81) resistor r=9.43134
    rVSS_83 (VSS_77 VSS_78) resistor r=15.1041
    rVSS_82 (VSS_77 VSS_116) resistor r=9.89549
    rVSS_81 (VSS_79 VSS_80) resistor r=12.8495
    rVSS_80 (VSS_79 VSS_82) resistor r=9.4369
    rVSS_79 (VSS_81 VSS_83) resistor r=21.1301
    rVSS_78 (VSS_82 VSS_83) resistor r=21.1301
    rVSS_77 (MM1_ELT_s VSS_87) resistor r=2.67027
    rVSS_76 (MM1_ELT_s VSS_89) resistor r=12.8495
    rVSS_75 (MM1_ELT_s VSS_89) resistor r=1.69926
    rVSS_74 (MM1_ELT_s VSS_92) resistor r=4.557
    rVSS_73 (VSS_85 VSS_87) resistor r=15.1041
    rVSS_72 (VSS_85 VSS_90) resistor r=9.43134
    rVSS_71 (VSS_86 VSS_87) resistor r=15.1041
    rVSS_70 (VSS_86 VSS_117) resistor r=9.89549
    rVSS_69 (VSS_88 VSS_89) resistor r=12.8495
    rVSS_68 (VSS_88 VSS_91) resistor r=9.4369
    rVSS_67 (VSS_90 VSS_92) resistor r=21.1301
    rVSS_66 (VSS_91 VSS_92) resistor r=21.1301
    rVSS_65 (MM2_ELT_s VSS_94) resistor r=18.0507
    rVSS_64 (MM2_ELT_s VSS_97) resistor r=2.67027
    rVSS_63 (MM2_ELT_s VSS_99) resistor r=12.8495
    rVSS_62 (MM2_ELT_s VSS_99) resistor r=1.69926
    rVSS_61 (VSS_94 VSS_96) resistor r=9.43134
    rVSS_60 (VSS_95 VSS_97) resistor r=15.1041
    rVSS_59 (VSS_95 VSS_118) resistor r=9.96613
    rVSS_58 (VSS_96 VSS_97) resistor r=15.1041
    rVSS_57 (VSS_98 VSS_99) resistor r=12.8495
    rVSS_56 (MM3_ELT_s VSS_101) resistor r=18.0507
    rVSS_55 (MM3_ELT_s VSS_104) resistor r=2.67027
    rVSS_54 (MM3_ELT_s VSS_106) resistor r=12.8495
    rVSS_53 (MM3_ELT_s VSS_106) resistor r=1.69926
    rVSS_52 (VSS_101 VSS_103) resistor r=9.43134
    rVSS_51 (VSS_102 VSS_104) resistor r=15.1041
    rVSS_50 (VSS_102 VSS_120) resistor r=11.0157
    rVSS_49 (VSS_103 VSS_104) resistor r=15.1041
    rVSS_48 (VSS_105 VSS_106) resistor r=12.8495
    rVSS_47 (VSS_105 VSS_122) resistor r=10.6787
    rVSS_46 (MM4_ELT_s VSS_110) resistor r=2.67027
    rVSS_45 (MM4_ELT_s VSS_112) resistor r=12.1643
    rVSS_44 (MM4_ELT_s VSS_112) resistor r=1.36649
    rVSS_43 (MM4_ELT_s VSS_115) resistor r=4.557
    rVSS_42 (MM4_ELT_s VSS_122) resistor r=10.6787
    rVSS_41 (VSS_108 VSS_110) resistor r=15.1041
    rVSS_40 (VSS_108 VSS_113) resistor r=9.43134
    rVSS_39 (VSS_109 VSS_110) resistor r=15.1041
    rVSS_38 (VSS_109 VSS_120) resistor r=11.0157
    rVSS_37 (VSS_111 VSS_112) resistor r=12.1643
    rVSS_36 (VSS_111 VSS_114) resistor r=9.4369
    rVSS_35 (VSS_113 VSS_115) resistor r=21.1301
    rVSS_34 (VSS_114 VSS_115) resistor r=21.1301
    rVSS_33 (VSS_119 VSS_120) resistor r=0.762262
    rVSS_32 (VSS_121 VSS_122) resistor r=0.57282
    rnet032_27 (MM8_ELT_d net032) resistor r=0.01
    rnet032_26 (net032_1 net032_10) resistor r=0.223875
    rnet032_25 (net032_1 net032_13) resistor r=0.0961114
    rnet032_24 (net032_3 net032_4) resistor r=8.66667
    rnet032_23 (net032_3 net032_7) resistor r=0.639641
    rnet032_22 (net032_4 MM5_ELT_s) resistor r=32.3614
    rnet032_21 (net032_7 net032_8) resistor r=8.66667
    rnet032_20 (net032_7 net032_10) resistor r=0.426428
    rnet032_19 (net032_8 MM5_ELT_s) resistor r=16.1807
    rnet032_18 (net032_8 net032_11) resistor r=32.3614
    rnet032_17 (net032_10 net032_11) resistor r=26
    rnet032_16 (net032_12 net032_13) resistor r=0.949195
    rnet032_15 (net032_12 net032_14) resistor r=0.0961114
    rnet032_14 (net032_14 net032_23) resistor r=0.223875
    rnet032_13 (net032_16 net032_17) resistor r=8.66667
    rnet032_12 (net032_16 net032_20) resistor r=0.639641
    rnet032_11 (net032_17 net032) resistor r=32.3614
    rnet032_10 (net032_20 net032_21) resistor r=8.66667
    rnet032_9 (net032_20 net032_23) resistor r=0.426428
    rnet032_8 (net032_21 net032) resistor r=16.1807
    rnet032_7 (net032_21 net032_24) resistor r=32.3614
    rnet032_6 (net032_23 net032_24) resistor r=26
    rnet040_18 (MM2_ELT_d net040) resistor r=0.01
    rnet040_17 (net040_1 net040_3) resistor r=0.0586338
    rnet040_16 (net040_1 net040_17) resistor r=0.0728402
    rnet040_15 (net040_3 net040_4) resistor r=13
    rnet040_14 (net040_4 MM18_s) resistor r=8.44
    rnet040_13 (net040_8 net040_9) resistor r=0.58407
    rnet040_12 (net040_8 net040_18) resistor r=0.0189299
    rnet040_11 (net040_9 net040_17) resistor r=0.0189299
    rnet040_10 (net040_10 net040_12) resistor r=0.0586338
    rnet040_9 (net040_10 net040_18) resistor r=0.0728402
    rnet040_8 (net040_12 net040_13) resistor r=13
    rnet040_7 (net040_13 net040) resistor r=8.44
    rnet031_43 (MM9_ELT_d net031) resistor r=0.01
    rnet031_42 (net031_1 net031_3) resistor r=0.291178
    rnet031_41 (net031_1 net031_13) resistor r=0.0961114
    rnet031_40 (net031_3 net031_4) resistor r=8.66667
    rnet031_39 (net031_3 net031_6) resistor r=0.759596
    rnet031_38 (net031_4 net031) resistor r=32.3614
    rnet031_37 (net031_6 net031_7) resistor r=8.66667
    rnet031_36 (net031_6 net031_9) resistor r=0.426428
    rnet031_35 (net031_7 net031) resistor r=16.1807
    rnet031_34 (net031_7 net031_10) resistor r=32.3614
    rnet031_33 (net031_9 net031_10) resistor r=26
    rnet031_32 (net031_12 net031_13) resistor r=1.23062
    rnet031_31 (net031_12 net031_27) resistor r=0.0189299
    rnet031_30 (net031_16 net031_18) resistor r=0.0292843
    rnet031_29 (net031_16 net031_27) resistor r=0.0728402
    rnet031_28 (net031_18 net031_25) resistor r=8.66667
    rnet031_27 (net031_18 net031_21) resistor r=0.617635
    rnet031_26 (net031_21 net031_25) resistor r=8.66667
    rnet031_25 (net031_21 net031_24) resistor r=0.685271
    rnet031_24 (net031_24 net031_25) resistor r=8.66667
    rnet031_23 (net031_25 net031_36) resistor r=26.9476
    rnet031_22 (net031_25 net031_35) resistor r=26.9476
    rnet031_21 (net031_25 MM20_ELT_s) resistor r=5.62434
    rnet031_20 (MM20_ELT_s net031_30) resistor r=12.3172
    rnet031_19 (MM20_ELT_s net031_30) resistor r=1.62887
    rnet031_18 (MM20_ELT_s net031_33) resistor r=2.55965
    rnet031_17 (MM20_ELT_s net031_34) resistor r=25.7298
    rnet031_16 (net031_29 net031_30) resistor r=12.3172
    rnet031_15 (net031_29 net031_35) resistor r=9.45545
    rnet031_14 (net031_31 net031_33) resistor r=14.4784
    rnet031_13 (net031_31 net031_34) resistor r=9.04062
    rnet031_12 (net031_32 net031_33) resistor r=14.4784
    rnet031_11 (net031_32 net031_36) resistor r=9.55325
    rSDN_161 (SDN_32 SDN_38) resistor r=58.3583
    rSDN_160 (SDN_32 SDN_38) resistor r=4.16253
    rSDN_159 (SDN_32 SDN_38) resistor r=58.3583
    rSDN_158 (SDN_32 SDN_38) resistor r=4.16253
    rSDN_157 (SDN_35 SDN_38) resistor r=58.3583
    rSDN_156 (SDN_35 SDN_38) resistor r=4.16253
    rSDN_155 (SDN_35 SDN_38) resistor r=58.3583
    rSDN_154 (SDN_35 SDN_38) resistor r=4.16253
    rSDN_153 (SDN_38 SDN_43) resistor r=24.8333
    rSDN_152 (SDN_38 SDN_40) resistor r=24.8333
    rSDN_151 (SDN_38 SDN_51) resistor r=24.8333
    rSDN_150 (SDN_38 SDN_48) resistor r=24.8333
    rSDN_149 (SDN_38 SDN_56) resistor r=14.9
    rSDN_148 (SDN_38 SDN_62) resistor r=58.3583
    rSDN_147 (SDN_38 SDN_65) resistor r=58.3583
    rSDN_146 (SDN_38 SDN_43) resistor r=4.16253
    rSDN_145 (SDN_38 SDN_51) resistor r=4.16253
    rSDN_144 (SDN_38 SDN_62) resistor r=6.30933
    rSDN_143 (SDN_38 SDN_56) resistor r=6.30933
    rSDN_142 (SDN_38 SDN_40) resistor r=1.63969
    rSDN_141 (SDN_38 SDN_48) resistor r=4.16253
    rSDN_140 (SDN_38 SDN_65) resistor r=4.16253
    rSDN_139 (SDN_38 SDN_43) resistor r=24.8333
    rSDN_138 (SDN_38 SDN_40) resistor r=24.8333
    rSDN_137 (SDN_38 SDN_51) resistor r=24.8333
    rSDN_136 (SDN_38 SDN_48) resistor r=24.8333
    rSDN_135 (SDN_38 SDN_253) resistor r=39.7333
    rSDN_134 (SDN_38 SDN_56) resistor r=14.9
    rSDN_133 (SDN_38 SDN_62) resistor r=58.3583
    rSDN_132 (SDN_38 MM25_ELT_g) resistor r=7.45
    rSDN_131 (SDN_38 SDN_43) resistor r=4.16253
    rSDN_130 (SDN_38 SDN_51) resistor r=4.16253
    rSDN_129 (SDN_38 SDN_62) resistor r=6.30933
    rSDN_128 (SDN_38 SDN_56) resistor r=6.30933
    rSDN_127 (SDN_38 SDN_40) resistor r=1.63969
    rSDN_126 (SDN_38 SDN_48) resistor r=4.16253
    rSDN_125 (SDN_38 SDN_65) resistor r=4.16253
    rSDN_124 (SDN_65 MM25_ELT_g) resistor r=50.9083
    rSDN_123 (SDN_70 SDN_76) resistor r=58.3583
    rSDN_122 (SDN_70 SDN_76) resistor r=4.16253
    rSDN_121 (SDN_70 SDN_76) resistor r=58.3583
    rSDN_120 (SDN_70 SDN_76) resistor r=4.16253
    rSDN_119 (SDN_73 SDN_76) resistor r=58.3583
    rSDN_118 (SDN_73 SDN_76) resistor r=4.16253
    rSDN_117 (SDN_73 SDN_76) resistor r=58.3583
    rSDN_116 (SDN_73 SDN_76) resistor r=4.16253
    rSDN_115 (SDN_76 SDN_81) resistor r=24.8333
    rSDN_114 (SDN_76 SDN_78) resistor r=24.8333
    rSDN_113 (SDN_76 SDN_89) resistor r=24.8333
    rSDN_112 (SDN_76 SDN_86) resistor r=24.8333
    rSDN_111 (SDN_76 SDN_94) resistor r=58.3583
    rSDN_110 (SDN_76 SDN_97) resistor r=58.3583
    rSDN_109 (SDN_76 SDN_102) resistor r=14.9
    rSDN_108 (SDN_76 SDN_81) resistor r=4.16253
    rSDN_107 (SDN_76 SDN_89) resistor r=4.16253
    rSDN_106 (SDN_76 SDN_78) resistor r=4.16253
    rSDN_105 (SDN_76 SDN_94) resistor r=4.16253
    rSDN_104 (SDN_76 SDN_102) resistor r=6.30933
    rSDN_103 (SDN_76 SDN_97) resistor r=6.30933
    rSDN_102 (SDN_76 SDN_86) resistor r=1.63969
    rSDN_101 (SDN_76 SDN_81) resistor r=24.8333
    rSDN_100 (SDN_76 SDN_78) resistor r=24.8333
    rSDN_99 (SDN_76 SDN_89) resistor r=24.8333
    rSDN_98 (SDN_76 SDN_86) resistor r=24.8333
    rSDN_97 (SDN_76 SDN_94) resistor r=58.3583
    rSDN_96 (SDN_76 MM24_g) resistor r=22.35
    rSDN_95 (SDN_76 SDN_102) resistor r=14.9
    rSDN_94 (SDN_76 SDN_278) resistor r=39.7333
    rSDN_93 (SDN_76 SDN_81) resistor r=4.16253
    rSDN_92 (SDN_76 SDN_89) resistor r=4.16253
    rSDN_91 (SDN_76 SDN_78) resistor r=4.16253
    rSDN_90 (SDN_76 SDN_94) resistor r=4.16253
    rSDN_89 (SDN_76 SDN_102) resistor r=6.30933
    rSDN_88 (SDN_76 SDN_97) resistor r=6.30933
    rSDN_87 (SDN_76 SDN_86) resistor r=1.63969
    rSDN_86 (SDN_97 MM24_g) resistor r=36.0083
    rSDN_85 (SDN_108 SDN_114) resistor r=58.3583
    rSDN_84 (SDN_108 SDN_114) resistor r=4.16253
    rSDN_83 (SDN_108 SDN_114) resistor r=58.3583
    rSDN_82 (SDN_108 SDN_114) resistor r=4.16253
    rSDN_81 (SDN_111 SDN_114) resistor r=58.3583
    rSDN_80 (SDN_111 SDN_114) resistor r=6.30933
    rSDN_79 (SDN_111 SDN_114) resistor r=58.3583
    rSDN_78 (SDN_111 SDN_114) resistor r=6.30933
    rSDN_77 (SDN_114 SDN_116) resistor r=14.9
    rSDN_76 (SDN_114 SDN_125) resistor r=24.8333
    rSDN_75 (SDN_114 SDN_122) resistor r=24.8333
    rSDN_74 (SDN_114 SDN_133) resistor r=24.8333
    rSDN_73 (SDN_114 SDN_130) resistor r=24.8333
    rSDN_72 (SDN_114 SDN_138) resistor r=58.3583
    rSDN_71 (SDN_114 SDN_141) resistor r=58.3583
    rSDN_70 (SDN_114 SDN_125) resistor r=4.16253
    rSDN_69 (SDN_114 SDN_116) resistor r=6.30933
    rSDN_68 (SDN_114 SDN_133) resistor r=1.63969
    rSDN_67 (SDN_114 SDN_122) resistor r=4.16253
    rSDN_66 (SDN_114 SDN_138) resistor r=4.16253
    rSDN_65 (SDN_114 SDN_130) resistor r=4.16253
    rSDN_64 (SDN_114 SDN_141) resistor r=4.16253
    rSDN_63 (SDN_114 SDN_116) resistor r=14.9
    rSDN_62 (SDN_114 SDN_284) resistor r=39.7333
    rSDN_61 (SDN_114 SDN_125) resistor r=24.8333
    rSDN_60 (SDN_114 SDN_122) resistor r=24.8333
    rSDN_59 (SDN_114 SDN_133) resistor r=24.8333
    rSDN_58 (SDN_114 SDN_130) resistor r=24.8333
    rSDN_57 (SDN_114 SDN_138) resistor r=58.3583
    rSDN_56 (SDN_114 MM18_g) resistor r=7.45
    rSDN_55 (SDN_114 SDN_125) resistor r=4.16253
    rSDN_54 (SDN_114 SDN_116) resistor r=6.30933
    rSDN_53 (SDN_114 SDN_133) resistor r=1.63969
    rSDN_52 (SDN_114 SDN_122) resistor r=4.16253
    rSDN_51 (SDN_114 SDN_138) resistor r=4.16253
    rSDN_50 (SDN_114 SDN_130) resistor r=4.16253
    rSDN_49 (SDN_114 SDN_141) resistor r=4.16253
    rSDN_48 (SDN_141 MM18_g) resistor r=50.9083
    rSDN_47 (SDN_196 SDN_198) resistor r=0.317897
    rSDN_46 (SDN_196 SDN_202) resistor r=0.111466
    rSDN_45 (SDN_198 SDN_199) resistor r=10
    rSDN_44 (SDN_199 SDN_299) resistor r=13.5455
    rSDN_43 (SDN_201 SDN_202) resistor r=1.04193
    rSDN_42 (SDN_201 SDN_204) resistor r=0.0961114
    rSDN_41 (SDN_203 SDN_204) resistor r=1.28911
    rSDN_40 (SDN_203 SDN_206) resistor r=0.0961114
    rSDN_39 (SDN_205 SDN_206) resistor r=0.0976143
    rSDN_38 (SDN_205 SDN_207) resistor r=0.111466
    rSDN_37 (SDN_207 SDN) resistor r=0.023548
    rSDN_36 (SDN SDN_211) resistor r=0.102041
    rSDN_35 (SDN_211 SDN_212) resistor r=10
    rSDN_34 (SDN_212 SDN_307) resistor r=37.25
    rSDN_33 (SDN_212 SDN_310) resistor r=19.6409
    rSDN_32 (SDN_253 SDN_300) resistor r=4.38767
    rSDN_31 (SDN_278 SDN_307) resistor r=9.29775
    rSDN_30 (SDN_284 SDN_310) resistor r=9.29775
    rSDN_29 (SDN_299 SDN_300) resistor r=3.71511
    rnet033_15 (MM24_s net033) resistor r=0.01
    rnet033_14 (net033_1 net033_3) resistor r=0.191892
    rnet033_13 (net033_1 net033_7) resistor r=0.0961114
    rnet033_12 (net033_3 net033_4) resistor r=13
    rnet033_11 (net033_4 MM1_ELT_d) resistor r=8.44
    rnet033_10 (net033_6 net033_7) resistor r=1.86134
    rnet033_9 (net033_6 net033_8) resistor r=0.0961114
    rnet033_8 (net033_8 net033_10) resistor r=0.191892
    rnet033_7 (net033_10 net033_11) resistor r=13
    rnet033_6 (net033_11 net033) resistor r=8.44
    rnet037_39 (net037_3 MM24_d) resistor r=4.22001
    rnet037_38 (net037_3 net037_24) resistor r=4.22001
    rnet037_37 (net037_3 MM10_ELT_s) resistor r=4.22001
    rnet037_36 (net037_3 net037_22) resistor r=4.22001
    rnet037_35 (net037_6 net037_9) resistor r=21.1301
    rnet037_34 (net037_6 net037_11) resistor r=9.43134
    rnet037_33 (net037_7 net037_9) resistor r=21.1301
    rnet037_32 (net037_7 net037_13) resistor r=9.4369
    rnet037_31 (MM10_ELT_s net037_9) resistor r=4.557
    rnet037_30 (MM10_ELT_s net037_12) resistor r=2.67027
    rnet037_29 (MM10_ELT_s net037_14) resistor r=12.8495
    rnet037_28 (MM10_ELT_s net037_14) resistor r=1.69926
    rnet037_27 (MM10_ELT_s net037) resistor r=10.6787
    rnet037_26 (net037_10 net037_12) resistor r=15.1041
    rnet037_25 (net037_10 net037_23) resistor r=11.0157
    rnet037_24 (net037_11 net037_12) resistor r=15.1041
    rnet037_23 (net037_13 net037_14) resistor r=12.8495
    rnet037_22 (MM24_d net037_18) resistor r=2.67027
    rnet037_21 (MM24_d net037_20) resistor r=12.8495
    rnet037_20 (MM24_d net037_20) resistor r=1.69926
    rnet037_19 (MM24_d net037_21) resistor r=18.0507
    rnet037_18 (net037_16 net037_18) resistor r=15.1041
    rnet037_17 (net037_16 net037_21) resistor r=9.43134
    rnet037_16 (net037_17 net037_18) resistor r=15.1041
    rnet037_15 (net037_17 net037_23) resistor r=11.0157
    rnet037_14 (net037_19 net037_20) resistor r=12.8495
    rnet037_13 (net037_19 net037) resistor r=10.6787
    rnet037_12 (net037_22 net037_23) resistor r=0.762262
    rnet037_11 (net037_24 net037) resistor r=0.57282
    rX_75 (MM11_ELT_d X) resistor r=0.01
    rX_74 (X_12 X_15) resistor r=14.9
    rX_73 (X_12 X_15) resistor r=6.30933
    rX_72 (X_12 X_15) resistor r=14.9
    rX_71 (X_12 X_15) resistor r=6.30933
    rX_70 (X_15 X_18) resistor r=202.392
    rX_69 (X_15 X_21) resistor r=202.392
    rX_68 (X_15 X_29) resistor r=24.8333
    rX_67 (X_15 X_26) resistor r=24.8333
    rX_66 (X_15 X_37) resistor r=24.8333
    rX_65 (X_15 X_34) resistor r=24.8333
    rX_64 (X_15 X_42) resistor r=202.392
    rX_63 (X_15 X_45) resistor r=202.392
    rX_62 (X_15 X_18) resistor r=6.30933
    rX_61 (X_15 X_29) resistor r=1.63969
    rX_60 (X_15 X_37) resistor r=4.16253
    rX_59 (X_15 X_21) resistor r=4.16253
    rX_58 (X_15 X_26) resistor r=4.16253
    rX_57 (X_15 X_42) resistor r=4.16253
    rX_56 (X_15 X_34) resistor r=4.16253
    rX_55 (X_15 X_45) resistor r=4.16253
    rX_54 (X_15 X_101) resistor r=42.2167
    rX_53 (X_15 X_18) resistor r=202.392
    rX_52 (X_15 X_21) resistor r=202.392
    rX_51 (X_15 X_29) resistor r=24.8333
    rX_50 (X_15 X_26) resistor r=24.8333
    rX_49 (X_15 X_37) resistor r=24.8333
    rX_48 (X_15 X_34) resistor r=24.8333
    rX_47 (X_15 X_42) resistor r=202.392
    rX_46 (X_15 MM9_ELT_g) resistor r=7.45
    rX_45 (X_15 X_18) resistor r=6.30933
    rX_44 (X_15 X_29) resistor r=1.63969
    rX_43 (X_15 X_37) resistor r=4.16253
    rX_42 (X_15 X_21) resistor r=4.16253
    rX_41 (X_15 X_26) resistor r=4.16253
    rX_40 (X_15 X_42) resistor r=4.16253
    rX_39 (X_15 X_34) resistor r=4.16253
    rX_38 (X_15 X_45) resistor r=4.16253
    rX_37 (X_45 MM9_ELT_g) resistor r=194.942
    rX_36 (X_68 X_69) resistor r=0.112256
    rX_35 (X_68 X_71) resistor r=0.0961114
    rX_34 (X_69 X_85) resistor r=0.0480557
    rX_33 (X_70 X_71) resistor r=0.395594
    rX_32 (X_70 X_73) resistor r=0.111466
    rX_31 (X_72 X_75) resistor r=0.121873
    rX_30 (X_72 X_78) resistor r=0.111466
    rX_29 (X_73 X_75) resistor r=0.0667192
    rX_28 (X_75 X_76) resistor r=10
    rX_27 (X_76 X_118) resistor r=25.0591
    rX_26 (X_77 X_78) resistor r=0.195229
    rX_25 (X_77 X_87) resistor r=0.0101024
    rX_24 (X_79 X_81) resistor r=0.30383
    rX_23 (X_79 X_89) resistor r=0.0101024
    rX_22 (X_81 X_82) resistor r=13
    rX_21 (X_82 MM10_ELT_d) resistor r=8.44
    rX_20 (X_85 X_86) resistor r=13
    rX_19 (X_86 X) resistor r=8.09035
    rX_18 (X_87 X_89) resistor r=0.141541
    rX_17 (X_101 X_118) resistor r=9.29775
    rY_167 (Y_22 Y_28) resistor r=58.3583
    rY_166 (Y_22 Y_28) resistor r=4.16253
    rY_165 (Y_22 Y_28) resistor r=58.3583
    rY_164 (Y_22 Y_28) resistor r=4.16253
    rY_163 (Y_25 Y_28) resistor r=58.3583
    rY_162 (Y_25 Y_28) resistor r=6.30933
    rY_161 (Y_25 Y_28) resistor r=58.3583
    rY_160 (Y_25 Y_28) resistor r=6.30933
    rY_159 (Y_28 Y_30) resistor r=14.9
    rY_158 (Y_28 Y_53) resistor r=24.8333
    rY_157 (Y_28 Y_50) resistor r=24.8333
    rY_156 (Y_28 Y_61) resistor r=24.8333
    rY_155 (Y_28 Y_58) resistor r=24.8333
    rY_154 (Y_28 Y_82) resistor r=58.3583
    rY_153 (Y_28 Y_85) resistor r=58.3583
    rY_152 (Y_28 Y_53) resistor r=4.16253
    rY_151 (Y_28 Y_30) resistor r=6.30933
    rY_150 (Y_28 Y_61) resistor r=1.63969
    rY_149 (Y_28 Y_50) resistor r=4.16253
    rY_148 (Y_28 Y_82) resistor r=4.16253
    rY_147 (Y_28 Y_58) resistor r=4.16253
    rY_146 (Y_28 Y_85) resistor r=4.16253
    rY_145 (Y_28 Y_30) resistor r=14.9
    rY_144 (Y_28 Y_198) resistor r=39.7333
    rY_143 (Y_28 Y_53) resistor r=24.8333
    rY_142 (Y_28 Y_50) resistor r=24.8333
    rY_141 (Y_28 Y_61) resistor r=24.8333
    rY_140 (Y_28 Y_58) resistor r=24.8333
    rY_139 (Y_28 Y_82) resistor r=58.3583
    rY_138 (Y_28 MM3_ELT_g) resistor r=7.45
    rY_137 (Y_28 Y_53) resistor r=4.16253
    rY_136 (Y_28 Y_30) resistor r=6.30933
    rY_135 (Y_28 Y_61) resistor r=1.63969
    rY_134 (Y_28 Y_50) resistor r=4.16253
    rY_133 (Y_28 Y_82) resistor r=4.16253
    rY_132 (Y_28 Y_58) resistor r=4.16253
    rY_131 (Y_28 Y_85) resistor r=4.16253
    rY_130 (Y_36 Y_39) resistor r=14.9
    rY_129 (Y_36 Y_39) resistor r=6.30933
    rY_128 (Y_36 Y_39) resistor r=14.9
    rY_127 (Y_36 Y_39) resistor r=6.30933
    rY_126 (Y_39 Y_42) resistor r=202.392
    rY_125 (Y_39 Y_45) resistor r=202.392
    rY_124 (Y_39 Y_69) resistor r=24.8333
    rY_123 (Y_39 Y_66) resistor r=24.8333
    rY_122 (Y_39 Y_77) resistor r=24.8333
    rY_121 (Y_39 Y_74) resistor r=24.8333
    rY_120 (Y_39 Y_90) resistor r=202.392
    rY_119 (Y_39 Y_93) resistor r=202.392
    rY_118 (Y_39 Y_42) resistor r=6.30933
    rY_117 (Y_39 Y_69) resistor r=1.63969
    rY_116 (Y_39 Y_77) resistor r=4.16253
    rY_115 (Y_39 Y_45) resistor r=4.16253
    rY_114 (Y_39 Y_66) resistor r=4.16253
    rY_113 (Y_39 Y_90) resistor r=4.16253
    rY_112 (Y_39 Y_74) resistor r=4.16253
    rY_111 (Y_39 Y_93) resistor r=4.16253
    rY_110 (Y_39 Y_200) resistor r=42.2167
    rY_109 (Y_39 Y_42) resistor r=202.392
    rY_108 (Y_39 Y_45) resistor r=202.392
    rY_107 (Y_39 Y_69) resistor r=24.8333
    rY_106 (Y_39 Y_66) resistor r=24.8333
    rY_105 (Y_39 Y_77) resistor r=24.8333
    rY_104 (Y_39 Y_74) resistor r=24.8333
    rY_103 (Y_39 Y_90) resistor r=202.392
    rY_102 (Y_39 MM8_ELT_g) resistor r=7.45
    rY_101 (Y_39 Y_42) resistor r=6.30933
    rY_100 (Y_39 Y_69) resistor r=1.63969
    rY_99 (Y_39 Y_77) resistor r=4.16253
    rY_98 (Y_39 Y_45) resistor r=4.16253
    rY_97 (Y_39 Y_66) resistor r=4.16253
    rY_96 (Y_39 Y_90) resistor r=4.16253
    rY_95 (Y_39 Y_74) resistor r=4.16253
    rY_94 (Y_39 Y_93) resistor r=4.16253
    rY_93 (Y_85 MM3_ELT_g) resistor r=50.9083
    rY_92 (Y_93 MM8_ELT_g) resistor r=194.942
    rY_91 (Y_131 Y_133) resistor r=0.426428
    rY_90 (Y_131 Y_158) resistor r=0.0480557
    rY_89 (Y_133 Y_159) resistor r=8.66667
    rY_88 (Y_136 Y_137) resistor r=1.42535
    rY_87 (Y_136 Y_148) resistor r=0.103122
    rY_86 (Y_137 Y_158) resistor r=0.0480557
    rY_85 (Y_138 Y_141) resistor r=0.442419
    rY_84 (Y_138 Y_147) resistor r=0.0963574
    rY_83 (Y_139 Y_144) resistor r=0.14925
    rY_82 (Y_139 Y_160) resistor r=0.0529336
    rY_81 (Y_141 Y_142) resistor r=8.66667
    rY_80 (Y_141 Y_144) resistor r=0.639641
    rY_79 (Y_142 MM20_ELT_d) resistor r=32.3614
    rY_78 (Y_144 Y_145) resistor r=8.66667
    rY_77 (Y_145 MM20_ELT_d) resistor r=16.1807
    rY_76 (Y_145 Y_265) resistor r=32.3614
    rY_75 (Y_146 Y_147) resistor r=0.639952
    rY_74 (Y_146 Y_151) resistor r=0.100285
    rY_73 (Y_148 Y_149) resistor r=0.0946512
    rY_72 (Y_149 Y_161) resistor r=0.0822776
    rY_71 (Y_150 Y_151) resistor r=0.165832
    rY_70 (Y_150 Y_161) resistor r=0.0822776
    rY_69 (Y_152 Y_154) resistor r=0.406219
    rY_68 (Y_152 Y_161) resistor r=0.0106887
    rY_67 (Y_154 Y_155) resistor r=10
    rY_66 (Y_155 Y_250) resistor r=7.45
    rY_65 (Y_158 Y_159) resistor r=26
    rY_64 (Y_159 MM18_d) resistor r=2.94846
    rY_63 (Y_159 Y_247) resistor r=11.8944
    rY_62 (Y_160 Y_172) resistor r=0.0419648
    rY_61 (Y_162 Y_164) resistor r=0.360955
    rY_60 (Y_162 Y_168) resistor r=0.0762583
    rY_59 (Y_164 Y_165) resistor r=0.75
    rY_58 (Y_165 Y_253) resistor r=13
    rY_57 (Y_167 Y_168) resistor r=1.42829
    rY_56 (Y_167 Y_169) resistor r=0.0762583
    rY_55 (Y_169 Y_171) resistor r=0.399767
    rY_54 (Y_171 Y_172) resistor r=0.75
    rY_53 (Y_172 Y) resistor r=0.17835
    rY_52 (Y_198 Y_250) resistor r=5.23411
    rY_51 (Y_200 Y_250) resistor r=5.23411
    rY_50 (MM18_d Y_241) resistor r=2.67027
    rY_49 (MM18_d Y_243) resistor r=12.8495
    rY_48 (MM18_d Y_243) resistor r=1.69926
    rY_47 (MM18_d Y_246) resistor r=4.557
    rY_46 (Y_239 Y_241) resistor r=15.1041
    rY_45 (Y_239 Y_244) resistor r=9.43134
    rY_44 (Y_240 Y_241) resistor r=15.1041
    rY_43 (Y_240 Y_247) resistor r=9.96613
    rY_42 (Y_242 Y_243) resistor r=12.8495
    rY_41 (Y_242 Y_245) resistor r=9.4369
    rY_40 (Y_244 Y_246) resistor r=21.1301
    rY_39 (Y_245 Y_246) resistor r=21.1301
    rY_38 (Y_253 MM25_ELT_d) resistor r=8.09035
    rY_37 (Y_265 Y) resistor r=26
    rD_96 (D_22 D_28) resistor r=58.3583
    rD_95 (D_22 D_28) resistor r=4.16253
    rD_94 (D_22 D_28) resistor r=58.3583
    rD_93 (D_22 D_28) resistor r=4.16253
    rD_92 (D_25 D_28) resistor r=58.3583
    rD_91 (D_25 D_28) resistor r=6.30933
    rD_90 (D_25 D_28) resistor r=58.3583
    rD_89 (D_25 D_28) resistor r=6.30933
    rD_88 (D_28 D_30) resistor r=14.9
    rD_87 (D_28 D_53) resistor r=24.8333
    rD_86 (D_28 D_50) resistor r=24.8333
    rD_85 (D_28 D_61) resistor r=24.8333
    rD_84 (D_28 D_58) resistor r=24.8333
    rD_83 (D_28 D_82) resistor r=58.3583
    rD_82 (D_28 D_85) resistor r=58.3583
    rD_81 (D_28 D_53) resistor r=4.16253
    rD_80 (D_28 D_30) resistor r=6.30933
    rD_79 (D_28 D_61) resistor r=1.63969
    rD_78 (D_28 D_50) resistor r=4.16253
    rD_77 (D_28 D_82) resistor r=4.16253
    rD_76 (D_28 D_58) resistor r=4.16253
    rD_75 (D_28 D_85) resistor r=4.16253
    rD_74 (D_28 D_30) resistor r=14.9
    rD_73 (D_28 D_162) resistor r=39.7333
    rD_72 (D_28 D_53) resistor r=24.8333
    rD_71 (D_28 D_50) resistor r=24.8333
    rD_70 (D_28 D_61) resistor r=24.8333
    rD_69 (D_28 D_58) resistor r=24.8333
    rD_68 (D_28 D_82) resistor r=58.3583
    rD_67 (D_28 MM1_ELT_g) resistor r=7.45
    rD_66 (D_28 D_53) resistor r=4.16253
    rD_65 (D_28 D_30) resistor r=6.30933
    rD_64 (D_28 D_61) resistor r=1.63969
    rD_63 (D_28 D_50) resistor r=4.16253
    rD_62 (D_28 D_82) resistor r=4.16253
    rD_61 (D_28 D_58) resistor r=4.16253
    rD_60 (D_28 D_85) resistor r=4.16253
    rD_59 (D_36 D_39) resistor r=14.9
    rD_58 (D_36 D_39) resistor r=6.30933
    rD_57 (D_36 D_39) resistor r=14.9
    rD_56 (D_36 D_39) resistor r=6.30933
    rD_55 (D_39 D_42) resistor r=58.3583
    rD_54 (D_39 D_45) resistor r=58.3583
    rD_53 (D_39 D_69) resistor r=24.8333
    rD_52 (D_39 D_66) resistor r=24.8333
    rD_51 (D_39 D_77) resistor r=24.8333
    rD_50 (D_39 D_74) resistor r=24.8333
    rD_49 (D_39 D_90) resistor r=58.3583
    rD_48 (D_39 D_93) resistor r=58.3583
    rD_47 (D_39 D_42) resistor r=6.30933
    rD_46 (D_39 D_69) resistor r=1.63969
    rD_45 (D_39 D_77) resistor r=4.16253
    rD_44 (D_39 D_45) resistor r=4.16253
    rD_43 (D_39 D_66) resistor r=4.16253
    rD_42 (D_39 D_90) resistor r=4.16253
    rD_41 (D_39 D_74) resistor r=4.16253
    rD_40 (D_39 D_93) resistor r=4.16253
    rD_39 (D_39 D_164) resistor r=55.875
    rD_38 (D_39 D_42) resistor r=58.3583
    rD_37 (D_39 D_45) resistor r=58.3583
    rD_36 (D_39 D_69) resistor r=24.8333
    rD_35 (D_39 D_66) resistor r=24.8333
    rD_34 (D_39 D_77) resistor r=24.8333
    rD_33 (D_39 D_74) resistor r=24.8333
    rD_32 (D_39 D_90) resistor r=58.3583
    rD_31 (D_39 MM11_ELT_g) resistor r=7.45
    rD_30 (D_39 D_42) resistor r=6.30933
    rD_29 (D_39 D_69) resistor r=1.63969
    rD_28 (D_39 D_77) resistor r=4.16253
    rD_27 (D_39 D_45) resistor r=4.16253
    rD_26 (D_39 D_66) resistor r=4.16253
    rD_25 (D_39 D_90) resistor r=4.16253
    rD_24 (D_39 D_74) resistor r=4.16253
    rD_23 (D_39 D_93) resistor r=4.16253
    rD_22 (D_85 MM1_ELT_g) resistor r=50.9083
    rD_21 (D_93 MM11_ELT_g) resistor r=50.9083
    rD_20 (D_132 D_133) resistor r=10
    rD_19 (D_132 D) resistor r=0.00230852
    rD_18 (D_133 D_194) resistor r=25.0591
    rD_17 (D_162 D_195) resistor r=10.0997
    rD_16 (D_164 D_195) resistor r=10.0997
    rD_15 (D_194 D_195) resistor r=0.877078
    rCPN_248 (MM21_ELT_d CPN) resistor r=0.01
    rCPN_247 (CPN_42 CPN_48) resistor r=58.3583
    rCPN_246 (CPN_42 CPN_48) resistor r=4.16253
    rCPN_245 (CPN_42 CPN_48) resistor r=58.3583
    rCPN_244 (CPN_42 CPN_48) resistor r=4.16253
    rCPN_243 (CPN_45 CPN_48) resistor r=58.3583
    rCPN_242 (CPN_45 CPN_48) resistor r=4.16253
    rCPN_241 (CPN_45 CPN_48) resistor r=58.3583
    rCPN_240 (CPN_45 CPN_48) resistor r=4.16253
    rCPN_239 (CPN_48 CPN_53) resistor r=24.8333
    rCPN_238 (CPN_48 CPN_50) resistor r=24.8333
    rCPN_237 (CPN_48 CPN_61) resistor r=24.8333
    rCPN_236 (CPN_48 CPN_58) resistor r=24.8333
    rCPN_235 (CPN_48 CPN_66) resistor r=58.3583
    rCPN_234 (CPN_48 CPN_69) resistor r=58.3583
    rCPN_233 (CPN_48 CPN_74) resistor r=14.9
    rCPN_232 (CPN_48 CPN_53) resistor r=4.16253
    rCPN_231 (CPN_48 CPN_61) resistor r=4.16253
    rCPN_230 (CPN_48 CPN_50) resistor r=4.16253
    rCPN_229 (CPN_48 CPN_66) resistor r=4.16253
    rCPN_228 (CPN_48 CPN_74) resistor r=6.30933
    rCPN_227 (CPN_48 CPN_69) resistor r=6.30933
    rCPN_226 (CPN_48 CPN_58) resistor r=1.63969
    rCPN_225 (CPN_48 CPN_53) resistor r=24.8333
    rCPN_224 (CPN_48 CPN_50) resistor r=24.8333
    rCPN_223 (CPN_48 CPN_61) resistor r=24.8333
    rCPN_222 (CPN_48 CPN_58) resistor r=24.8333
    rCPN_221 (CPN_48 CPN_66) resistor r=58.3583
    rCPN_220 (CPN_48 MM10_ELT_g) resistor r=22.35
    rCPN_219 (CPN_48 CPN_74) resistor r=14.9
    rCPN_218 (CPN_48 CPN_368) resistor r=39.7333
    rCPN_217 (CPN_48 CPN_53) resistor r=4.16253
    rCPN_216 (CPN_48 CPN_61) resistor r=4.16253
    rCPN_215 (CPN_48 CPN_50) resistor r=4.16253
    rCPN_214 (CPN_48 CPN_66) resistor r=4.16253
    rCPN_213 (CPN_48 CPN_74) resistor r=6.30933
    rCPN_212 (CPN_48 CPN_69) resistor r=6.30933
    rCPN_211 (CPN_48 CPN_58) resistor r=1.63969
    rCPN_210 (CPN_69 MM10_ELT_g) resistor r=36.0083
    rCPN_209 (CPN_80 CPN_86) resistor r=202.392
    rCPN_208 (CPN_80 CPN_86) resistor r=4.16253
    rCPN_207 (CPN_80 CPN_86) resistor r=202.392
    rCPN_206 (CPN_80 CPN_86) resistor r=4.16253
    rCPN_205 (CPN_83 CPN_86) resistor r=202.392
    rCPN_204 (CPN_83 CPN_86) resistor r=4.16253
    rCPN_203 (CPN_83 CPN_86) resistor r=202.392
    rCPN_202 (CPN_83 CPN_86) resistor r=4.16253
    rCPN_201 (CPN_86 CPN_91) resistor r=24.8333
    rCPN_200 (CPN_86 CPN_88) resistor r=24.8333
    rCPN_199 (CPN_86 CPN_99) resistor r=24.8333
    rCPN_198 (CPN_86 CPN_96) resistor r=24.8333
    rCPN_197 (CPN_86 CPN_104) resistor r=14.9
    rCPN_196 (CPN_86 CPN_110) resistor r=202.392
    rCPN_195 (CPN_86 CPN_113) resistor r=202.392
    rCPN_194 (CPN_86 CPN_91) resistor r=4.16253
    rCPN_193 (CPN_86 CPN_99) resistor r=4.16253
    rCPN_192 (CPN_86 CPN_110) resistor r=6.30933
    rCPN_191 (CPN_86 CPN_104) resistor r=6.30933
    rCPN_190 (CPN_86 CPN_88) resistor r=1.63969
    rCPN_189 (CPN_86 CPN_96) resistor r=4.16253
    rCPN_188 (CPN_86 CPN_113) resistor r=4.16253
    rCPN_187 (CPN_86 CPN_91) resistor r=24.8333
    rCPN_186 (CPN_86 CPN_88) resistor r=24.8333
    rCPN_185 (CPN_86 CPN_99) resistor r=24.8333
    rCPN_184 (CPN_86 CPN_96) resistor r=24.8333
    rCPN_183 (CPN_86 CPN_381) resistor r=42.2167
    rCPN_182 (CPN_86 CPN_104) resistor r=14.9
    rCPN_181 (CPN_86 CPN_110) resistor r=202.392
    rCPN_180 (CPN_86 MM20_ELT_g) resistor r=7.45
    rCPN_179 (CPN_86 CPN_91) resistor r=4.16253
    rCPN_178 (CPN_86 CPN_99) resistor r=4.16253
    rCPN_177 (CPN_86 CPN_110) resistor r=6.30933
    rCPN_176 (CPN_86 CPN_104) resistor r=6.30933
    rCPN_175 (CPN_86 CPN_88) resistor r=1.63969
    rCPN_174 (CPN_86 CPN_96) resistor r=4.16253
    rCPN_173 (CPN_86 CPN_113) resistor r=4.16253
    rCPN_172 (CPN_113 MM20_ELT_g) resistor r=194.942
    rCPN_171 (CPN_118 CPN_124) resistor r=58.3583
    rCPN_170 (CPN_118 CPN_124) resistor r=4.16253
    rCPN_169 (CPN_118 CPN_124) resistor r=58.3583
    rCPN_168 (CPN_118 CPN_124) resistor r=4.16253
    rCPN_167 (CPN_121 CPN_124) resistor r=58.3583
    rCPN_166 (CPN_121 CPN_124) resistor r=6.30933
    rCPN_165 (CPN_121 CPN_124) resistor r=58.3583
    rCPN_164 (CPN_121 CPN_124) resistor r=6.30933
    rCPN_163 (CPN_124 CPN_126) resistor r=14.9
    rCPN_162 (CPN_124 CPN_149) resistor r=24.8333
    rCPN_161 (CPN_124 CPN_146) resistor r=24.8333
    rCPN_160 (CPN_124 CPN_157) resistor r=24.8333
    rCPN_159 (CPN_124 CPN_154) resistor r=24.8333
    rCPN_158 (CPN_124 CPN_178) resistor r=58.3583
    rCPN_157 (CPN_124 CPN_181) resistor r=58.3583
    rCPN_156 (CPN_124 CPN_149) resistor r=4.16253
    rCPN_155 (CPN_124 CPN_126) resistor r=6.30933
    rCPN_154 (CPN_124 CPN_157) resistor r=1.63969
    rCPN_153 (CPN_124 CPN_146) resistor r=4.16253
    rCPN_152 (CPN_124 CPN_178) resistor r=4.16253
    rCPN_151 (CPN_124 CPN_154) resistor r=4.16253
    rCPN_150 (CPN_124 CPN_181) resistor r=4.16253
    rCPN_149 (CPN_124 CPN_126) resistor r=14.9
    rCPN_148 (CPN_124 CPN_393) resistor r=39.7333
    rCPN_147 (CPN_124 CPN_149) resistor r=24.8333
    rCPN_146 (CPN_124 CPN_146) resistor r=24.8333
    rCPN_145 (CPN_124 CPN_157) resistor r=24.8333
    rCPN_144 (CPN_124 CPN_154) resistor r=24.8333
    rCPN_143 (CPN_124 CPN_178) resistor r=58.3583
    rCPN_142 (CPN_124 MM2_ELT_g) resistor r=7.45
    rCPN_141 (CPN_124 CPN_149) resistor r=4.16253
    rCPN_140 (CPN_124 CPN_126) resistor r=6.30933
    rCPN_139 (CPN_124 CPN_157) resistor r=1.63969
    rCPN_138 (CPN_124 CPN_146) resistor r=4.16253
    rCPN_137 (CPN_124 CPN_178) resistor r=4.16253
    rCPN_136 (CPN_124 CPN_154) resistor r=4.16253
    rCPN_135 (CPN_124 CPN_181) resistor r=4.16253
    rCPN_134 (CPN_132 CPN_135) resistor r=14.9
    rCPN_133 (CPN_132 CPN_135) resistor r=6.30933
    rCPN_132 (CPN_132 CPN_135) resistor r=14.9
    rCPN_131 (CPN_132 CPN_135) resistor r=6.30933
    rCPN_130 (CPN_135 CPN_138) resistor r=202.392
    rCPN_129 (CPN_135 CPN_141) resistor r=202.392
    rCPN_128 (CPN_135 CPN_165) resistor r=24.8333
    rCPN_127 (CPN_135 CPN_162) resistor r=24.8333
    rCPN_126 (CPN_135 CPN_173) resistor r=24.8333
    rCPN_125 (CPN_135 CPN_170) resistor r=24.8333
    rCPN_124 (CPN_135 CPN_186) resistor r=202.392
    rCPN_123 (CPN_135 CPN_189) resistor r=202.392
    rCPN_122 (CPN_135 CPN_138) resistor r=6.30933
    rCPN_121 (CPN_135 CPN_165) resistor r=1.63969
    rCPN_120 (CPN_135 CPN_173) resistor r=4.16253
    rCPN_119 (CPN_135 CPN_141) resistor r=4.16253
    rCPN_118 (CPN_135 CPN_162) resistor r=4.16253
    rCPN_117 (CPN_135 CPN_186) resistor r=4.16253
    rCPN_116 (CPN_135 CPN_170) resistor r=4.16253
    rCPN_115 (CPN_135 CPN_189) resistor r=4.16253
    rCPN_114 (CPN_135 CPN_395) resistor r=42.2167
    rCPN_113 (CPN_135 CPN_138) resistor r=202.392
    rCPN_112 (CPN_135 CPN_141) resistor r=202.392
    rCPN_111 (CPN_135 CPN_165) resistor r=24.8333
    rCPN_110 (CPN_135 CPN_162) resistor r=24.8333
    rCPN_109 (CPN_135 CPN_173) resistor r=24.8333
    rCPN_108 (CPN_135 CPN_170) resistor r=24.8333
    rCPN_107 (CPN_135 CPN_186) resistor r=202.392
    rCPN_106 (CPN_135 MM5_ELT_g) resistor r=7.45
    rCPN_105 (CPN_135 CPN_138) resistor r=6.30933
    rCPN_104 (CPN_135 CPN_165) resistor r=1.63969
    rCPN_103 (CPN_135 CPN_173) resistor r=4.16253
    rCPN_102 (CPN_135 CPN_141) resistor r=4.16253
    rCPN_101 (CPN_135 CPN_162) resistor r=4.16253
    rCPN_100 (CPN_135 CPN_186) resistor r=4.16253
    rCPN_99 (CPN_135 CPN_170) resistor r=4.16253
    rCPN_98 (CPN_135 CPN_189) resistor r=4.16253
    rCPN_97 (CPN_181 MM2_ELT_g) resistor r=50.9083
    rCPN_96 (CPN_189 MM5_ELT_g) resistor r=194.942
    rCPN_95 (CPN_261 CPN_263) resistor r=0.341142
    rCPN_94 (CPN_261 CPN_279) resistor r=0.0101024
    rCPN_93 (CPN_263 CPN_264) resistor r=8.66667
    rCPN_92 (CPN_263 CPN_266) resistor r=0.639641
    rCPN_91 (CPN_264 CPN) resistor r=32.3614
    rCPN_90 (CPN_266 CPN_267) resistor r=8.66667
    rCPN_89 (CPN_266 CPN_269) resistor r=0.426428
    rCPN_88 (CPN_267 CPN) resistor r=16.1807
    rCPN_87 (CPN_267 CPN_270) resistor r=32.3614
    rCPN_86 (CPN_269 CPN_270) resistor r=26
    rCPN_85 (CPN_272 CPN_273) resistor r=0.872755
    rCPN_84 (CPN_272 CPN_277) resistor r=0.000892559
    rCPN_83 (CPN_273 CPN_281) resistor r=0.000892559
    rCPN_82 (CPN_274 CPN_275) resistor r=0.000892559
    rCPN_81 (CPN_274 CPN_277) resistor r=0.131779
    rCPN_80 (CPN_275 CPN_450) resistor r=0.295721
    rCPN_79 (CPN_279 CPN_281) resistor r=0.13666
    rCPN_78 (CPN_283 CPN_285) resistor r=0.22123
    rCPN_77 (CPN_283 CPN_289) resistor r=0.0762583
    rCPN_76 (CPN_285 CPN_450) resistor r=0.75
    rCPN_75 (CPN_288 CPN_289) resistor r=1.20706
    rCPN_74 (CPN_288 CPN_310) resistor r=0.057794
    rCPN_73 (CPN_290 CPN_292) resistor r=0.0388123
    rCPN_72 (CPN_290 CPN_311) resistor r=0.057794
    rCPN_71 (CPN_292 CPN_293) resistor r=0.75
    rCPN_70 (CPN_293 CPN_446) resistor r=10
    rCPN_69 (CPN_295 CPN_296) resistor r=0.698622
    rCPN_68 (CPN_295 CPN_310) resistor r=0.0150197
    rCPN_67 (CPN_296 CPN_311) resistor r=0.0150197
    rCPN_66 (CPN_297 CPN_298) resistor r=0.974189
    rCPN_65 (CPN_297 CPN_306) resistor r=0.0762583
    rCPN_64 (CPN_298 CPN_310) resistor r=0.057794
    rCPN_63 (CPN_301 CPN_303) resistor r=0.0388123
    rCPN_62 (CPN_301 CPN_312) resistor r=0.057794
    rCPN_61 (CPN_303 CPN_304) resistor r=0.75
    rCPN_60 (CPN_304 CPN_443) resistor r=10
    rCPN_59 (CPN_306 CPN_307) resistor r=0.698622
    rCPN_58 (CPN_307 CPN_312) resistor r=0.0150197
    rCPN_57 (CPN_368 CPN_446) resistor r=5.57865
    rCPN_56 (CPN_381 CPN_429) resistor r=9.29775
    rCPN_55 (CPN_393 CPN_435) resistor r=10.0997
    rCPN_54 (CPN_395 CPN_435) resistor r=10.0997
    rCPN_53 (CPN_429 CPN_443) resistor r=10.8364
    rCPN_52 (CPN_434 CPN_435) resistor r=0.877078
    rCPN_51 (CPN_434 CPN_443) resistor r=37.9273
    rCPN_50 (CPN_449 CPN_450) resistor r=13
    rCPN_49 (CPN_449 MM22_ELT_d) resistor r=8.44
    rCP_96 (CP_22 CP_28) resistor r=58.3583
    rCP_95 (CP_22 CP_28) resistor r=4.16253
    rCP_94 (CP_22 CP_28) resistor r=58.3583
    rCP_93 (CP_22 CP_28) resistor r=4.16253
    rCP_92 (CP_25 CP_28) resistor r=58.3583
    rCP_91 (CP_25 CP_28) resistor r=6.30933
    rCP_90 (CP_25 CP_28) resistor r=58.3583
    rCP_89 (CP_25 CP_28) resistor r=6.30933
    rCP_88 (CP_28 CP_30) resistor r=14.9
    rCP_87 (CP_28 CP_53) resistor r=24.8333
    rCP_86 (CP_28 CP_50) resistor r=24.8333
    rCP_85 (CP_28 CP_61) resistor r=24.8333
    rCP_84 (CP_28 CP_58) resistor r=24.8333
    rCP_83 (CP_28 CP_82) resistor r=58.3583
    rCP_82 (CP_28 CP_85) resistor r=58.3583
    rCP_81 (CP_28 CP_53) resistor r=4.16253
    rCP_80 (CP_28 CP_30) resistor r=6.30933
    rCP_79 (CP_28 CP_61) resistor r=1.63969
    rCP_78 (CP_28 CP_50) resistor r=4.16253
    rCP_77 (CP_28 CP_82) resistor r=4.16253
    rCP_76 (CP_28 CP_58) resistor r=4.16253
    rCP_75 (CP_28 CP_85) resistor r=4.16253
    rCP_74 (CP_28 CP_30) resistor r=14.9
    rCP_73 (CP_28 CP_162) resistor r=40.975
    rCP_72 (CP_28 CP_53) resistor r=24.8333
    rCP_71 (CP_28 CP_50) resistor r=24.8333
    rCP_70 (CP_28 CP_61) resistor r=24.8333
    rCP_69 (CP_28 CP_58) resistor r=24.8333
    rCP_68 (CP_28 CP_82) resistor r=58.3583
    rCP_67 (CP_28 MM22_ELT_g) resistor r=7.45
    rCP_66 (CP_28 CP_53) resistor r=4.16253
    rCP_65 (CP_28 CP_30) resistor r=6.30933
    rCP_64 (CP_28 CP_61) resistor r=1.63969
    rCP_63 (CP_28 CP_50) resistor r=4.16253
    rCP_62 (CP_28 CP_82) resistor r=4.16253
    rCP_61 (CP_28 CP_58) resistor r=4.16253
    rCP_60 (CP_28 CP_85) resistor r=4.16253
    rCP_59 (CP_36 CP_39) resistor r=14.9
    rCP_58 (CP_36 CP_39) resistor r=6.30933
    rCP_57 (CP_36 CP_39) resistor r=14.9
    rCP_56 (CP_36 CP_39) resistor r=6.30933
    rCP_55 (CP_39 CP_42) resistor r=202.392
    rCP_54 (CP_39 CP_45) resistor r=202.392
    rCP_53 (CP_39 CP_69) resistor r=24.8333
    rCP_52 (CP_39 CP_66) resistor r=24.8333
    rCP_51 (CP_39 CP_77) resistor r=24.8333
    rCP_50 (CP_39 CP_74) resistor r=24.8333
    rCP_49 (CP_39 CP_90) resistor r=202.392
    rCP_48 (CP_39 CP_93) resistor r=202.392
    rCP_47 (CP_39 CP_42) resistor r=6.30933
    rCP_46 (CP_39 CP_69) resistor r=1.63969
    rCP_45 (CP_39 CP_77) resistor r=4.16253
    rCP_44 (CP_39 CP_45) resistor r=4.16253
    rCP_43 (CP_39 CP_66) resistor r=4.16253
    rCP_42 (CP_39 CP_90) resistor r=4.16253
    rCP_41 (CP_39 CP_74) resistor r=4.16253
    rCP_40 (CP_39 CP_93) resistor r=4.16253
    rCP_39 (CP_39 CP_164) resistor r=40.975
    rCP_38 (CP_39 CP_42) resistor r=202.392
    rCP_37 (CP_39 CP_45) resistor r=202.392
    rCP_36 (CP_39 CP_69) resistor r=24.8333
    rCP_35 (CP_39 CP_66) resistor r=24.8333
    rCP_34 (CP_39 CP_77) resistor r=24.8333
    rCP_33 (CP_39 CP_74) resistor r=24.8333
    rCP_32 (CP_39 CP_90) resistor r=202.392
    rCP_31 (CP_39 MM21_ELT_g) resistor r=7.45
    rCP_30 (CP_39 CP_42) resistor r=6.30933
    rCP_29 (CP_39 CP_69) resistor r=1.63969
    rCP_28 (CP_39 CP_77) resistor r=4.16253
    rCP_27 (CP_39 CP_45) resistor r=4.16253
    rCP_26 (CP_39 CP_66) resistor r=4.16253
    rCP_25 (CP_39 CP_90) resistor r=4.16253
    rCP_24 (CP_39 CP_74) resistor r=4.16253
    rCP_23 (CP_39 CP_93) resistor r=4.16253
    rCP_22 (CP_85 MM22_ELT_g) resistor r=50.9083
    rCP_21 (CP_93 MM21_ELT_g) resistor r=194.942
    rCP_20 (CP_132 CP_133) resistor r=10
    rCP_19 (CP_132 CP) resistor r=0.0875783
    rCP_18 (CP_133 CP_196) resistor r=13.5455
    rCP_17 (CP_162 CP_197) resistor r=3.725
    rCP_16 (CP_164 CP_197) resistor r=3.725
    rCP_15 (CP_196 CP_197) resistor r=3.725
ends DDFSND1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: TIEH_LVT_ELT
// View name: calibre
subckt TIEH_LVT_ELT VDD VSS ZN
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciZN_1 (ZN_2 VSS) capacitor c=1.77046e-16
    ciZN_0 (ZN_3 VSS) capacitor c=3.31306e-16
    cinet5_13 (net5_22 VSS) capacitor c=4.28147e-18
    cinet5_12 (net5_28 VSS) capacitor c=8.53685e-17
    cinet5_11 (net5_39 VSS) capacitor c=5.74039e-16
    cinet5_10 (net5_45 VSS) capacitor c=4.73887e-18
    cinet5_9 (net5_50 VSS) capacitor c=6.69399e-18
    cinet5_8 (net5_66 VSS) capacitor c=8.49341e-18
    cinet5_7 (net5_74 VSS) capacitor c=1.51948e-17
    cinet5_6 (net5_82 VSS) capacitor c=2.22299e-18
    cinet5_5 (net5_93 VSS) capacitor c=2.22299e-18
    cinet5_4 (net5_131 VSS) capacitor c=3.26537e-17
    cinet5_3 (net5_138 VSS) capacitor c=4.56834e-17
    cinet5_2 (net5_139 VSS) capacitor c=6.09619e-18
    cinet5_1 (net5_199 VSS) capacitor c=3.16009e-17
    cinet5_0 (net5_200 VSS) capacitor c=7.65046e-18
    ciVDD_6 (VDD_4 VSS) capacitor c=1.33484e-16
    ciVDD_5 (VDD_13 VSS) capacitor c=2.63453e-17
    ciVDD_4 (VDD_18 VSS) capacitor c=6.301e-17
    ciVDD_3 (VDD_30 VSS) capacitor c=1.11099e-18
    ciVDD_2 (VDD_32 VSS) capacitor c=1.07074e-18
    ciVDD_1 (VDD_35 VSS) capacitor c=1.32762e-17
    ciVDD_0 (VDD_36 VSS) capacitor c=2.16736e-16
    ciVSS_4 (VSS_4 VSS) capacitor c=6.07904e-17
    ciVSS_3 (VSS_10 VSS) capacitor c=2.63453e-17
    ciVSS_2 (VSS_15 VSS) capacitor c=6.23008e-17
    ciVSS_1 (VSS_27 VSS) capacitor c=3.38628e-18
    ciVSS_0 (VSS_31 VSS) capacitor c=6.99899e-17
    rZN_10 (ZN_2 ZN_3) resistor r=8.66667
    rZN_9 (ZN_2 ZN) resistor r=0.46307
    rZN_8 (ZN_3 MM1_ELT_d) resistor r=32.3614
    rZN_7 (ZN ZN_8) resistor r=0.175647
    rZN_6 (ZN_8 ZN_9) resistor r=8.66667
    rZN_5 (ZN_8 ZN_11) resistor r=0.425811
    rZN_4 (ZN_9 MM1_ELT_d) resistor r=16.1807
    rZN_3 (ZN_9 ZN_12) resistor r=32.3614
    rZN_2 (ZN_11 ZN_12) resistor r=26
    rnet5_100 (MM0_ELT_d net5) resistor r=0.01
    rnet5_99 (net5_22 net5_28) resistor r=58.3583
    rnet5_98 (net5_22 net5_28) resistor r=4.16253
    rnet5_97 (net5_22 net5_28) resistor r=58.3583
    rnet5_96 (net5_22 net5_28) resistor r=4.16253
    rnet5_95 (net5_25 net5_28) resistor r=58.3583
    rnet5_94 (net5_25 net5_28) resistor r=6.30933
    rnet5_93 (net5_25 net5_28) resistor r=58.3583
    rnet5_92 (net5_25 net5_28) resistor r=6.30933
    rnet5_91 (net5_28 net5_30) resistor r=14.9
    rnet5_90 (net5_28 net5_53) resistor r=24.8333
    rnet5_89 (net5_28 net5_50) resistor r=24.8333
    rnet5_88 (net5_28 net5_61) resistor r=24.8333
    rnet5_87 (net5_28 net5_58) resistor r=24.8333
    rnet5_86 (net5_28 net5_82) resistor r=58.3583
    rnet5_85 (net5_28 net5_85) resistor r=58.3583
    rnet5_84 (net5_28 net5_53) resistor r=4.16253
    rnet5_83 (net5_28 net5_30) resistor r=6.30933
    rnet5_82 (net5_28 net5_61) resistor r=1.63969
    rnet5_81 (net5_28 net5_50) resistor r=4.16253
    rnet5_80 (net5_28 net5_82) resistor r=4.16253
    rnet5_79 (net5_28 net5_58) resistor r=4.16253
    rnet5_78 (net5_28 net5_85) resistor r=4.16253
    rnet5_77 (net5_28 net5_30) resistor r=14.9
    rnet5_76 (net5_28 net5_165) resistor r=40.975
    rnet5_75 (net5_28 net5_53) resistor r=24.8333
    rnet5_74 (net5_28 net5_50) resistor r=24.8333
    rnet5_73 (net5_28 net5_61) resistor r=24.8333
    rnet5_72 (net5_28 net5_58) resistor r=24.8333
    rnet5_71 (net5_28 net5_82) resistor r=58.3583
    rnet5_70 (net5_28 MM0_ELT_g) resistor r=7.45
    rnet5_69 (net5_28 net5_53) resistor r=4.16253
    rnet5_68 (net5_28 net5_30) resistor r=6.30933
    rnet5_67 (net5_28 net5_61) resistor r=1.63969
    rnet5_66 (net5_28 net5_50) resistor r=4.16253
    rnet5_65 (net5_28 net5_82) resistor r=4.16253
    rnet5_64 (net5_28 net5_58) resistor r=4.16253
    rnet5_63 (net5_28 net5_85) resistor r=4.16253
    rnet5_62 (net5_36 net5_39) resistor r=14.9
    rnet5_61 (net5_36 net5_39) resistor r=6.30933
    rnet5_60 (net5_36 net5_39) resistor r=14.9
    rnet5_59 (net5_36 net5_39) resistor r=6.30933
    rnet5_58 (net5_39 net5_42) resistor r=202.392
    rnet5_57 (net5_39 net5_45) resistor r=202.392
    rnet5_56 (net5_39 net5_69) resistor r=24.8333
    rnet5_55 (net5_39 net5_66) resistor r=24.8333
    rnet5_54 (net5_39 net5_77) resistor r=24.8333
    rnet5_53 (net5_39 net5_74) resistor r=24.8333
    rnet5_52 (net5_39 net5_90) resistor r=202.392
    rnet5_51 (net5_39 net5_93) resistor r=202.392
    rnet5_50 (net5_39 net5_42) resistor r=6.30933
    rnet5_49 (net5_39 net5_69) resistor r=1.63969
    rnet5_48 (net5_39 net5_77) resistor r=4.16253
    rnet5_47 (net5_39 net5_45) resistor r=4.16253
    rnet5_46 (net5_39 net5_66) resistor r=4.16253
    rnet5_45 (net5_39 net5_90) resistor r=4.16253
    rnet5_44 (net5_39 net5_74) resistor r=4.16253
    rnet5_43 (net5_39 net5_93) resistor r=4.16253
    rnet5_42 (net5_39 net5_167) resistor r=40.975
    rnet5_41 (net5_39 net5_42) resistor r=202.392
    rnet5_40 (net5_39 net5_45) resistor r=202.392
    rnet5_39 (net5_39 net5_69) resistor r=24.8333
    rnet5_38 (net5_39 net5_66) resistor r=24.8333
    rnet5_37 (net5_39 net5_77) resistor r=24.8333
    rnet5_36 (net5_39 net5_74) resistor r=24.8333
    rnet5_35 (net5_39 net5_90) resistor r=202.392
    rnet5_34 (net5_39 MM1_ELT_g) resistor r=7.45
    rnet5_33 (net5_39 net5_42) resistor r=6.30933
    rnet5_32 (net5_39 net5_69) resistor r=1.63969
    rnet5_31 (net5_39 net5_77) resistor r=4.16253
    rnet5_30 (net5_39 net5_45) resistor r=4.16253
    rnet5_29 (net5_39 net5_66) resistor r=4.16253
    rnet5_28 (net5_39 net5_90) resistor r=4.16253
    rnet5_27 (net5_39 net5_74) resistor r=4.16253
    rnet5_26 (net5_39 net5_93) resistor r=4.16253
    rnet5_25 (net5_85 MM0_ELT_g) resistor r=50.9083
    rnet5_24 (net5_93 MM1_ELT_g) resistor r=194.942
    rnet5_23 (net5_131 net5_133) resistor r=0.188072
    rnet5_22 (net5_131 net5_136) resistor r=0.107063
    rnet5_21 (net5_133 net5_134) resistor r=10
    rnet5_20 (net5_134 net5_199) resistor r=13.5455
    rnet5_19 (net5_136 net5_138) resistor r=0.628071
    rnet5_18 (net5_138 net5_139) resistor r=13
    rnet5_17 (net5_139 net5) resistor r=8.44
    rnet5_16 (net5_165 net5_200) resistor r=3.725
    rnet5_15 (net5_167 net5_200) resistor r=3.725
    rnet5_14 (net5_199 net5_200) resistor r=3.725
    rVDD_34 (MM1_ELT_b VDD_18) resistor r=26
    rVDD_33 (MM1_ELT_b VDD_16) resistor r=11.2533
    rVDD_32 (VDD_2 VDD_11) resistor r=0.489683
    rVDD_31 (VDD_2 VDD_24) resistor r=0.119057
    rVDD_30 (VDD_4 VDD_12) resistor r=8.66667
    rVDD_29 (VDD_4 VDD_8) resistor r=0.638717
    rVDD_28 (VDD_8 VDD_12) resistor r=8.66667
    rVDD_27 (VDD_8 VDD_11) resistor r=0.638717
    rVDD_26 (VDD_11 VDD_12) resistor r=8.66667
    rVDD_25 (VDD_12 MM1_ELT_s) resistor r=1.847
    rVDD_24 (VDD_12 VDD_36) resistor r=20.317
    rVDD_23 (VDD_13 VDD_15) resistor r=0.0335603
    rVDD_22 (VDD_13 VDD_24) resistor r=0.0177672
    rVDD_21 (VDD_15 VDD_16) resistor r=8.66667
    rVDD_20 (VDD_15 VDD_18) resistor r=0.157931
    rVDD_19 (VDD VDD_24) resistor r=0.0513276
    rVDD_18 (MM1_ELT_s VDD_30) resistor r=2.55965
    rVDD_17 (MM1_ELT_s VDD_32) resistor r=12.3172
    rVDD_16 (MM1_ELT_s VDD_32) resistor r=1.62887
    rVDD_15 (MM1_ELT_s VDD_35) resistor r=6.12113
    rVDD_14 (VDD_28 VDD_30) resistor r=14.4784
    rVDD_13 (VDD_28 VDD_34) resistor r=9.04062
    rVDD_12 (VDD_29 VDD_30) resistor r=14.4784
    rVDD_11 (VDD_29 VDD_36) resistor r=9.48555
    rVDD_10 (VDD_31 VDD_32) resistor r=12.3172
    rVDD_9 (VDD_31 VDD_33) resistor r=9.04595
    rVDD_8 (VDD_33 VDD_35) resistor r=31.2341
    rVDD_7 (VDD_34 VDD_35) resistor r=31.2341
    rVSS_30 (MM0_ELT_b VSS_15) resistor r=26
    rVSS_29 (MM0_ELT_b VSS_13) resistor r=10.7871
    rVSS_28 (VSS_2 VSS_4) resistor r=0.404521
    rVSS_27 (VSS_2 VSS_21) resistor r=0.119057
    rVSS_26 (VSS_4 VSS_8) resistor r=8.66667
    rVSS_25 (VSS_4 VSS_7) resistor r=0.425811
    rVSS_24 (VSS_7 VSS_8) resistor r=26
    rVSS_23 (VSS_8 MM0_ELT_s) resistor r=2.90692
    rVSS_22 (VSS_8 VSS_31) resistor r=12.1406
    rVSS_21 (VSS_10 VSS_12) resistor r=0.0335603
    rVSS_20 (VSS_10 VSS_21) resistor r=0.0177672
    rVSS_19 (VSS_12 VSS_13) resistor r=8.66667
    rVSS_18 (VSS_12 VSS_15) resistor r=0.157931
    rVSS_17 (VSS VSS_21) resistor r=0.0493534
    rVSS_16 (MM0_ELT_s VSS_25) resistor r=2.67027
    rVSS_15 (MM0_ELT_s VSS_27) resistor r=12.8495
    rVSS_14 (MM0_ELT_s VSS_27) resistor r=1.69926
    rVSS_13 (MM0_ELT_s VSS_30) resistor r=4.557
    rVSS_12 (VSS_23 VSS_25) resistor r=15.1041
    rVSS_11 (VSS_23 VSS_28) resistor r=9.43134
    rVSS_10 (VSS_24 VSS_25) resistor r=15.1041
    rVSS_9 (VSS_24 VSS_31) resistor r=9.89549
    rVSS_8 (VSS_26 VSS_27) resistor r=12.8495
    rVSS_7 (VSS_26 VSS_29) resistor r=9.4369
    rVSS_6 (VSS_28 VSS_30) resistor r=21.1301
    rVSS_5 (VSS_29 VSS_30) resistor r=21.1301
ends TIEH_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: INVD2_LVT_ELT
// View name: calibre
subckt INVD2_LVT_ELT I ZN VDD VSS
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciZN_20 (ZN_3 VSS) capacitor c=5.76004e-17
    ciZN_19 (ZN_4 VSS) capacitor c=1.11612e-16
    ciZN_18 (ZN_8 VSS) capacitor c=1.90766e-16
    ciZN_17 (ZN_9 VSS) capacitor c=3.2986e-16
    ciZN_16 (ZN_17 VSS) capacitor c=2.07429e-17
    ciZN_15 (ZN_18 VSS) capacitor c=1.11747e-17
    ciZN_14 (ZN_19 VSS) capacitor c=2.07679e-17
    ciZN_13 (ZN_20 VSS) capacitor c=1.11747e-17
    ciZN_12 (ZN_22 VSS) capacitor c=9.95552e-18
    ciZN_11 (ZN_24 VSS) capacitor c=9.95552e-18
    ciZN_10 (ZN_25 VSS) capacitor c=2.52131e-17
    ciZN_9 (ZN_29 VSS) capacitor c=4.75788e-17
    ciZN_8 (ZN_30 VSS) capacitor c=1.1105e-16
    ciZN_7 (ZN_34 VSS) capacitor c=1.74039e-16
    ciZN_6 (ZN_35 VSS) capacitor c=3.2943e-16
    ciZN_5 (ZN VSS) capacitor c=2.07941e-17
    ciZN_4 (ZN_48 VSS) capacitor c=2.49019e-17
    ciZN_3 (ZN_49 VSS) capacitor c=1.10706e-17
    ciZN_2 (ZN_52 VSS) capacitor c=1.85237e-17
    ciZN_1 (ZN_56 VSS) capacitor c=1.55842e-17
    ciZN_0 (ZN_58 VSS) capacitor c=4.06021e-18
    ciVDD_12 (VDD_2 VSS) capacitor c=6.33994e-17
    ciVDD_11 (VDD_11 VSS) capacitor c=2.47209e-16
    ciVDD_10 (VDD_19 VSS) capacitor c=2.05041e-17
    ciVDD_9 (VDD_25 VSS) capacitor c=7.3515e-17
    ciVDD_8 (VDD_28 VSS) capacitor c=3.58509e-18
    ciVDD_7 (VDD_34 VSS) capacitor c=1.32762e-17
    ciVDD_6 (VDD_36 VSS) capacitor c=4.66658e-18
    ciVDD_5 (VDD_39 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_43 VSS) capacitor c=1.11099e-18
    ciVDD_3 (VDD_44 VSS) capacitor c=5.8958e-18
    ciVDD_2 (VDD_45 VSS) capacitor c=3.41183e-18
    ciVDD_1 (VDD_48 VSS) capacitor c=1.62337e-17
    ciVDD_0 (VDD_50 VSS) capacitor c=3.75299e-16
    ciVSS_8 (VSS_2 VSS) capacitor c=6.1414e-17
    ciVSS_7 (VSS_11 VSS) capacitor c=7.43497e-17
    ciVSS_6 (VSS_12 VSS) capacitor c=1.20618e-16
    ciVSS_5 (VSS_19 VSS) capacitor c=7.12669e-17
    ciVSS_4 (VSS_22 VSS) capacitor c=3.58509e-18
    ciVSS_3 (VSS_31 VSS) capacitor c=3.98382e-18
    ciVSS_2 (VSS_36 VSS) capacitor c=5.8958e-18
    ciVSS_1 (VSS_37 VSS) capacitor c=2.3411e-18
    ciVSS_0 (VSS_40 VSS) capacitor c=1.96647e-18
    ciI_26 (I_42 VSS) capacitor c=2.22299e-18
    ciI_25 (I_48 VSS) capacitor c=1.78856e-16
    ciI_24 (I_53 VSS) capacitor c=2.22299e-18
    ciI_23 (I_56 VSS) capacitor c=5.63653e-16
    ciI_22 (I_58 VSS) capacitor c=2.23768e-17
    ciI_21 (I_66 VSS) capacitor c=2.07832e-17
    ciI_20 (I_74 VSS) capacitor c=1.44502e-17
    ciI_19 (I_82 VSS) capacitor c=1.51948e-17
    ciI_18 (I_90 VSS) capacitor c=4.21073e-18
    ciI_17 (I_113 VSS) capacitor c=4.28147e-18
    ciI_16 (I_118 VSS) capacitor c=4.28147e-18
    ciI_15 (I_124 VSS) capacitor c=1.80213e-16
    ciI_14 (I_135 VSS) capacitor c=5.67368e-16
    ciI_13 (I_141 VSS) capacitor c=4.28147e-18
    ciI_12 (I_146 VSS) capacitor c=2.23559e-17
    ciI_11 (I_154 VSS) capacitor c=2.22432e-17
    ciI_10 (I_162 VSS) capacitor c=1.37545e-17
    ciI_9 (I_170 VSS) capacitor c=1.51948e-17
    ciI_8 (I_178 VSS) capacitor c=2.11871e-18
    ciI_7 (I_181 VSS) capacitor c=3.9912e-18
    ciI_6 (I_186 VSS) capacitor c=4.02575e-18
    ciI_5 (I_189 VSS) capacitor c=2.22299e-18
    ciI_4 (I VSS) capacitor c=4.42846e-17
    ciI_3 (I_342 VSS) capacitor c=2.6273e-17
    ciI_2 (I_384 VSS) capacitor c=2.70107e-17
    ciI_1 (I_385 VSS) capacitor c=2.80174e-18
    ciI_0 (I_390 VSS) capacitor c=1.50204e-17
    rZN_68 (ZN_1 ZN_3) resistor r=0.435949
    rZN_67 (ZN_1 ZN_18) resistor r=0.0958609
    rZN_66 (ZN_3 ZN_4) resistor r=13
    rZN_65 (ZN_4 MM0_ELT_d) resistor r=8.44
    rZN_64 (ZN_6 ZN_8) resistor r=0.521012
    rZN_63 (ZN_6 ZN_20) resistor r=0.0958609
    rZN_62 (ZN_8 ZN_9) resistor r=8.66667
    rZN_61 (ZN_8 ZN_11) resistor r=0.637974
    rZN_60 (ZN_9 MM2_ELT_d) resistor r=32.3614
    rZN_59 (ZN_11 ZN_12) resistor r=8.66667
    rZN_58 (ZN_11 ZN_14) resistor r=0.425316
    rZN_57 (ZN_12 MM2_ELT_d) resistor r=16.1807
    rZN_56 (ZN_12 ZN_15) resistor r=32.3614
    rZN_55 (ZN_14 ZN_15) resistor r=26
    rZN_54 (ZN_17 ZN_18) resistor r=0.0924918
    rZN_53 (ZN_17 ZN_21) resistor r=0.0958609
    rZN_52 (ZN_19 ZN_20) resistor r=0.0924918
    rZN_51 (ZN_19 ZN_24) resistor r=0.0958609
    rZN_50 (ZN_21 ZN_22) resistor r=0.162132
    rZN_49 (ZN_22 ZN_49) resistor r=0.0726503
    rZN_48 (ZN_23 ZN_24) resistor r=0.162132
    rZN_47 (ZN_23 ZN_49) resistor r=0.0726503
    rZN_46 (ZN_25 ZN_26) resistor r=0.368962
    rZN_45 (ZN_25 ZN_58) resistor r=0.0188806
    rZN_44 (ZN_26 ZN_49) resistor r=0.0188806
    rZN_43 (ZN_27 ZN_29) resistor r=0.303038
    rZN_42 (ZN_27 ZN_50) resistor r=0.0100761
    rZN_41 (ZN_29 ZN_30) resistor r=13
    rZN_40 (ZN_30 MM3_ELT_d) resistor r=8.44
    rZN_39 (ZN_32 ZN_34) resistor r=0.340253
    rZN_38 (ZN_32 ZN_54) resistor r=0.0100761
    rZN_37 (ZN_34 ZN_35) resistor r=8.66667
    rZN_36 (ZN_34 ZN_37) resistor r=0.637974
    rZN_35 (ZN_35 MM1_ELT_d) resistor r=32.3614
    rZN_34 (ZN_37 ZN_38) resistor r=8.66667
    rZN_33 (ZN_37 ZN_40) resistor r=0.425316
    rZN_32 (ZN_38 MM1_ELT_d) resistor r=16.1807
    rZN_31 (ZN_38 ZN_41) resistor r=32.3614
    rZN_30 (ZN_40 ZN_41) resistor r=26
    rZN_29 (ZN_43 ZN) resistor r=0.155776
    rZN_28 (ZN_43 ZN_52) resistor r=0.0100761
    rZN_27 (ZN_44 ZN) resistor r=0.0924918
    rZN_26 (ZN_44 ZN_58) resistor r=0.0726503
    rZN_25 (ZN_47 ZN_48) resistor r=0.292079
    rZN_24 (ZN_47 ZN_58) resistor r=0.0726503
    rZN_23 (ZN_48 ZN_56) resistor r=0.0100761
    rZN_22 (ZN_50 ZN_52) resistor r=0.127907
    rZN_21 (ZN_54 ZN_56) resistor r=0.126568
    rVDD_58 (MM1_ELT_b MM2_ELT_b) resistor r=0.01
    rVDD_57 (MM2_ELT_b VDD_22) resistor r=8.66667
    rVDD_56 (MM2_ELT_b VDD_25) resistor r=26
    rVDD_55 (MM2_ELT_b VDD_8) resistor r=45.0133
    rVDD_54 (VDD_2 VDD_7) resistor r=0.114475
    rVDD_53 (VDD_2 VDD_28) resistor r=0.0221239
    rVDD_52 (VDD VDD_7) resistor r=0.102633
    rVDD_51 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_50 (VDD_9 VDD_18) resistor r=0.41442
    rVDD_49 (VDD_9 VDD_28) resistor r=0.0880129
    rVDD_48 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_47 (VDD_11 VDD_15) resistor r=0.700428
    rVDD_46 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_45 (VDD_15 VDD_18) resistor r=0.700428
    rVDD_44 (VDD_18 VDD_19) resistor r=8.66667
    rVDD_43 (VDD_19 MM1_ELT_s) resistor r=0.850556
    rVDD_42 (VDD_19 MM2_ELT_s) resistor r=0.850556
    rVDD_41 (VDD_19 VDD_49) resistor r=13.0961
    rVDD_40 (VDD_20 VDD_22) resistor r=0.0868434
    rVDD_39 (VDD_20 VDD_28) resistor r=0.0221239
    rVDD_38 (VDD_22 VDD_25) resistor r=0.157897
    rVDD_37 (VDD_31 VDD_34) resistor r=31.2341
    rVDD_36 (VDD_31 VDD_35) resistor r=9.04595
    rVDD_35 (VDD_32 VDD_34) resistor r=31.2341
    rVDD_34 (VDD_32 VDD_38) resistor r=9.04062
    rVDD_33 (MM2_ELT_s VDD_34) resistor r=6.12113
    rVDD_32 (MM2_ELT_s VDD_36) resistor r=12.3172
    rVDD_31 (MM2_ELT_s VDD_36) resistor r=1.62887
    rVDD_30 (MM2_ELT_s VDD_39) resistor r=2.55965
    rVDD_29 (VDD_35 VDD_36) resistor r=12.3172
    rVDD_28 (VDD_37 VDD_39) resistor r=14.4784
    rVDD_27 (VDD_37 VDD_50) resistor r=10.5593
    rVDD_26 (VDD_38 VDD_39) resistor r=14.4784
    rVDD_25 (MM1_ELT_s VDD_43) resistor r=2.55965
    rVDD_24 (MM1_ELT_s VDD_45) resistor r=12.3172
    rVDD_23 (MM1_ELT_s VDD_45) resistor r=1.62887
    rVDD_22 (MM1_ELT_s VDD_48) resistor r=6.12113
    rVDD_21 (VDD_41 VDD_43) resistor r=14.4784
    rVDD_20 (VDD_41 VDD_47) resistor r=9.04062
    rVDD_19 (VDD_42 VDD_43) resistor r=14.4784
    rVDD_18 (VDD_42 VDD_50) resistor r=10.5593
    rVDD_17 (VDD_44 VDD_45) resistor r=12.3172
    rVDD_16 (VDD_44 VDD_46) resistor r=9.04595
    rVDD_15 (VDD_46 VDD_48) resistor r=31.2341
    rVDD_14 (VDD_47 VDD_48) resistor r=31.2341
    rVDD_13 (VDD_49 VDD_50) resistor r=0.730683
    rVSS_50 (MM3_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_49 (MM0_ELT_b VSS_16) resistor r=8.66667
    rVSS_48 (MM0_ELT_b VSS_19) resistor r=26
    rVSS_47 (MM0_ELT_b VSS_8) resistor r=43.1485
    rVSS_46 (VSS_2 VSS_7) resistor r=0.114475
    rVSS_45 (VSS_2 VSS_22) resistor r=0.0221239
    rVSS_44 (VSS VSS_7) resistor r=0.100659
    rVSS_43 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_42 (VSS_9 VSS_11) resistor r=0.443605
    rVSS_41 (VSS_9 VSS_22) resistor r=0.0880129
    rVSS_40 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_39 (VSS_12 MM3_ELT_s) resistor r=2.27123
    rVSS_38 (VSS_12 MM0_ELT_s) resistor r=2.27123
    rVSS_37 (VSS_12 VSS_41) resistor r=8.4738
    rVSS_36 (VSS_14 VSS_16) resistor r=0.0868434
    rVSS_35 (VSS_14 VSS_22) resistor r=0.0221239
    rVSS_34 (VSS_16 VSS_19) resistor r=0.157897
    rVSS_33 (VSS_23 VSS_26) resistor r=21.1301
    rVSS_32 (VSS_23 VSS_28) resistor r=9.43134
    rVSS_31 (VSS_24 VSS_26) resistor r=21.1301
    rVSS_30 (VSS_24 VSS_30) resistor r=9.4369
    rVSS_29 (MM0_ELT_s VSS_26) resistor r=4.557
    rVSS_28 (MM0_ELT_s VSS_29) resistor r=2.67027
    rVSS_27 (MM0_ELT_s VSS_31) resistor r=12.8495
    rVSS_26 (MM0_ELT_s VSS_31) resistor r=1.69926
    rVSS_25 (VSS_27 VSS_29) resistor r=15.1041
    rVSS_24 (VSS_27 VSS_42) resistor r=11.0157
    rVSS_23 (VSS_28 VSS_29) resistor r=15.1041
    rVSS_22 (VSS_30 VSS_31) resistor r=12.8495
    rVSS_21 (MM3_ELT_s VSS_35) resistor r=2.67027
    rVSS_20 (MM3_ELT_s VSS_37) resistor r=12.8495
    rVSS_19 (MM3_ELT_s VSS_37) resistor r=1.69926
    rVSS_18 (MM3_ELT_s VSS_40) resistor r=4.557
    rVSS_17 (VSS_33 VSS_35) resistor r=15.1041
    rVSS_16 (VSS_33 VSS_38) resistor r=9.43134
    rVSS_15 (VSS_34 VSS_35) resistor r=15.1041
    rVSS_14 (VSS_34 VSS_42) resistor r=11.0157
    rVSS_13 (VSS_36 VSS_37) resistor r=12.8495
    rVSS_12 (VSS_36 VSS_39) resistor r=9.4369
    rVSS_11 (VSS_38 VSS_40) resistor r=21.1301
    rVSS_10 (VSS_39 VSS_40) resistor r=21.1301
    rVSS_9 (VSS_41 VSS_42) resistor r=0.762262
    rI_189 (I_42 I_48) resistor r=58.3583
    rI_188 (I_42 I_48) resistor r=4.16253
    rI_187 (I_42 I_48) resistor r=58.3583
    rI_186 (I_42 I_48) resistor r=4.16253
    rI_185 (I_45 I_48) resistor r=58.3583
    rI_184 (I_45 I_48) resistor r=4.16253
    rI_183 (I_45 I_48) resistor r=58.3583
    rI_182 (I_45 I_48) resistor r=4.16253
    rI_181 (I_48 I_61) resistor r=24.8333
    rI_180 (I_48 I_58) resistor r=24.8333
    rI_179 (I_48 I_69) resistor r=24.8333
    rI_178 (I_48 I_66) resistor r=24.8333
    rI_177 (I_48 I_90) resistor r=58.3583
    rI_176 (I_48 I_93) resistor r=58.3583
    rI_175 (I_48 I_98) resistor r=14.9
    rI_174 (I_48 I_61) resistor r=4.16253
    rI_173 (I_48 I_69) resistor r=4.16253
    rI_172 (I_48 I_58) resistor r=4.16253
    rI_171 (I_48 I_90) resistor r=4.16253
    rI_170 (I_48 I_98) resistor r=6.30933
    rI_169 (I_48 I_93) resistor r=6.30933
    rI_168 (I_48 I_66) resistor r=1.63969
    rI_167 (I_48 I_61) resistor r=24.8333
    rI_166 (I_48 I_58) resistor r=24.8333
    rI_165 (I_48 I_69) resistor r=24.8333
    rI_164 (I_48 I_66) resistor r=24.8333
    rI_163 (I_48 I_90) resistor r=58.3583
    rI_162 (I_48 MM0_ELT_g) resistor r=22.35
    rI_161 (I_48 I_98) resistor r=14.9
    rI_160 (I_48 I_332) resistor r=40.975
    rI_159 (I_48 I_61) resistor r=4.16253
    rI_158 (I_48 I_69) resistor r=4.16253
    rI_157 (I_48 I_58) resistor r=4.16253
    rI_156 (I_48 I_90) resistor r=4.16253
    rI_155 (I_48 I_98) resistor r=6.30933
    rI_154 (I_48 I_93) resistor r=6.30933
    rI_153 (I_48 I_66) resistor r=1.63969
    rI_152 (I_50 I_56) resistor r=202.392
    rI_151 (I_50 I_56) resistor r=4.16253
    rI_150 (I_50 I_56) resistor r=202.392
    rI_149 (I_50 I_56) resistor r=4.16253
    rI_148 (I_53 I_56) resistor r=202.392
    rI_147 (I_53 I_56) resistor r=4.16253
    rI_146 (I_53 I_56) resistor r=202.392
    rI_145 (I_53 I_56) resistor r=4.16253
    rI_144 (I_56 I_77) resistor r=24.8333
    rI_143 (I_56 I_74) resistor r=24.8333
    rI_142 (I_56 I_85) resistor r=24.8333
    rI_141 (I_56 I_82) resistor r=24.8333
    rI_140 (I_56 I_104) resistor r=14.9
    rI_139 (I_56 I_110) resistor r=202.392
    rI_138 (I_56 I_113) resistor r=202.392
    rI_137 (I_56 I_77) resistor r=4.16253
    rI_136 (I_56 I_85) resistor r=4.16253
    rI_135 (I_56 I_110) resistor r=6.30933
    rI_134 (I_56 I_104) resistor r=6.30933
    rI_133 (I_56 I_74) resistor r=1.63969
    rI_132 (I_56 I_82) resistor r=4.16253
    rI_131 (I_56 I_113) resistor r=4.16253
    rI_130 (I_56 I_77) resistor r=24.8333
    rI_129 (I_56 I_74) resistor r=24.8333
    rI_128 (I_56 I_85) resistor r=24.8333
    rI_127 (I_56 I_82) resistor r=24.8333
    rI_126 (I_56 I_334) resistor r=40.975
    rI_125 (I_56 I_104) resistor r=14.9
    rI_124 (I_56 I_110) resistor r=202.392
    rI_123 (I_56 MM2_ELT_g) resistor r=7.45
    rI_122 (I_56 I_77) resistor r=4.16253
    rI_121 (I_56 I_85) resistor r=4.16253
    rI_120 (I_56 I_110) resistor r=6.30933
    rI_119 (I_56 I_104) resistor r=6.30933
    rI_118 (I_56 I_74) resistor r=1.63969
    rI_117 (I_56 I_82) resistor r=4.16253
    rI_116 (I_56 I_113) resistor r=4.16253
    rI_115 (I_93 MM0_ELT_g) resistor r=36.0083
    rI_114 (I_113 MM2_ELT_g) resistor r=194.942
    rI_113 (I_118 I_124) resistor r=58.3583
    rI_112 (I_118 I_124) resistor r=4.16253
    rI_111 (I_118 I_124) resistor r=58.3583
    rI_110 (I_118 I_124) resistor r=4.16253
    rI_109 (I_121 I_124) resistor r=58.3583
    rI_108 (I_121 I_124) resistor r=6.30933
    rI_107 (I_121 I_124) resistor r=58.3583
    rI_106 (I_121 I_124) resistor r=6.30933
    rI_105 (I_124 I_126) resistor r=14.9
    rI_104 (I_124 I_149) resistor r=24.8333
    rI_103 (I_124 I_146) resistor r=24.8333
    rI_102 (I_124 I_157) resistor r=24.8333
    rI_101 (I_124 I_154) resistor r=24.8333
    rI_100 (I_124 I_178) resistor r=58.3583
    rI_99 (I_124 I_181) resistor r=58.3583
    rI_98 (I_124 I_149) resistor r=4.16253
    rI_97 (I_124 I_126) resistor r=6.30933
    rI_96 (I_124 I_157) resistor r=1.63969
    rI_95 (I_124 I_146) resistor r=4.16253
    rI_94 (I_124 I_178) resistor r=4.16253
    rI_93 (I_124 I_154) resistor r=4.16253
    rI_92 (I_124 I_181) resistor r=4.16253
    rI_91 (I_124 I_126) resistor r=14.9
    rI_90 (I_124 I_348) resistor r=40.975
    rI_89 (I_124 I_149) resistor r=24.8333
    rI_88 (I_124 I_146) resistor r=24.8333
    rI_87 (I_124 I_157) resistor r=24.8333
    rI_86 (I_124 I_154) resistor r=24.8333
    rI_85 (I_124 I_178) resistor r=58.3583
    rI_84 (I_124 MM3_ELT_g) resistor r=7.45
    rI_83 (I_124 I_149) resistor r=4.16253
    rI_82 (I_124 I_126) resistor r=6.30933
    rI_81 (I_124 I_157) resistor r=1.63969
    rI_80 (I_124 I_146) resistor r=4.16253
    rI_79 (I_124 I_178) resistor r=4.16253
    rI_78 (I_124 I_154) resistor r=4.16253
    rI_77 (I_124 I_181) resistor r=4.16253
    rI_76 (I_132 I_135) resistor r=14.9
    rI_75 (I_132 I_135) resistor r=6.30933
    rI_74 (I_132 I_135) resistor r=14.9
    rI_73 (I_132 I_135) resistor r=6.30933
    rI_72 (I_135 I_138) resistor r=202.392
    rI_71 (I_135 I_141) resistor r=202.392
    rI_70 (I_135 I_165) resistor r=24.8333
    rI_69 (I_135 I_162) resistor r=24.8333
    rI_68 (I_135 I_173) resistor r=24.8333
    rI_67 (I_135 I_170) resistor r=24.8333
    rI_66 (I_135 I_186) resistor r=202.392
    rI_65 (I_135 I_189) resistor r=202.392
    rI_64 (I_135 I_138) resistor r=6.30933
    rI_63 (I_135 I_165) resistor r=1.63969
    rI_62 (I_135 I_173) resistor r=4.16253
    rI_61 (I_135 I_141) resistor r=4.16253
    rI_60 (I_135 I_162) resistor r=4.16253
    rI_59 (I_135 I_186) resistor r=4.16253
    rI_58 (I_135 I_170) resistor r=4.16253
    rI_57 (I_135 I_189) resistor r=4.16253
    rI_56 (I_135 I_350) resistor r=40.975
    rI_55 (I_135 I_138) resistor r=202.392
    rI_54 (I_135 I_141) resistor r=202.392
    rI_53 (I_135 I_165) resistor r=24.8333
    rI_52 (I_135 I_162) resistor r=24.8333
    rI_51 (I_135 I_173) resistor r=24.8333
    rI_50 (I_135 I_170) resistor r=24.8333
    rI_49 (I_135 I_186) resistor r=202.392
    rI_48 (I_135 MM1_ELT_g) resistor r=7.45
    rI_47 (I_135 I_138) resistor r=6.30933
    rI_46 (I_135 I_165) resistor r=1.63969
    rI_45 (I_135 I_173) resistor r=4.16253
    rI_44 (I_135 I_141) resistor r=4.16253
    rI_43 (I_135 I_162) resistor r=4.16253
    rI_42 (I_135 I_186) resistor r=4.16253
    rI_41 (I_135 I_170) resistor r=4.16253
    rI_40 (I_135 I_189) resistor r=4.16253
    rI_39 (I_181 MM3_ELT_g) resistor r=50.9083
    rI_38 (I_189 MM1_ELT_g) resistor r=194.942
    rI_37 (I_262 I_263) resistor r=10
    rI_36 (I_262 I) resistor r=0.0845484
    rI_35 (I_263 I_384) resistor r=41.3136
    rI_34 (I_332 I_385) resistor r=3.725
    rI_33 (I_334 I_385) resistor r=3.725
    rI_32 (I_342 I_343) resistor r=27.0909
    rI_31 (I_342 I_390) resistor r=0.877078
    rI_30 (I_343 I_385) resistor r=3.725
    rI_29 (I_348 I_390) resistor r=10.0997
    rI_28 (I_350 I_390) resistor r=10.0997
    rI_27 (I_384 I_385) resistor r=3.725
ends INVD2_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: INVD1_LVT_ELT
// View name: calibre
subckt INVD1_LVT_ELT I ZN VDD VSS
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciZN_6 (ZN_3 VSS) capacitor c=4.47427e-17
    ciZN_5 (ZN_4 VSS) capacitor c=1.11612e-16
    ciZN_4 (ZN_8 VSS) capacitor c=1.73908e-16
    ciZN_3 (ZN_9 VSS) capacitor c=3.31535e-16
    ciZN_2 (ZN VSS) capacitor c=7.8124e-17
    ciZN_1 (ZN_23 VSS) capacitor c=2.45201e-17
    ciZN_0 (ZN_27 VSS) capacitor c=1.79461e-17
    ciVDD_7 (VDD_4 VSS) capacitor c=1.35235e-16
    ciVDD_6 (VDD_13 VSS) capacitor c=2.63453e-17
    ciVDD_5 (VDD_18 VSS) capacitor c=6.30092e-17
    ciVDD_4 (VDD_30 VSS) capacitor c=1.11099e-18
    ciVDD_3 (VDD_31 VSS) capacitor c=5.8958e-18
    ciVDD_2 (VDD_32 VSS) capacitor c=2.3177e-18
    ciVDD_1 (VDD_35 VSS) capacitor c=1.62337e-17
    ciVDD_0 (VDD_36 VSS) capacitor c=2.16736e-16
    ciVSS_6 (VSS_4 VSS) capacitor c=5.75919e-17
    ciVSS_5 (VSS_10 VSS) capacitor c=2.63453e-17
    ciVSS_4 (VSS_15 VSS) capacitor c=6.07475e-17
    ciVSS_3 (VSS_26 VSS) capacitor c=5.8958e-18
    ciVSS_2 (VSS_27 VSS) capacitor c=1.99685e-18
    ciVSS_1 (VSS_30 VSS) capacitor c=1.96647e-18
    ciVSS_0 (VSS_31 VSS) capacitor c=6.99899e-17
    ciI_14 (I_22 VSS) capacitor c=4.28147e-18
    ciI_13 (I_28 VSS) capacitor c=1.94345e-16
    ciI_12 (I_39 VSS) capacitor c=5.86534e-16
    ciI_11 (I_45 VSS) capacitor c=4.73887e-18
    ciI_10 (I_50 VSS) capacitor c=2.23559e-17
    ciI_9 (I_58 VSS) capacitor c=2.04214e-17
    ciI_8 (I_66 VSS) capacitor c=1.2317e-17
    ciI_7 (I_74 VSS) capacitor c=1.51948e-17
    ciI_6 (I_82 VSS) capacitor c=2.11871e-18
    ciI_5 (I_85 VSS) capacitor c=3.9912e-18
    ciI_4 (I_90 VSS) capacitor c=4.02575e-18
    ciI_3 (I_93 VSS) capacitor c=2.22299e-18
    ciI_2 (I VSS) capacitor c=4.46475e-17
    ciI_1 (I_196 VSS) capacitor c=3.16009e-17
    ciI_0 (I_197 VSS) capacitor c=1.56853e-17
    rZN_26 (ZN_1 ZN_3) resistor r=0.303696
    rZN_25 (ZN_1 ZN_21) resistor r=0.010098
    rZN_24 (ZN_3 ZN_4) resistor r=13
    rZN_23 (ZN_4 MM0_ELT_d) resistor r=8.44
    rZN_22 (ZN_6 ZN_8) resistor r=0.340992
    rZN_21 (ZN_6 ZN_25) resistor r=0.010098
    rZN_20 (ZN_8 ZN_9) resistor r=8.66667
    rZN_19 (ZN_8 ZN_11) resistor r=0.639359
    rZN_18 (ZN_9 MM1_ELT_d) resistor r=32.3614
    rZN_17 (ZN_11 ZN_12) resistor r=8.66667
    rZN_16 (ZN_11 ZN_14) resistor r=0.42624
    rZN_15 (ZN_12 MM1_ELT_d) resistor r=16.1807
    rZN_14 (ZN_12 ZN_15) resistor r=32.3614
    rZN_13 (ZN_14 ZN_15) resistor r=26
    rZN_12 (ZN_17 ZN) resistor r=0.156114
    rZN_11 (ZN_17 ZN_23) resistor r=0.010098
    rZN_10 (ZN_18 ZN) resistor r=0.606192
    rZN_9 (ZN_18 ZN_27) resistor r=0.010098
    rZN_8 (ZN_21 ZN_23) resistor r=0.126843
    rZN_7 (ZN_25 ZN_27) resistor r=0.126843
    rVDD_35 (MM1_ELT_b VDD_18) resistor r=26
    rVDD_34 (MM1_ELT_b VDD_16) resistor r=11.2533
    rVDD_33 (VDD_2 VDD_11) resistor r=0.490176
    rVDD_32 (VDD_2 VDD_24) resistor r=0.119122
    rVDD_31 (VDD_4 VDD_12) resistor r=8.66667
    rVDD_30 (VDD_4 VDD_8) resistor r=0.639359
    rVDD_29 (VDD_8 VDD_12) resistor r=8.66667
    rVDD_28 (VDD_8 VDD_11) resistor r=0.639359
    rVDD_27 (VDD_11 VDD_12) resistor r=8.66667
    rVDD_26 (VDD_12 MM1_ELT_s) resistor r=1.847
    rVDD_25 (VDD_12 VDD_36) resistor r=20.317
    rVDD_24 (VDD_13 VDD_15) resistor r=0.0335785
    rVDD_23 (VDD_13 VDD_24) resistor r=0.0177768
    rVDD_22 (VDD_15 VDD_16) resistor r=8.66667
    rVDD_21 (VDD_15 VDD_18) resistor r=0.158016
    rVDD_20 (VDD VDD_24) resistor r=0.0513553
    rVDD_19 (MM1_ELT_s VDD_30) resistor r=2.55965
    rVDD_18 (MM1_ELT_s VDD_32) resistor r=12.3172
    rVDD_17 (MM1_ELT_s VDD_32) resistor r=1.62887
    rVDD_16 (MM1_ELT_s VDD_35) resistor r=6.12113
    rVDD_15 (VDD_28 VDD_30) resistor r=14.4784
    rVDD_14 (VDD_28 VDD_34) resistor r=9.04062
    rVDD_13 (VDD_29 VDD_30) resistor r=14.4784
    rVDD_12 (VDD_29 VDD_36) resistor r=9.48555
    rVDD_11 (VDD_31 VDD_32) resistor r=12.3172
    rVDD_10 (VDD_31 VDD_33) resistor r=9.04595
    rVDD_9 (VDD_33 VDD_35) resistor r=31.2341
    rVDD_8 (VDD_34 VDD_35) resistor r=31.2341
    rVSS_32 (MM0_ELT_b VSS_15) resistor r=26
    rVSS_31 (MM0_ELT_b VSS_13) resistor r=10.7871
    rVSS_30 (VSS_2 VSS_4) resistor r=0.404928
    rVSS_29 (VSS_2 VSS_21) resistor r=0.119122
    rVSS_28 (VSS_4 VSS_8) resistor r=8.66667
    rVSS_27 (VSS_4 VSS_7) resistor r=0.42624
    rVSS_26 (VSS_7 VSS_8) resistor r=26
    rVSS_25 (VSS_8 MM0_ELT_s) resistor r=2.90692
    rVSS_24 (VSS_8 VSS_31) resistor r=12.1406
    rVSS_23 (VSS_10 VSS_12) resistor r=0.0335785
    rVSS_22 (VSS_10 VSS_21) resistor r=0.0177768
    rVSS_21 (VSS_12 VSS_13) resistor r=8.66667
    rVSS_20 (VSS_12 VSS_15) resistor r=0.158016
    rVSS_19 (VSS VSS_21) resistor r=0.0493801
    rVSS_18 (MM0_ELT_s VSS_25) resistor r=2.67027
    rVSS_17 (MM0_ELT_s VSS_27) resistor r=12.8495
    rVSS_16 (MM0_ELT_s VSS_27) resistor r=1.69926
    rVSS_15 (MM0_ELT_s VSS_30) resistor r=4.557
    rVSS_14 (VSS_23 VSS_25) resistor r=15.1041
    rVSS_13 (VSS_23 VSS_28) resistor r=9.43134
    rVSS_12 (VSS_24 VSS_25) resistor r=15.1041
    rVSS_11 (VSS_24 VSS_31) resistor r=9.89549
    rVSS_10 (VSS_26 VSS_27) resistor r=12.8495
    rVSS_9 (VSS_26 VSS_29) resistor r=9.4369
    rVSS_8 (VSS_28 VSS_30) resistor r=21.1301
    rVSS_7 (VSS_29 VSS_30) resistor r=21.1301
    rI_96 (I_22 I_28) resistor r=58.3583
    rI_95 (I_22 I_28) resistor r=4.16253
    rI_94 (I_22 I_28) resistor r=58.3583
    rI_93 (I_22 I_28) resistor r=4.16253
    rI_92 (I_25 I_28) resistor r=58.3583
    rI_91 (I_25 I_28) resistor r=6.30933
    rI_90 (I_25 I_28) resistor r=58.3583
    rI_89 (I_25 I_28) resistor r=6.30933
    rI_88 (I_28 I_30) resistor r=14.9
    rI_87 (I_28 I_53) resistor r=24.8333
    rI_86 (I_28 I_50) resistor r=24.8333
    rI_85 (I_28 I_61) resistor r=24.8333
    rI_84 (I_28 I_58) resistor r=24.8333
    rI_83 (I_28 I_82) resistor r=58.3583
    rI_82 (I_28 I_85) resistor r=58.3583
    rI_81 (I_28 I_53) resistor r=4.16253
    rI_80 (I_28 I_30) resistor r=6.30933
    rI_79 (I_28 I_61) resistor r=1.63969
    rI_78 (I_28 I_50) resistor r=4.16253
    rI_77 (I_28 I_82) resistor r=4.16253
    rI_76 (I_28 I_58) resistor r=4.16253
    rI_75 (I_28 I_85) resistor r=4.16253
    rI_74 (I_28 I_30) resistor r=14.9
    rI_73 (I_28 I_162) resistor r=40.975
    rI_72 (I_28 I_53) resistor r=24.8333
    rI_71 (I_28 I_50) resistor r=24.8333
    rI_70 (I_28 I_61) resistor r=24.8333
    rI_69 (I_28 I_58) resistor r=24.8333
    rI_68 (I_28 I_82) resistor r=58.3583
    rI_67 (I_28 MM0_ELT_g) resistor r=7.45
    rI_66 (I_28 I_53) resistor r=4.16253
    rI_65 (I_28 I_30) resistor r=6.30933
    rI_64 (I_28 I_61) resistor r=1.63969
    rI_63 (I_28 I_50) resistor r=4.16253
    rI_62 (I_28 I_82) resistor r=4.16253
    rI_61 (I_28 I_58) resistor r=4.16253
    rI_60 (I_28 I_85) resistor r=4.16253
    rI_59 (I_36 I_39) resistor r=14.9
    rI_58 (I_36 I_39) resistor r=6.30933
    rI_57 (I_36 I_39) resistor r=14.9
    rI_56 (I_36 I_39) resistor r=6.30933
    rI_55 (I_39 I_42) resistor r=202.392
    rI_54 (I_39 I_45) resistor r=202.392
    rI_53 (I_39 I_69) resistor r=24.8333
    rI_52 (I_39 I_66) resistor r=24.8333
    rI_51 (I_39 I_77) resistor r=24.8333
    rI_50 (I_39 I_74) resistor r=24.8333
    rI_49 (I_39 I_90) resistor r=202.392
    rI_48 (I_39 I_93) resistor r=202.392
    rI_47 (I_39 I_42) resistor r=6.30933
    rI_46 (I_39 I_69) resistor r=1.63969
    rI_45 (I_39 I_77) resistor r=4.16253
    rI_44 (I_39 I_45) resistor r=4.16253
    rI_43 (I_39 I_66) resistor r=4.16253
    rI_42 (I_39 I_90) resistor r=4.16253
    rI_41 (I_39 I_74) resistor r=4.16253
    rI_40 (I_39 I_93) resistor r=4.16253
    rI_39 (I_39 I_164) resistor r=40.975
    rI_38 (I_39 I_42) resistor r=202.392
    rI_37 (I_39 I_45) resistor r=202.392
    rI_36 (I_39 I_69) resistor r=24.8333
    rI_35 (I_39 I_66) resistor r=24.8333
    rI_34 (I_39 I_77) resistor r=24.8333
    rI_33 (I_39 I_74) resistor r=24.8333
    rI_32 (I_39 I_90) resistor r=202.392
    rI_31 (I_39 MM1_ELT_g) resistor r=7.45
    rI_30 (I_39 I_42) resistor r=6.30933
    rI_29 (I_39 I_69) resistor r=1.63969
    rI_28 (I_39 I_77) resistor r=4.16253
    rI_27 (I_39 I_45) resistor r=4.16253
    rI_26 (I_39 I_66) resistor r=4.16253
    rI_25 (I_39 I_90) resistor r=4.16253
    rI_24 (I_39 I_74) resistor r=4.16253
    rI_23 (I_39 I_93) resistor r=4.16253
    rI_22 (I_85 MM0_ELT_g) resistor r=50.9083
    rI_21 (I_93 MM1_ELT_g) resistor r=194.942
    rI_20 (I_132 I_133) resistor r=10
    rI_19 (I_132 I) resistor r=0.0875143
    rI_18 (I_133 I_196) resistor r=13.5455
    rI_17 (I_162 I_197) resistor r=3.725
    rI_16 (I_164 I_197) resistor r=3.725
    rI_15 (I_196 I_197) resistor r=3.725
ends INVD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: NR4D1_LVT_ELT
// View name: calibre
subckt NR4D1_LVT_ELT A1 A2 A3 A4 VDD VSS ZN
    MM22_ELT (MM22_ELT_d MM22_ELT_g MM22_ELT_s MM22_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.8675e-13 pd=1.34e-06 \
        ps=5.73e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM21_ELT (MM21_ELT_d MM21_ELT_g MM21_ELT_s MM21_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.8675e-13 pd=1.34e-06 \
        ps=5.73e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.8675e-13 pd=1.34e-06 \
        ps=5.73e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.8675e-13 pd=1.34e-06 \
        ps=5.73e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM19_ELT (MM19_ELT_d MM19_ELT_g MM19_ELT_s MM19_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM20_ELT (MM20_ELT_d MM20_ELT_g MM20_ELT_s MM20_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM16_ELT (MM16_ELT_d MM16_ELT_g MM16_ELT_s MM16_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet027_9 (net027_4 VSS) capacitor c=3.04198e-17
    cinet027_8 (net027_5 VSS) capacitor c=1.52284e-18
    cinet027_7 (net027_6 VSS) capacitor c=5.58395e-18
    cinet027_6 (net027_8 VSS) capacitor c=1.4183e-18
    cinet027_5 (net027_9 VSS) capacitor c=7.0199e-18
    cinet027_4 (net027_12 VSS) capacitor c=4.19899e-17
    cinet027_3 (net027_15 VSS) capacitor c=1.11099e-18
    cinet027_2 (net027_16 VSS) capacitor c=2.89375e-18
    cinet027_1 (net027_17 VSS) capacitor c=5.93983e-18
    cinet027_0 (net027_20 VSS) capacitor c=3.03346e-17
    cinet028_10 (net028_4 VSS) capacitor c=3.03638e-17
    cinet028_9 (net028_6 VSS) capacitor c=1.07074e-18
    cinet028_8 (net028_8 VSS) capacitor c=1.4183e-18
    cinet028_7 (net028_9 VSS) capacitor c=4.63397e-18
    cinet028_6 (MM20_ELT_d VSS) capacitor c=3.28439e-17
    cinet028_5 (net028_13 VSS) capacitor c=3.79581e-17
    cinet028_4 (net028_15 VSS) capacitor c=5.08819e-18
    cinet028_3 (net028_16 VSS) capacitor c=1.4183e-18
    cinet028_2 (net028_18 VSS) capacitor c=4.63397e-18
    cinet028_1 (net028_20 VSS) capacitor c=3.37903e-18
    cinet028_0 (net028 VSS) capacitor c=2.21571e-18
    ciZN_29 (ZN_3 VSS) capacitor c=3.02e-16
    ciZN_28 (ZN_10 VSS) capacitor c=3.41514e-16
    ciZN_27 (ZN_12 VSS) capacitor c=2.83417e-17
    ciZN_26 (ZN_13 VSS) capacitor c=2.03178e-17
    ciZN_25 (ZN_16 VSS) capacitor c=5.87537e-17
    ciZN_24 (ZN_17 VSS) capacitor c=1.14517e-16
    ciZN_23 (ZN_19 VSS) capacitor c=7.77043e-17
    ciZN_22 (ZN_23 VSS) capacitor c=5.61078e-17
    ciZN_21 (ZN_24 VSS) capacitor c=1.15296e-16
    ciZN_20 (ZN_26 VSS) capacitor c=1.90854e-16
    ciZN_19 (ZN_30 VSS) capacitor c=5.88862e-17
    ciZN_18 (ZN_31 VSS) capacitor c=1.14423e-16
    ciZN_17 (ZN_33 VSS) capacitor c=2.92211e-16
    ciZN_16 (ZN_37 VSS) capacitor c=5.89851e-17
    ciZN_15 (ZN_38 VSS) capacitor c=1.12488e-16
    ciZN_14 (ZN_40 VSS) capacitor c=4.52493e-17
    ciZN_13 (ZN_42 VSS) capacitor c=4.23717e-17
    ciZN_12 (ZN_45 VSS) capacitor c=1.23722e-17
    ciZN_11 (ZN_46 VSS) capacitor c=1.23722e-17
    ciZN_10 (ZN_47 VSS) capacitor c=7.30847e-18
    ciZN_9 (ZN_48 VSS) capacitor c=1.23034e-17
    ciZN_8 (ZN_52 VSS) capacitor c=1.32762e-17
    ciZN_7 (ZN_54 VSS) capacitor c=1.07074e-18
    ciZN_6 (ZN_57 VSS) capacitor c=7.0199e-18
    ciZN_5 (ZN_59 VSS) capacitor c=1.4183e-18
    ciZN_4 (ZN_61 VSS) capacitor c=4.63397e-18
    ciZN_3 (ZN_62 VSS) capacitor c=8.31472e-19
    ciZN_2 (ZN_63 VSS) capacitor c=1.07074e-18
    ciZN_1 (ZN_66 VSS) capacitor c=3.25941e-17
    ciZN_0 (ZN_68 VSS) capacitor c=2.21571e-18
    cinet031_5 (net031_3 VSS) capacitor c=1.2631e-16
    cinet031_4 (net031_4 VSS) capacitor c=3.17255e-16
    cinet031_3 (net031_12 VSS) capacitor c=4.42937e-16
    cinet031_2 (net031_13 VSS) capacitor c=1.92189e-17
    cinet031_1 (net031_16 VSS) capacitor c=1.94515e-16
    cinet031_0 (net031_17 VSS) capacitor c=3.27323e-16
    ciVDD_11 (VDD_2 VSS) capacitor c=5.00466e-16
    ciVDD_10 (VDD_29 VSS) capacitor c=2.28235e-16
    ciVDD_9 (VDD_37 VSS) capacitor c=3.38706e-16
    ciVDD_8 (VDD_43 VSS) capacitor c=7.04014e-17
    ciVDD_7 (VDD_46 VSS) capacitor c=6.77184e-18
    ciVDD_6 (MM10_ELT_s VSS) capacitor c=3.17115e-17
    ciVDD_5 (VDD_53 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_55 VSS) capacitor c=6.00084e-18
    ciVDD_3 (VDD_59 VSS) capacitor c=1.11099e-18
    ciVDD_2 (VDD_61 VSS) capacitor c=4.24442e-18
    ciVDD_1 (VDD_64 VSS) capacitor c=1.32762e-17
    ciVDD_0 (VDD_66 VSS) capacitor c=5.08516e-18
    ciVSS_28 (VSS_2 VSS) capacitor c=6.1612e-17
    ciVSS_27 (VSS_11 VSS) capacitor c=6.32975e-17
    ciVSS_26 (VSS_14 VSS) capacitor c=9.09329e-17
    ciVSS_25 (VSS_24 VSS) capacitor c=6.08692e-17
    ciVSS_24 (VSS_27 VSS) capacitor c=8.78273e-17
    ciVSS_23 (VSS_37 VSS) capacitor c=5.86667e-17
    ciVSS_22 (VSS_40 VSS) capacitor c=8.48062e-17
    ciVSS_21 (VSS_50 VSS) capacitor c=5.71189e-17
    ciVSS_20 (VSS_58 VSS) capacitor c=7.36393e-17
    ciVSS_19 (VSS_61 VSS) capacitor c=3.58509e-18
    ciVSS_18 (VSS_62 VSS) capacitor c=3.58509e-18
    ciVSS_17 (VSS_63 VSS) capacitor c=3.58509e-18
    ciVSS_16 (VSS_64 VSS) capacitor c=3.58509e-18
    ciVSS_15 (VSS_69 VSS) capacitor c=1.22812e-18
    ciVSS_14 (VSS_70 VSS) capacitor c=2.15319e-18
    ciVSS_13 (VSS_73 VSS) capacitor c=7.29886e-18
    ciVSS_12 (VSS_77 VSS) capacitor c=7.37144e-18
    ciVSS_11 (VSS_81 VSS) capacitor c=4.64869e-18
    ciVSS_10 (VSS_82 VSS) capacitor c=2.72959e-18
    ciVSS_9 (VSS_86 VSS) capacitor c=6.28631e-18
    ciVSS_8 (VSS_90 VSS) capacitor c=1.22812e-18
    ciVSS_7 (VSS_91 VSS) capacitor c=3.14091e-18
    ciVSS_6 (VSS_96 VSS) capacitor c=5.1705e-19
    ciVSS_5 (VSS_97 VSS) capacitor c=2.26202e-18
    ciVSS_4 (VSS_100 VSS) capacitor c=4.06483e-18
    ciVSS_3 (VSS_101 VSS) capacitor c=8.71518e-17
    ciVSS_2 (VSS_102 VSS) capacitor c=1.13844e-16
    ciVSS_1 (VSS_103 VSS) capacitor c=1.13023e-16
    ciVSS_0 (VSS_104 VSS) capacitor c=1.13104e-16
    cinet026_6 (net026_5 VSS) capacitor c=8.32433e-17
    cinet026_5 (net026_6 VSS) capacitor c=3.3238e-16
    cinet026_4 (net026_14 VSS) capacitor c=8.56379e-17
    cinet026_3 (net026_20 VSS) capacitor c=1.37017e-16
    cinet026_2 (net026_21 VSS) capacitor c=3.4528e-16
    cinet026_1 (net026_29 VSS) capacitor c=2.19655e-17
    cinet026_0 (net026_30 VSS) capacitor c=2.78071e-17
    cinet29_5 (net29_3 VSS) capacitor c=1.85208e-16
    cinet29_4 (net29_4 VSS) capacitor c=3.27041e-16
    cinet29_3 (net29_12 VSS) capacitor c=4.39593e-16
    cinet29_2 (net29_13 VSS) capacitor c=1.60499e-17
    cinet29_1 (net29_16 VSS) capacitor c=1.34448e-16
    cinet29_0 (net29_17 VSS) capacitor c=3.23603e-16
    ciA3_21 (A3_32 VSS) capacitor c=4.84834e-18
    ciA3_20 (A3_35 VSS) capacitor c=1.12779e-17
    ciA3_19 (A3_38 VSS) capacitor c=4.68745e-16
    ciA3_18 (A3_40 VSS) capacitor c=1.75638e-17
    ciA3_17 (A3_48 VSS) capacitor c=2.71781e-17
    ciA3_16 (A3_65 VSS) capacitor c=8.34686e-18
    ciA3_15 (A3_70 VSS) capacitor c=2.13788e-18
    ciA3_14 (A3_73 VSS) capacitor c=3.11897e-18
    ciA3_13 (A3_76 VSS) capacitor c=1.95716e-16
    ciA3_12 (A3_78 VSS) capacitor c=3.22974e-18
    ciA3_11 (A3_81 VSS) capacitor c=6.10119e-18
    ciA3_10 (A3_84 VSS) capacitor c=4.80878e-16
    ciA3_9 (A3_86 VSS) capacitor c=2.23961e-17
    ciA3_8 (A3_94 VSS) capacitor c=2.21774e-17
    ciA3_7 (A3_102 VSS) capacitor c=1.58541e-17
    ciA3_6 (A3_110 VSS) capacitor c=2.26301e-17
    ciA3_5 (A3_118 VSS) capacitor c=2.96436e-18
    ciA3_4 (A3_141 VSS) capacitor c=5.62291e-18
    ciA3_3 (A3 VSS) capacitor c=8.78527e-17
    ciA3_2 (A3_286 VSS) capacitor c=1.20198e-17
    ciA3_1 (A3_295 VSS) capacitor c=5.87447e-17
    ciA3_0 (A3_296 VSS) capacitor c=1.22634e-17
    cinet033_8 (net033_3 VSS) capacitor c=1.269e-16
    cinet033_7 (net033_4 VSS) capacitor c=3.41482e-16
    cinet033_6 (net033_9 VSS) capacitor c=1.49371e-17
    cinet033_5 (net033_13 VSS) capacitor c=7.28469e-17
    cinet033_4 (net033_17 VSS) capacitor c=8.48524e-17
    cinet033_3 (net033_18 VSS) capacitor c=3.24985e-16
    cinet033_2 (net033_23 VSS) capacitor c=1.29003e-17
    cinet033_1 (net033_27 VSS) capacitor c=5.88247e-18
    cinet033_0 (net033_28 VSS) capacitor c=3.63597e-18
    ciA2_30 (A2_32 VSS) capacitor c=4.06555e-18
    ciA2_29 (A2_35 VSS) capacitor c=5.15897e-18
    ciA2_28 (A2_38 VSS) capacitor c=2.07164e-16
    ciA2_27 (A2_40 VSS) capacitor c=2.5941e-18
    ciA2_26 (A2_43 VSS) capacitor c=8.14456e-18
    ciA2_25 (A2_46 VSS) capacitor c=5.10849e-16
    ciA2_24 (A2_48 VSS) capacitor c=2.23961e-17
    ciA2_23 (A2_56 VSS) capacitor c=2.15262e-17
    ciA2_22 (A2_64 VSS) capacitor c=8.9559e-18
    ciA2_21 (A2_72 VSS) capacitor c=2.57902e-17
    ciA2_20 (A2_80 VSS) capacitor c=2.96436e-18
    ciA2_19 (A2_103 VSS) capacitor c=1.12779e-17
    ciA2_18 (A2_111 VSS) capacitor c=5.26015e-16
    ciA2_17 (A2_117 VSS) capacitor c=5.89798e-18
    ciA2_16 (A2_122 VSS) capacitor c=1.49495e-17
    ciA2_15 (A2_130 VSS) capacitor c=1.51948e-17
    ciA2_14 (A2_138 VSS) capacitor c=4.37203e-18
    ciA2_13 (A2_141 VSS) capacitor c=4.21727e-18
    ciA2_12 (A2_196 VSS) capacitor c=1.95049e-17
    ciA2_11 (A2_202 VSS) capacitor c=3.23854e-17
    ciA2_10 (A2_203 VSS) capacitor c=1.73787e-16
    ciA2_9 (A2_204 VSS) capacitor c=1.19955e-17
    ciA2_8 (A2_205 VSS) capacitor c=3.57432e-18
    ciA2_7 (A2_206 VSS) capacitor c=4.01039e-17
    ciA2_6 (A2_210 VSS) capacitor c=1.97648e-17
    ciA2_5 (A2_211 VSS) capacitor c=7.75311e-17
    ciA2_4 (A2_278 VSS) capacitor c=2.86342e-17
    ciA2_3 (A2_303 VSS) capacitor c=1.33319e-17
    ciA2_2 (A2_304 VSS) capacitor c=2.49724e-17
    ciA2_1 (A2_316 VSS) capacitor c=3.73341e-17
    ciA2_0 (A2 VSS) capacitor c=6.49568e-17
    ciA1_30 (A1_32 VSS) capacitor c=2.96436e-18
    ciA1_29 (A1_38 VSS) capacitor c=2.13429e-16
    ciA1_28 (A1_49 VSS) capacitor c=6.08443e-16
    ciA1_27 (A1_55 VSS) capacitor c=1.14845e-17
    ciA1_26 (A1_60 VSS) capacitor c=2.24142e-17
    ciA1_25 (A1_68 VSS) capacitor c=2.38189e-17
    ciA1_24 (A1_76 VSS) capacitor c=8.54096e-18
    ciA1_23 (A1_84 VSS) capacitor c=2.57991e-17
    ciA1_22 (A1_92 VSS) capacitor c=4.06555e-18
    ciA1_21 (A1_95 VSS) capacitor c=4.68686e-18
    ciA1_20 (A1_100 VSS) capacitor c=1.73784e-18
    ciA1_19 (A1_103 VSS) capacitor c=8.14456e-18
    ciA1_18 (A1_111 VSS) capacitor c=6.32909e-16
    ciA1_17 (A1_117 VSS) capacitor c=4.15066e-18
    ciA1_16 (A1_122 VSS) capacitor c=1.6146e-17
    ciA1_15 (A1_130 VSS) capacitor c=1.51948e-17
    ciA1_14 (A1_138 VSS) capacitor c=7.44391e-18
    ciA1_13 (A1_141 VSS) capacitor c=6.12953e-18
    ciA1_12 (A1_196 VSS) capacitor c=1.88883e-17
    ciA1_11 (A1_202 VSS) capacitor c=5.86566e-17
    ciA1_10 (A1_203 VSS) capacitor c=2.88801e-16
    ciA1_9 (A1_204 VSS) capacitor c=9.17266e-18
    ciA1_8 (A1_205 VSS) capacitor c=7.8781e-18
    ciA1_7 (A1_206 VSS) capacitor c=6.10962e-17
    ciA1_6 (A1_210 VSS) capacitor c=2.19037e-17
    ciA1_5 (A1_211 VSS) capacitor c=7.92904e-17
    ciA1_4 (A1_298 VSS) capacitor c=8.32259e-18
    ciA1_3 (A1_305 VSS) capacitor c=2.83013e-17
    ciA1_2 (A1_306 VSS) capacitor c=2.6114e-17
    ciA1_1 (A1_312 VSS) capacitor c=3.02576e-17
    ciA1_0 (A1 VSS) capacitor c=7.13947e-17
    ciA4_26 (A4_35 VSS) capacitor c=2.22299e-18
    ciA4_25 (A4_38 VSS) capacitor c=5.52095e-16
    ciA4_24 (A4_40 VSS) capacitor c=8.50437e-18
    ciA4_23 (A4_48 VSS) capacitor c=2.31916e-17
    ciA4_22 (A4_65 VSS) capacitor c=9.20697e-18
    ciA4_21 (A4_70 VSS) capacitor c=4.19636e-18
    ciA4_20 (A4_76 VSS) capacitor c=1.8374e-16
    ciA4_19 (A4_87 VSS) capacitor c=5.73013e-16
    ciA4_18 (A4_93 VSS) capacitor c=6.12953e-18
    ciA4_17 (A4_98 VSS) capacitor c=2.23567e-17
    ciA4_16 (A4_106 VSS) capacitor c=2.40237e-17
    ciA4_15 (A4_114 VSS) capacitor c=1.4271e-17
    ciA4_14 (A4_122 VSS) capacitor c=1.51948e-17
    ciA4_13 (A4_130 VSS) capacitor c=2.14282e-18
    ciA4_12 (A4_133 VSS) capacitor c=4.69501e-18
    ciA4_11 (A4_141 VSS) capacitor c=2.22299e-18
    ciA4_10 (A4_196 VSS) capacitor c=7.36416e-18
    ciA4_9 (A4_199 VSS) capacitor c=3.48666e-17
    ciA4_8 (A4_202 VSS) capacitor c=4.00497e-17
    ciA4_7 (A4_203 VSS) capacitor c=3.58677e-16
    ciA4_6 (A4_204 VSS) capacitor c=7.76304e-18
    ciA4_5 (A4_206 VSS) capacitor c=5.51009e-17
    ciA4_4 (A4_210 VSS) capacitor c=2.14495e-17
    ciA4_3 (A4_295 VSS) capacitor c=3.84187e-17
    ciA4_2 (A4_301 VSS) capacitor c=5.33106e-18
    ciA4_1 (A4_313 VSS) capacitor c=2.99012e-17
    ciA4_0 (A4 VSS) capacitor c=8.3151e-17
    rnet027_37 (net027_1 net027_4) resistor r=31.2341
    rnet027_36 (net027_1 net027_5) resistor r=9.04595
    rnet027_35 (net027_2 net027_4) resistor r=31.2341
    rnet027_34 (net027_2 net027_8) resistor r=9.04062
    rnet027_33 (MM15_ELT_s net027_4) resistor r=6.12113
    rnet027_32 (MM15_ELT_s net027_6) resistor r=12.3172
    rnet027_31 (MM15_ELT_s net027_6) resistor r=1.62887
    rnet027_30 (MM15_ELT_s net027_9) resistor r=2.55965
    rnet027_29 (MM15_ELT_s net027_12) resistor r=0.850556
    rnet027_28 (net027_5 net027_6) resistor r=12.3172
    rnet027_27 (net027_7 net027_9) resistor r=14.4784
    rnet027_26 (net027_7 net027) resistor r=10.5593
    rnet027_25 (net027_8 net027_9) resistor r=14.4784
    rnet027_24 (net027_10 net027_12) resistor r=13.0961
    rnet027_23 (net027_10 net027) resistor r=0.730683
    rnet027_22 (MM11_ELT_d net027_12) resistor r=0.850556
    rnet027_21 (MM11_ELT_d net027_15) resistor r=2.55965
    rnet027_20 (MM11_ELT_d net027_17) resistor r=12.3172
    rnet027_19 (MM11_ELT_d net027_17) resistor r=1.62887
    rnet027_18 (MM11_ELT_d net027_20) resistor r=6.12113
    rnet027_17 (net027_13 net027_15) resistor r=14.4784
    rnet027_16 (net027_13 net027_19) resistor r=9.04062
    rnet027_15 (net027_14 net027_15) resistor r=14.4784
    rnet027_14 (net027_14 net027) resistor r=10.5593
    rnet027_13 (net027_16 net027_17) resistor r=12.3172
    rnet027_12 (net027_16 net027_18) resistor r=9.04595
    rnet027_11 (net027_18 net027_20) resistor r=31.2341
    rnet027_10 (net027_19 net027_20) resistor r=31.2341
    rnet028_39 (net028_1 net028_4) resistor r=31.2341
    rnet028_38 (net028_1 net028_5) resistor r=9.04595
    rnet028_37 (net028_2 net028_4) resistor r=31.2341
    rnet028_36 (net028_2 net028_8) resistor r=9.04062
    rnet028_35 (MM17_ELT_s net028_4) resistor r=6.12113
    rnet028_34 (MM17_ELT_s net028_6) resistor r=12.3172
    rnet028_33 (MM17_ELT_s net028_6) resistor r=1.62887
    rnet028_32 (MM17_ELT_s net028_9) resistor r=2.55965
    rnet028_31 (MM17_ELT_s net028_13) resistor r=4.04518
    rnet028_30 (MM17_ELT_s net028_20) resistor r=10.2363
    rnet028_29 (net028_5 net028_6) resistor r=12.3172
    rnet028_28 (net028_7 net028_9) resistor r=14.4784
    rnet028_27 (net028_7 net028) resistor r=10.5593
    rnet028_26 (net028_8 net028_9) resistor r=14.4784
    rnet028_25 (net028_10 net028_13) resistor r=4.04518
    rnet028_24 (net028_10 net028_20) resistor r=0.549089
    rnet028_23 (net028_11 net028_13) resistor r=4.04518
    rnet028_22 (net028_11 net028) resistor r=0.730683
    rnet028_21 (MM20_ELT_d net028_13) resistor r=4.04518
    rnet028_20 (MM20_ELT_d net028_15) resistor r=12.3172
    rnet028_19 (MM20_ELT_d net028_15) resistor r=1.62887
    rnet028_18 (MM20_ELT_d net028_18) resistor r=2.55965
    rnet028_17 (MM20_ELT_d net028_19) resistor r=25.7298
    rnet028_16 (net028_14 net028_15) resistor r=12.3172
    rnet028_15 (net028_14 net028_20) resistor r=10.2363
    rnet028_14 (net028_16 net028_18) resistor r=14.4784
    rnet028_13 (net028_16 net028_19) resistor r=9.04062
    rnet028_12 (net028_17 net028_18) resistor r=14.4784
    rnet028_11 (net028_17 net028) resistor r=10.5593
    rZN_95 (ZN_1 ZN_3) resistor r=1.33026
    rZN_94 (ZN_1 ZN_13) resistor r=0.0987414
    rZN_93 (ZN_3 ZN_10) resistor r=8.66667
    rZN_92 (ZN_3 ZN_6) resistor r=0.702065
    rZN_91 (ZN_6 ZN_10) resistor r=8.66667
    rZN_90 (ZN_6 ZN_9) resistor r=0.468043
    rZN_89 (ZN_9 ZN_10) resistor r=26
    rZN_88 (ZN_10 MM18_ELT_d) resistor r=0.850556
    rZN_87 (ZN_10 MM16_ELT_d) resistor r=0.850556
    rZN_86 (ZN_10 ZN_67) resistor r=13.0961
    rZN_85 (ZN_12 ZN_13) resistor r=0.17717
    rZN_84 (ZN_12 ZN_45) resistor r=0.0545779
    rZN_83 (ZN_14 ZN_16) resistor r=0.399665
    rZN_82 (ZN_14 ZN_45) resistor r=0.0361099
    rZN_81 (ZN_16 ZN_17) resistor r=13
    rZN_80 (ZN_17 MM2_ELT_d) resistor r=8.44
    rZN_79 (ZN_19 ZN_20) resistor r=0.614883
    rZN_78 (ZN_19 ZN_46) resistor r=0.0545779
    rZN_77 (ZN_20 ZN_45) resistor r=0.0545779
    rZN_76 (ZN_21 ZN_23) resistor r=0.399665
    rZN_75 (ZN_21 ZN_46) resistor r=0.0361099
    rZN_74 (ZN_23 ZN_24) resistor r=13
    rZN_73 (ZN_24 MM1_ELT_d) resistor r=8.44
    rZN_72 (ZN_26 ZN_27) resistor r=1.36378
    rZN_71 (ZN_26 ZN_47) resistor r=0.0545779
    rZN_70 (ZN_27 ZN_46) resistor r=0.0545779
    rZN_69 (ZN_28 ZN_30) resistor r=0.399665
    rZN_68 (ZN_28 ZN_47) resistor r=0.0361099
    rZN_67 (ZN_30 ZN_31) resistor r=13
    rZN_66 (ZN_31 MM21_ELT_d) resistor r=8.44
    rZN_65 (ZN_33 ZN_34) resistor r=2.00267
    rZN_64 (ZN_33 ZN_48) resistor r=0.0545779
    rZN_63 (ZN_34 ZN_47) resistor r=0.0545779
    rZN_62 (ZN_35 ZN_37) resistor r=0.399665
    rZN_61 (ZN_35 ZN_48) resistor r=0.0361099
    rZN_60 (ZN_37 ZN_38) resistor r=13
    rZN_59 (ZN_38 MM22_ELT_d) resistor r=8.44
    rZN_58 (ZN_40 ZN_41) resistor r=0.244911
    rZN_57 (ZN_40 ZN_42) resistor r=0.0958136
    rZN_56 (ZN_41 ZN_48) resistor r=0.0545779
    rZN_55 (ZN_42 ZN) resistor r=0.0791297
    rZN_54 (ZN_49 ZN_52) resistor r=31.2341
    rZN_53 (ZN_49 ZN_53) resistor r=9.04595
    rZN_52 (ZN_50 ZN_52) resistor r=31.2341
    rZN_51 (ZN_50 ZN_56) resistor r=9.04062
    rZN_50 (MM16_ELT_d ZN_52) resistor r=6.12113
    rZN_49 (MM16_ELT_d ZN_54) resistor r=12.3172
    rZN_48 (MM16_ELT_d ZN_54) resistor r=1.62887
    rZN_47 (MM16_ELT_d ZN_57) resistor r=2.55965
    rZN_46 (ZN_53 ZN_54) resistor r=12.3172
    rZN_45 (ZN_55 ZN_57) resistor r=14.4784
    rZN_44 (ZN_55 ZN_68) resistor r=10.5593
    rZN_43 (ZN_56 ZN_57) resistor r=14.4784
    rZN_42 (MM18_ELT_d ZN_61) resistor r=2.55965
    rZN_41 (MM18_ELT_d ZN_63) resistor r=12.3172
    rZN_40 (MM18_ELT_d ZN_63) resistor r=1.62887
    rZN_39 (MM18_ELT_d ZN_66) resistor r=6.12113
    rZN_38 (ZN_59 ZN_61) resistor r=14.4784
    rZN_37 (ZN_59 ZN_65) resistor r=9.04062
    rZN_36 (ZN_60 ZN_61) resistor r=14.4784
    rZN_35 (ZN_60 ZN_68) resistor r=10.5593
    rZN_34 (ZN_62 ZN_63) resistor r=12.3172
    rZN_33 (ZN_62 ZN_64) resistor r=9.04595
    rZN_32 (ZN_64 ZN_66) resistor r=31.2341
    rZN_31 (ZN_65 ZN_66) resistor r=31.2341
    rZN_30 (ZN_67 ZN_68) resistor r=0.730683
    rnet031_27 (MM19_ELT_d net031) resistor r=0.01
    rnet031_26 (net031_1 net031_3) resistor r=0.400108
    rnet031_25 (net031_1 net031_13) resistor r=0.0960608
    rnet031_24 (net031_3 net031_4) resistor r=8.66667
    rnet031_23 (net031_3 net031_6) resistor r=0.585524
    rnet031_22 (net031_4 MM20_ELT_s) resistor r=32.3614
    rnet031_21 (net031_6 net031_7) resistor r=8.66667
    rnet031_20 (net031_6 net031_9) resistor r=0.390349
    rnet031_19 (net031_7 MM20_ELT_s) resistor r=16.1807
    rnet031_18 (net031_7 net031_10) resistor r=32.3614
    rnet031_17 (net031_9 net031_10) resistor r=26
    rnet031_16 (net031_12 net031_13) resistor r=3.21169
    rnet031_15 (net031_12 net031_14) resistor r=0.0960608
    rnet031_14 (net031_14 net031_16) resistor r=0.481367
    rnet031_13 (net031_16 net031_17) resistor r=8.66667
    rnet031_12 (net031_16 net031_19) resistor r=0.70444
    rnet031_11 (net031_17 net031) resistor r=32.3614
    rnet031_10 (net031_19 net031_20) resistor r=8.66667
    rnet031_9 (net031_19 net031_22) resistor r=0.469627
    rnet031_8 (net031_20 net031) resistor r=16.1807
    rnet031_7 (net031_20 net031_23) resistor r=32.3614
    rnet031_6 (net031_22 net031_23) resistor r=26
    rVDD_79 (MM18_ELT_b MM16_ELT_b) resistor r=0.01
    rVDD_78 (MM17_ELT_b MM16_ELT_b) resistor r=0.01
    rVDD_77 (MM20_ELT_b MM16_ELT_b) resistor r=0.01
    rVDD_76 (MM15_ELT_b MM16_ELT_b) resistor r=0.01
    rVDD_75 (MM11_ELT_b MM16_ELT_b) resistor r=0.01
    rVDD_74 (MM10_ELT_b MM16_ELT_b) resistor r=0.01
    rVDD_73 (MM19_ELT_b MM16_ELT_b) resistor r=0.01
    rVDD_72 (MM16_ELT_b VDD_19) resistor r=8.66667
    rVDD_71 (MM16_ELT_b VDD_22) resistor r=8.66667
    rVDD_70 (MM16_ELT_b VDD_25) resistor r=8.66667
    rVDD_69 (MM16_ELT_b VDD_40) resistor r=8.66667
    rVDD_68 (MM16_ELT_b VDD_43) resistor r=26
    rVDD_67 (MM16_ELT_b VDD_17) resistor r=45.0133
    rVDD_66 (VDD_2 VDD_25) resistor r=0.098762
    rVDD_65 (VDD_2 VDD_46) resistor r=0.0401681
    rVDD_64 (VDD VDD_7) resistor r=0.102713
    rVDD_63 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_62 (VDD_7 VDD_10) resistor r=0.23737
    rVDD_61 (VDD_8 VDD_11) resistor r=67.52
    rVDD_60 (VDD_10 VDD_11) resistor r=8.66667
    rVDD_59 (VDD_10 VDD_13) resistor r=0.23737
    rVDD_58 (VDD_11 VDD_14) resistor r=67.52
    rVDD_57 (VDD_13 VDD_14) resistor r=8.66667
    rVDD_56 (VDD_13 VDD_16) resistor r=0.23737
    rVDD_55 (VDD_14 VDD_17) resistor r=67.52
    rVDD_54 (VDD_16 VDD_17) resistor r=8.66667
    rVDD_53 (VDD_16 VDD_19) resistor r=0.23737
    rVDD_52 (VDD_19 VDD_22) resistor r=0.23737
    rVDD_51 (VDD_22 VDD_25) resistor r=0.237029
    rVDD_50 (VDD_27 VDD_36) resistor r=0.322827
    rVDD_49 (VDD_27 VDD_46) resistor r=0.0530752
    rVDD_48 (VDD_29 VDD_37) resistor r=8.66667
    rVDD_47 (VDD_29 VDD_33) resistor r=0.530674
    rVDD_46 (VDD_33 VDD_37) resistor r=8.66667
    rVDD_45 (VDD_33 VDD_36) resistor r=0.353783
    rVDD_44 (VDD_36 VDD_37) resistor r=26
    rVDD_43 (VDD_37 MM19_ELT_s) resistor r=4.04518
    rVDD_42 (VDD_37 VDD_67) resistor r=4.04518
    rVDD_41 (VDD_37 MM10_ELT_s) resistor r=4.04518
    rVDD_40 (VDD_37 VDD_65) resistor r=4.04518
    rVDD_39 (VDD_38 VDD_40) resistor r=0.0711087
    rVDD_38 (VDD_38 VDD_46) resistor r=0.0401681
    rVDD_37 (VDD_40 VDD_43) resistor r=0.158019
    rVDD_36 (MM10_ELT_s VDD_50) resistor r=25.7298
    rVDD_35 (MM10_ELT_s VDD_53) resistor r=2.55965
    rVDD_34 (MM10_ELT_s VDD_55) resistor r=12.3172
    rVDD_33 (MM10_ELT_s VDD_55) resistor r=1.62887
    rVDD_32 (VDD_50 VDD_52) resistor r=9.04062
    rVDD_31 (VDD_51 VDD_53) resistor r=14.4784
    rVDD_30 (VDD_51 VDD_68) resistor r=10.5593
    rVDD_29 (VDD_52 VDD_53) resistor r=14.4784
    rVDD_28 (VDD_54 VDD_55) resistor r=12.3172
    rVDD_27 (VDD_54 VDD_66) resistor r=10.2363
    rVDD_26 (MM19_ELT_s VDD_59) resistor r=2.55965
    rVDD_25 (MM19_ELT_s VDD_61) resistor r=12.3172
    rVDD_24 (MM19_ELT_s VDD_61) resistor r=1.62887
    rVDD_23 (MM19_ELT_s VDD_64) resistor r=6.12113
    rVDD_22 (MM19_ELT_s VDD_66) resistor r=10.2363
    rVDD_21 (VDD_57 VDD_59) resistor r=14.4784
    rVDD_20 (VDD_57 VDD_63) resistor r=9.04062
    rVDD_19 (VDD_58 VDD_59) resistor r=14.4784
    rVDD_18 (VDD_58 VDD_68) resistor r=10.5593
    rVDD_17 (VDD_60 VDD_61) resistor r=12.3172
    rVDD_16 (VDD_60 VDD_62) resistor r=9.04595
    rVDD_15 (VDD_62 VDD_64) resistor r=31.2341
    rVDD_14 (VDD_63 VDD_64) resistor r=31.2341
    rVDD_13 (VDD_65 VDD_66) resistor r=0.549089
    rVDD_12 (VDD_67 VDD_68) resistor r=0.730683
    rVSS_133 (MM1_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_132 (MM21_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_131 (MM22_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_130 (MM2_ELT_b VSS_33) resistor r=8.66667
    rVSS_129 (MM2_ELT_b VSS_43) resistor r=8.66667
    rVSS_128 (MM2_ELT_b VSS_46) resistor r=8.66667
    rVSS_127 (MM2_ELT_b VSS_55) resistor r=8.66667
    rVSS_126 (MM2_ELT_b VSS_58) resistor r=26
    rVSS_125 (MM2_ELT_b VSS_31) resistor r=43.1485
    rVSS_124 (VSS_2 VSS_7) resistor r=0.114564
    rVSS_123 (VSS_2 VSS_61) resistor r=0.022141
    rVSS_122 (VSS VSS_7) resistor r=0.100737
    rVSS_121 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_120 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_119 (VSS_9 VSS_11) resistor r=0.404994
    rVSS_118 (VSS_9 VSS_61) resistor r=0.0882358
    rVSS_117 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_116 (VSS_12 MM2_ELT_s) resistor r=4.47446
    rVSS_115 (VSS_12 VSS_101) resistor r=4.99508
    rVSS_114 (VSS_14 VSS_20) resistor r=0.114564
    rVSS_113 (VSS_14 VSS_62) resistor r=0.022141
    rVSS_112 (VSS_15 VSS_17) resistor r=0.0869106
    rVSS_111 (VSS_15 VSS_61) resistor r=0.022141
    rVSS_110 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_109 (VSS_17 VSS_20) resistor r=0.237029
    rVSS_108 (VSS_18 VSS_21) resistor r=64.7228
    rVSS_107 (VSS_20 VSS_21) resistor r=8.66667
    rVSS_106 (VSS_21 VSS_31) resistor r=64.7228
    rVSS_105 (VSS_22 VSS_24) resistor r=0.404994
    rVSS_104 (VSS_22 VSS_62) resistor r=0.0882358
    rVSS_103 (VSS_24 VSS_25) resistor r=8.66667
    rVSS_102 (VSS_25 MM1_ELT_s) resistor r=4.46703
    rVSS_101 (VSS_25 VSS_102) resistor r=5.00251
    rVSS_100 (VSS_27 VSS_33) resistor r=0.114564
    rVSS_99 (VSS_27 VSS_63) resistor r=0.022141
    rVSS_98 (VSS_28 VSS_30) resistor r=0.0869106
    rVSS_97 (VSS_28 VSS_62) resistor r=0.022141
    rVSS_96 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_95 (VSS_30 VSS_33) resistor r=0.237029
    rVSS_94 (VSS_35 VSS_37) resistor r=0.404994
    rVSS_93 (VSS_35 VSS_63) resistor r=0.0882358
    rVSS_92 (VSS_37 VSS_38) resistor r=8.66667
    rVSS_91 (VSS_38 MM21_ELT_s) resistor r=4.46703
    rVSS_90 (VSS_38 VSS_103) resistor r=5.00251
    rVSS_89 (VSS_40 VSS_46) resistor r=0.114564
    rVSS_88 (VSS_40 VSS_64) resistor r=0.022141
    rVSS_87 (VSS_41 VSS_43) resistor r=0.0869106
    rVSS_86 (VSS_41 VSS_63) resistor r=0.022141
    rVSS_85 (VSS_43 VSS_46) resistor r=0.237029
    rVSS_84 (VSS_48 VSS_50) resistor r=0.404994
    rVSS_83 (VSS_48 VSS_64) resistor r=0.0882358
    rVSS_82 (VSS_50 VSS_51) resistor r=8.66667
    rVSS_81 (VSS_51 MM22_ELT_s) resistor r=4.47446
    rVSS_80 (VSS_51 VSS_104) resistor r=4.99508
    rVSS_79 (VSS_53 VSS_55) resistor r=0.0869106
    rVSS_78 (VSS_53 VSS_64) resistor r=0.022141
    rVSS_77 (VSS_55 VSS_58) resistor r=0.158019
    rVSS_76 (MM2_ELT_s VSS_68) resistor r=2.67027
    rVSS_75 (MM2_ELT_s VSS_70) resistor r=12.8495
    rVSS_74 (MM2_ELT_s VSS_70) resistor r=1.69926
    rVSS_73 (MM2_ELT_s VSS_73) resistor r=4.557
    rVSS_72 (VSS_66 VSS_68) resistor r=15.1041
    rVSS_71 (VSS_66 VSS_71) resistor r=9.43134
    rVSS_70 (VSS_67 VSS_68) resistor r=15.1041
    rVSS_69 (VSS_67 VSS_101) resistor r=17.1506
    rVSS_68 (VSS_69 VSS_70) resistor r=12.8495
    rVSS_67 (VSS_69 VSS_72) resistor r=9.4369
    rVSS_66 (VSS_71 VSS_73) resistor r=21.1301
    rVSS_65 (VSS_72 VSS_73) resistor r=21.1301
    rVSS_64 (VSS_74 VSS_77) resistor r=21.1301
    rVSS_63 (VSS_74 VSS_79) resistor r=9.43134
    rVSS_62 (VSS_75 VSS_77) resistor r=21.1301
    rVSS_61 (VSS_75 VSS_81) resistor r=9.4369
    rVSS_60 (MM1_ELT_s VSS_77) resistor r=4.557
    rVSS_59 (MM1_ELT_s VSS_80) resistor r=2.67027
    rVSS_58 (MM1_ELT_s VSS_82) resistor r=12.8495
    rVSS_57 (MM1_ELT_s VSS_82) resistor r=1.69926
    rVSS_56 (VSS_78 VSS_80) resistor r=15.1041
    rVSS_55 (VSS_78 VSS_102) resistor r=17.1506
    rVSS_54 (VSS_79 VSS_80) resistor r=15.1041
    rVSS_53 (VSS_81 VSS_82) resistor r=12.8495
    rVSS_52 (VSS_83 VSS_86) resistor r=21.1301
    rVSS_51 (VSS_83 VSS_88) resistor r=9.43134
    rVSS_50 (VSS_84 VSS_86) resistor r=21.1301
    rVSS_49 (VSS_84 VSS_90) resistor r=9.4369
    rVSS_48 (MM21_ELT_s VSS_86) resistor r=4.557
    rVSS_47 (MM21_ELT_s VSS_89) resistor r=2.67027
    rVSS_46 (MM21_ELT_s VSS_91) resistor r=12.8495
    rVSS_45 (MM21_ELT_s VSS_91) resistor r=1.69926
    rVSS_44 (VSS_87 VSS_89) resistor r=15.1041
    rVSS_43 (VSS_87 VSS_103) resistor r=17.1506
    rVSS_42 (VSS_88 VSS_89) resistor r=15.1041
    rVSS_41 (VSS_90 VSS_91) resistor r=12.8495
    rVSS_40 (MM22_ELT_s VSS_95) resistor r=2.67027
    rVSS_39 (MM22_ELT_s VSS_97) resistor r=12.8495
    rVSS_38 (MM22_ELT_s VSS_97) resistor r=1.69926
    rVSS_37 (MM22_ELT_s VSS_100) resistor r=4.557
    rVSS_36 (VSS_93 VSS_95) resistor r=15.1041
    rVSS_35 (VSS_93 VSS_98) resistor r=9.43134
    rVSS_34 (VSS_94 VSS_95) resistor r=15.1041
    rVSS_33 (VSS_94 VSS_104) resistor r=17.1506
    rVSS_32 (VSS_96 VSS_97) resistor r=12.8495
    rVSS_31 (VSS_96 VSS_99) resistor r=9.4369
    rVSS_30 (VSS_98 VSS_100) resistor r=21.1301
    rVSS_29 (VSS_99 VSS_100) resistor r=21.1301
    rnet026_30 (MM10_ELT_d net026) resistor r=0.01
    rnet026_29 (net026_3 net026_5) resistor r=0.0780698
    rnet026_28 (net026_3 net026_29) resistor r=0.0857634
    rnet026_27 (net026_5 net026_6) resistor r=8.66667
    rnet026_26 (net026_5 net026_8) resistor r=0.585524
    rnet026_25 (net026_6 MM11_ELT_s) resistor r=32.3614
    rnet026_24 (net026_8 net026_9) resistor r=8.66667
    rnet026_23 (net026_8 net026_11) resistor r=0.390349
    rnet026_22 (net026_9 MM11_ELT_s) resistor r=16.1807
    rnet026_21 (net026_9 net026_12) resistor r=32.3614
    rnet026_20 (net026_11 net026_12) resistor r=26
    rnet026_19 (net026_14 net026_15) resistor r=0.569792
    rnet026_18 (net026_14 net026_30) resistor r=0.00864626
    rnet026_17 (net026_15 net026_29) resistor r=0.00864626
    rnet026_16 (net026_18 net026_20) resistor r=0.0939253
    rnet026_15 (net026_18 net026_30) resistor r=0.0857634
    rnet026_14 (net026_20 net026_21) resistor r=8.66667
    rnet026_13 (net026_20 net026_23) resistor r=0.70444
    rnet026_12 (net026_21 net026) resistor r=32.3614
    rnet026_11 (net026_23 net026_24) resistor r=8.66667
    rnet026_10 (net026_23 net026_26) resistor r=0.469627
    rnet026_9 (net026_24 net026) resistor r=16.1807
    rnet026_8 (net026_24 net026_27) resistor r=32.3614
    rnet026_7 (net026_26 net026_27) resistor r=26
    rnet29_27 (MM15_ELT_d net29) resistor r=0.01
    rnet29_26 (net29_1 net29_10) resistor r=0.271773
    rnet29_25 (net29_1 net29_13) resistor r=0.0960608
    rnet29_24 (net29_3 net29_4) resistor r=8.66667
    rnet29_23 (net29_3 net29_7) resistor r=0.639465
    rnet29_22 (net29_4 MM16_ELT_s) resistor r=32.3614
    rnet29_21 (net29_7 net29_8) resistor r=8.66667
    rnet29_20 (net29_7 net29_10) resistor r=0.42631
    rnet29_19 (net29_8 MM16_ELT_s) resistor r=16.1807
    rnet29_18 (net29_8 net29_11) resistor r=32.3614
    rnet29_17 (net29_10 net29_11) resistor r=26
    rnet29_16 (net29_12 net29_13) resistor r=3.36271
    rnet29_15 (net29_12 net29_14) resistor r=0.0960608
    rnet29_14 (net29_14 net29_23) resistor r=0.248848
    rnet29_13 (net29_16 net29_17) resistor r=8.66667
    rnet29_12 (net29_16 net29_20) resistor r=0.585524
    rnet29_11 (net29_17 net29) resistor r=32.3614
    rnet29_10 (net29_20 net29_21) resistor r=8.66667
    rnet29_9 (net29_20 net29_23) resistor r=0.390349
    rnet29_8 (net29_21 net29) resistor r=16.1807
    rnet29_7 (net29_21 net29_24) resistor r=32.3614
    rnet29_6 (net29_23 net29_24) resistor r=26
    rA3_143 (A3_32 A3_38) resistor r=202.392
    rA3_142 (A3_32 A3_38) resistor r=4.16253
    rA3_141 (A3_32 A3_38) resistor r=202.392
    rA3_140 (A3_32 A3_38) resistor r=4.16253
    rA3_139 (A3_35 A3_38) resistor r=202.392
    rA3_138 (A3_35 A3_38) resistor r=4.16253
    rA3_137 (A3_35 A3_38) resistor r=202.392
    rA3_136 (A3_35 A3_38) resistor r=4.16253
    rA3_135 (A3_38 A3_43) resistor r=24.8333
    rA3_134 (A3_38 A3_40) resistor r=24.8333
    rA3_133 (A3_38 A3_51) resistor r=24.8333
    rA3_132 (A3_38 A3_48) resistor r=24.8333
    rA3_131 (A3_38 A3_56) resistor r=14.9
    rA3_130 (A3_38 A3_62) resistor r=202.392
    rA3_129 (A3_38 A3_65) resistor r=202.392
    rA3_128 (A3_38 A3_43) resistor r=4.16253
    rA3_127 (A3_38 A3_51) resistor r=4.16253
    rA3_126 (A3_38 A3_62) resistor r=6.30933
    rA3_125 (A3_38 A3_56) resistor r=6.30933
    rA3_124 (A3_38 A3_40) resistor r=1.63969
    rA3_123 (A3_38 A3_48) resistor r=4.16253
    rA3_122 (A3_38 A3_65) resistor r=4.16253
    rA3_121 (A3_38 A3_43) resistor r=24.8333
    rA3_120 (A3_38 A3_40) resistor r=24.8333
    rA3_119 (A3_38 A3_51) resistor r=24.8333
    rA3_118 (A3_38 A3_48) resistor r=24.8333
    rA3_117 (A3_38 A3_242) resistor r=40.975
    rA3_116 (A3_38 A3_56) resistor r=14.9
    rA3_115 (A3_38 A3_62) resistor r=202.392
    rA3_114 (A3_38 MM20_ELT_g) resistor r=7.45
    rA3_113 (A3_38 A3_43) resistor r=4.16253
    rA3_112 (A3_38 A3_51) resistor r=4.16253
    rA3_111 (A3_38 A3_62) resistor r=6.30933
    rA3_110 (A3_38 A3_56) resistor r=6.30933
    rA3_109 (A3_38 A3_40) resistor r=1.63969
    rA3_108 (A3_38 A3_48) resistor r=4.16253
    rA3_107 (A3_38 A3_65) resistor r=4.16253
    rA3_106 (A3_65 MM20_ELT_g) resistor r=194.942
    rA3_105 (A3_70 A3_76) resistor r=58.3583
    rA3_104 (A3_70 A3_76) resistor r=4.16253
    rA3_103 (A3_70 A3_76) resistor r=58.3583
    rA3_102 (A3_70 A3_76) resistor r=4.16253
    rA3_101 (A3_73 A3_76) resistor r=58.3583
    rA3_100 (A3_73 A3_76) resistor r=4.16253
    rA3_99 (A3_73 A3_76) resistor r=58.3583
    rA3_98 (A3_73 A3_76) resistor r=4.16253
    rA3_97 (A3_76 A3_89) resistor r=24.8333
    rA3_96 (A3_76 A3_86) resistor r=24.8333
    rA3_95 (A3_76 A3_97) resistor r=24.8333
    rA3_94 (A3_76 A3_94) resistor r=24.8333
    rA3_93 (A3_76 A3_118) resistor r=58.3583
    rA3_92 (A3_76 A3_121) resistor r=58.3583
    rA3_91 (A3_76 A3_126) resistor r=14.9
    rA3_90 (A3_76 A3_89) resistor r=4.16253
    rA3_89 (A3_76 A3_97) resistor r=4.16253
    rA3_88 (A3_76 A3_86) resistor r=4.16253
    rA3_87 (A3_76 A3_118) resistor r=4.16253
    rA3_86 (A3_76 A3_126) resistor r=6.30933
    rA3_85 (A3_76 A3_121) resistor r=6.30933
    rA3_84 (A3_76 A3_94) resistor r=1.63969
    rA3_83 (A3_76 A3_89) resistor r=24.8333
    rA3_82 (A3_76 A3_86) resistor r=24.8333
    rA3_81 (A3_76 A3_97) resistor r=24.8333
    rA3_80 (A3_76 A3_94) resistor r=24.8333
    rA3_79 (A3_76 A3_118) resistor r=58.3583
    rA3_78 (A3_76 MM21_ELT_g) resistor r=22.35
    rA3_77 (A3_76 A3_126) resistor r=14.9
    rA3_76 (A3_76 A3_274) resistor r=40.975
    rA3_75 (A3_76 A3_89) resistor r=4.16253
    rA3_74 (A3_76 A3_97) resistor r=4.16253
    rA3_73 (A3_76 A3_86) resistor r=4.16253
    rA3_72 (A3_76 A3_118) resistor r=4.16253
    rA3_71 (A3_76 A3_126) resistor r=6.30933
    rA3_70 (A3_76 A3_121) resistor r=6.30933
    rA3_69 (A3_76 A3_94) resistor r=1.63969
    rA3_68 (A3_78 A3_84) resistor r=202.392
    rA3_67 (A3_78 A3_84) resistor r=4.16253
    rA3_66 (A3_78 A3_84) resistor r=202.392
    rA3_65 (A3_78 A3_84) resistor r=4.16253
    rA3_64 (A3_81 A3_84) resistor r=202.392
    rA3_63 (A3_81 A3_84) resistor r=4.16253
    rA3_62 (A3_81 A3_84) resistor r=202.392
    rA3_61 (A3_81 A3_84) resistor r=4.16253
    rA3_60 (A3_84 A3_105) resistor r=24.8333
    rA3_59 (A3_84 A3_102) resistor r=24.8333
    rA3_58 (A3_84 A3_113) resistor r=24.8333
    rA3_57 (A3_84 A3_110) resistor r=24.8333
    rA3_56 (A3_84 A3_132) resistor r=14.9
    rA3_55 (A3_84 A3_138) resistor r=202.392
    rA3_54 (A3_84 A3_141) resistor r=202.392
    rA3_53 (A3_84 A3_105) resistor r=4.16253
    rA3_52 (A3_84 A3_113) resistor r=4.16253
    rA3_51 (A3_84 A3_138) resistor r=6.30933
    rA3_50 (A3_84 A3_132) resistor r=6.30933
    rA3_49 (A3_84 A3_102) resistor r=1.63969
    rA3_48 (A3_84 A3_110) resistor r=4.16253
    rA3_47 (A3_84 A3_141) resistor r=4.16253
    rA3_46 (A3_84 A3_105) resistor r=24.8333
    rA3_45 (A3_84 A3_102) resistor r=24.8333
    rA3_44 (A3_84 A3_113) resistor r=24.8333
    rA3_43 (A3_84 A3_110) resistor r=24.8333
    rA3_42 (A3_84 A3_276) resistor r=40.975
    rA3_41 (A3_84 A3_132) resistor r=14.9
    rA3_40 (A3_84 A3_138) resistor r=202.392
    rA3_39 (A3_84 MM15_ELT_g) resistor r=7.45
    rA3_38 (A3_84 A3_105) resistor r=4.16253
    rA3_37 (A3_84 A3_113) resistor r=4.16253
    rA3_36 (A3_84 A3_138) resistor r=6.30933
    rA3_35 (A3_84 A3_132) resistor r=6.30933
    rA3_34 (A3_84 A3_102) resistor r=1.63969
    rA3_33 (A3_84 A3_110) resistor r=4.16253
    rA3_32 (A3_84 A3_141) resistor r=4.16253
    rA3_31 (A3_121 MM21_ELT_g) resistor r=36.0083
    rA3_30 (A3_141 MM15_ELT_g) resistor r=194.942
    rA3_29 (A3_197 A3_198) resistor r=10
    rA3_28 (A3_197 A3) resistor r=0.0879454
    rA3_27 (A3_198 A3_286) resistor r=24.3818
    rA3_26 (A3_198 A3_295) resistor r=59.6
    rA3_25 (A3_242 A3_286) resistor r=9.29775
    rA3_24 (A3_274 A3_296) resistor r=10.0997
    rA3_23 (A3_276 A3_296) resistor r=10.0997
    rA3_22 (A3_295 A3_296) resistor r=0.877078
    rnet033_34 (MM17_ELT_d net033) resistor r=0.01
    rnet033_33 (net033_1 net033_7) resistor r=0.298417
    rnet033_32 (net033_1 net033_27) resistor r=0.0857634
    rnet033_31 (net033_3 net033_4) resistor r=8.66667
    rnet033_30 (net033_3 net033_7) resistor r=0.639465
    rnet033_29 (net033_4 MM18_ELT_s) resistor r=32.3614
    rnet033_28 (net033_7 net033_8) resistor r=8.66667
    rnet033_27 (net033_8 MM18_ELT_s) resistor r=16.1807
    rnet033_26 (net033_8 net033_12) resistor r=32.3614
    rnet033_25 (net033_9 net033_11) resistor r=0.0191078
    rnet033_24 (net033_9 net033_27) resistor r=0.0857634
    rnet033_23 (net033_11 net033_12) resistor r=26
    rnet033_22 (net033_13 net033_14) resistor r=0.555759
    rnet033_21 (net033_13 net033_28) resistor r=0.00864626
    rnet033_20 (net033_14 net033_27) resistor r=0.00864626
    rnet033_19 (net033_15 net033_21) resistor r=0.273244
    rnet033_18 (net033_15 net033_28) resistor r=0.0857634
    rnet033_17 (net033_17 net033_18) resistor r=8.66667
    rnet033_16 (net033_17 net033_21) resistor r=0.585524
    rnet033_15 (net033_18 net033) resistor r=32.3614
    rnet033_14 (net033_21 net033_22) resistor r=8.66667
    rnet033_13 (net033_22 net033) resistor r=16.1807
    rnet033_12 (net033_22 net033_26) resistor r=32.3614
    rnet033_11 (net033_23 net033_25) resistor r=0.0191078
    rnet033_10 (net033_23 net033_28) resistor r=0.0857634
    rnet033_9 (net033_25 net033_26) resistor r=26
    rA2_162 (A2_32 A2_38) resistor r=58.3583
    rA2_161 (A2_32 A2_38) resistor r=4.16253
    rA2_160 (A2_32 A2_38) resistor r=58.3583
    rA2_159 (A2_32 A2_38) resistor r=4.16253
    rA2_158 (A2_35 A2_38) resistor r=58.3583
    rA2_157 (A2_35 A2_38) resistor r=4.16253
    rA2_156 (A2_35 A2_38) resistor r=58.3583
    rA2_155 (A2_35 A2_38) resistor r=4.16253
    rA2_154 (A2_38 A2_51) resistor r=24.8333
    rA2_153 (A2_38 A2_48) resistor r=24.8333
    rA2_152 (A2_38 A2_59) resistor r=24.8333
    rA2_151 (A2_38 A2_56) resistor r=24.8333
    rA2_150 (A2_38 A2_80) resistor r=58.3583
    rA2_149 (A2_38 A2_83) resistor r=58.3583
    rA2_148 (A2_38 A2_88) resistor r=14.9
    rA2_147 (A2_38 A2_51) resistor r=4.16253
    rA2_146 (A2_38 A2_59) resistor r=4.16253
    rA2_145 (A2_38 A2_48) resistor r=4.16253
    rA2_144 (A2_38 A2_80) resistor r=4.16253
    rA2_143 (A2_38 A2_88) resistor r=6.30933
    rA2_142 (A2_38 A2_83) resistor r=6.30933
    rA2_141 (A2_38 A2_56) resistor r=1.63969
    rA2_140 (A2_38 A2_51) resistor r=24.8333
    rA2_139 (A2_38 A2_48) resistor r=24.8333
    rA2_138 (A2_38 A2_59) resistor r=24.8333
    rA2_137 (A2_38 A2_56) resistor r=24.8333
    rA2_136 (A2_38 A2_80) resistor r=58.3583
    rA2_135 (A2_38 MM1_ELT_g) resistor r=22.35
    rA2_134 (A2_38 A2_88) resistor r=14.9
    rA2_133 (A2_38 A2_266) resistor r=40.975
    rA2_132 (A2_38 A2_51) resistor r=4.16253
    rA2_131 (A2_38 A2_59) resistor r=4.16253
    rA2_130 (A2_38 A2_48) resistor r=4.16253
    rA2_129 (A2_38 A2_80) resistor r=4.16253
    rA2_128 (A2_38 A2_88) resistor r=6.30933
    rA2_127 (A2_38 A2_83) resistor r=6.30933
    rA2_126 (A2_38 A2_56) resistor r=1.63969
    rA2_125 (A2_40 A2_46) resistor r=202.392
    rA2_124 (A2_40 A2_46) resistor r=4.16253
    rA2_123 (A2_40 A2_46) resistor r=202.392
    rA2_122 (A2_40 A2_46) resistor r=4.16253
    rA2_121 (A2_43 A2_46) resistor r=202.392
    rA2_120 (A2_43 A2_46) resistor r=4.16253
    rA2_119 (A2_43 A2_46) resistor r=202.392
    rA2_118 (A2_43 A2_46) resistor r=4.16253
    rA2_117 (A2_46 A2_67) resistor r=24.8333
    rA2_116 (A2_46 A2_64) resistor r=24.8333
    rA2_115 (A2_46 A2_75) resistor r=24.8333
    rA2_114 (A2_46 A2_72) resistor r=24.8333
    rA2_113 (A2_46 A2_94) resistor r=14.9
    rA2_112 (A2_46 A2_100) resistor r=202.392
    rA2_111 (A2_46 A2_103) resistor r=202.392
    rA2_110 (A2_46 A2_67) resistor r=4.16253
    rA2_109 (A2_46 A2_75) resistor r=4.16253
    rA2_108 (A2_46 A2_100) resistor r=6.30933
    rA2_107 (A2_46 A2_94) resistor r=6.30933
    rA2_106 (A2_46 A2_64) resistor r=1.63969
    rA2_105 (A2_46 A2_72) resistor r=4.16253
    rA2_104 (A2_46 A2_103) resistor r=4.16253
    rA2_103 (A2_46 A2_67) resistor r=24.8333
    rA2_102 (A2_46 A2_64) resistor r=24.8333
    rA2_101 (A2_46 A2_75) resistor r=24.8333
    rA2_100 (A2_46 A2_72) resistor r=24.8333
    rA2_99 (A2_46 A2_268) resistor r=40.975
    rA2_98 (A2_46 A2_94) resistor r=14.9
    rA2_97 (A2_46 A2_100) resistor r=202.392
    rA2_96 (A2_46 MM17_ELT_g) resistor r=7.45
    rA2_95 (A2_46 A2_67) resistor r=4.16253
    rA2_94 (A2_46 A2_75) resistor r=4.16253
    rA2_93 (A2_46 A2_100) resistor r=6.30933
    rA2_92 (A2_46 A2_94) resistor r=6.30933
    rA2_91 (A2_46 A2_64) resistor r=1.63969
    rA2_90 (A2_46 A2_72) resistor r=4.16253
    rA2_89 (A2_46 A2_103) resistor r=4.16253
    rA2_88 (A2_83 MM1_ELT_g) resistor r=36.0083
    rA2_87 (A2_103 MM17_ELT_g) resistor r=194.942
    rA2_86 (A2_108 A2_111) resistor r=14.9
    rA2_85 (A2_108 A2_111) resistor r=6.30933
    rA2_84 (A2_108 A2_111) resistor r=14.9
    rA2_83 (A2_108 A2_111) resistor r=6.30933
    rA2_82 (A2_111 A2_114) resistor r=202.392
    rA2_81 (A2_111 A2_117) resistor r=202.392
    rA2_80 (A2_111 A2_125) resistor r=24.8333
    rA2_79 (A2_111 A2_122) resistor r=24.8333
    rA2_78 (A2_111 A2_133) resistor r=24.8333
    rA2_77 (A2_111 A2_130) resistor r=24.8333
    rA2_76 (A2_111 A2_138) resistor r=202.392
    rA2_75 (A2_111 A2_141) resistor r=202.392
    rA2_74 (A2_111 A2_114) resistor r=6.30933
    rA2_73 (A2_111 A2_125) resistor r=1.63969
    rA2_72 (A2_111 A2_133) resistor r=4.16253
    rA2_71 (A2_111 A2_117) resistor r=4.16253
    rA2_70 (A2_111 A2_122) resistor r=4.16253
    rA2_69 (A2_111 A2_138) resistor r=4.16253
    rA2_68 (A2_111 A2_130) resistor r=4.16253
    rA2_67 (A2_111 A2_141) resistor r=4.16253
    rA2_66 (A2_111 A2_278) resistor r=40.975
    rA2_65 (A2_111 A2_114) resistor r=202.392
    rA2_64 (A2_111 A2_117) resistor r=202.392
    rA2_63 (A2_111 A2_125) resistor r=24.8333
    rA2_62 (A2_111 A2_122) resistor r=24.8333
    rA2_61 (A2_111 A2_133) resistor r=24.8333
    rA2_60 (A2_111 A2_130) resistor r=24.8333
    rA2_59 (A2_111 A2_138) resistor r=202.392
    rA2_58 (A2_111 MM11_ELT_g) resistor r=7.45
    rA2_57 (A2_111 A2_114) resistor r=6.30933
    rA2_56 (A2_111 A2_125) resistor r=1.63969
    rA2_55 (A2_111 A2_133) resistor r=4.16253
    rA2_54 (A2_111 A2_117) resistor r=4.16253
    rA2_53 (A2_111 A2_122) resistor r=4.16253
    rA2_52 (A2_111 A2_138) resistor r=4.16253
    rA2_51 (A2_111 A2_130) resistor r=4.16253
    rA2_50 (A2_111 A2_141) resistor r=4.16253
    rA2_49 (A2_141 MM11_ELT_g) resistor r=194.942
    rA2_48 (A2_196 A2_198) resistor r=0.14817
    rA2_47 (A2_196 A2_201) resistor r=0.0766115
    rA2_46 (A2_198 A2_199) resistor r=0.75
    rA2_45 (A2_199 A2_312) resistor r=10
    rA2_44 (A2_199 A2) resistor r=0.086861
    rA2_43 (A2_201 A2_202) resistor r=0.354828
    rA2_42 (A2_202 A2_204) resistor r=0.0767387
    rA2_41 (A2_203 A2_204) resistor r=1.07928
    rA2_40 (A2_203 A2_206) resistor r=0.0767387
    rA2_39 (A2_205 A2_206) resistor r=0.354828
    rA2_38 (A2_205 A2_210) resistor r=0.0383057
    rA2_37 (A2_210 A2_211) resistor r=0.75
    rA2_36 (A2_211 A2_316) resistor r=10
    rA2_35 (A2_266 A2_304) resistor r=3.725
    rA2_34 (A2_268 A2_304) resistor r=3.725
    rA2_33 (A2_278 A2_316) resistor r=5.35325
    rA2_32 (A2_303 A2_304) resistor r=3.725
    rA2_31 (A2_303 A2_312) resistor r=9.48182
    rA1_164 (A1_32 A1_38) resistor r=58.3583
    rA1_163 (A1_32 A1_38) resistor r=4.16253
    rA1_162 (A1_32 A1_38) resistor r=58.3583
    rA1_161 (A1_32 A1_38) resistor r=4.16253
    rA1_160 (A1_35 A1_38) resistor r=58.3583
    rA1_159 (A1_35 A1_38) resistor r=6.30933
    rA1_158 (A1_35 A1_38) resistor r=58.3583
    rA1_157 (A1_35 A1_38) resistor r=6.30933
    rA1_156 (A1_38 A1_40) resistor r=14.9
    rA1_155 (A1_38 A1_63) resistor r=24.8333
    rA1_154 (A1_38 A1_60) resistor r=24.8333
    rA1_153 (A1_38 A1_71) resistor r=24.8333
    rA1_152 (A1_38 A1_68) resistor r=24.8333
    rA1_151 (A1_38 A1_92) resistor r=58.3583
    rA1_150 (A1_38 A1_95) resistor r=58.3583
    rA1_149 (A1_38 A1_63) resistor r=4.16253
    rA1_148 (A1_38 A1_40) resistor r=6.30933
    rA1_147 (A1_38 A1_71) resistor r=1.63969
    rA1_146 (A1_38 A1_60) resistor r=4.16253
    rA1_145 (A1_38 A1_92) resistor r=4.16253
    rA1_144 (A1_38 A1_68) resistor r=4.16253
    rA1_143 (A1_38 A1_95) resistor r=4.16253
    rA1_142 (A1_38 A1_40) resistor r=14.9
    rA1_141 (A1_38 A1_246) resistor r=40.975
    rA1_140 (A1_38 A1_63) resistor r=24.8333
    rA1_139 (A1_38 A1_60) resistor r=24.8333
    rA1_138 (A1_38 A1_71) resistor r=24.8333
    rA1_137 (A1_38 A1_68) resistor r=24.8333
    rA1_136 (A1_38 A1_92) resistor r=58.3583
    rA1_135 (A1_38 MM2_ELT_g) resistor r=7.45
    rA1_134 (A1_38 A1_63) resistor r=4.16253
    rA1_133 (A1_38 A1_40) resistor r=6.30933
    rA1_132 (A1_38 A1_71) resistor r=1.63969
    rA1_131 (A1_38 A1_60) resistor r=4.16253
    rA1_130 (A1_38 A1_92) resistor r=4.16253
    rA1_129 (A1_38 A1_68) resistor r=4.16253
    rA1_128 (A1_38 A1_95) resistor r=4.16253
    rA1_127 (A1_46 A1_49) resistor r=14.9
    rA1_126 (A1_46 A1_49) resistor r=6.30933
    rA1_125 (A1_46 A1_49) resistor r=14.9
    rA1_124 (A1_46 A1_49) resistor r=6.30933
    rA1_123 (A1_49 A1_52) resistor r=202.392
    rA1_122 (A1_49 A1_55) resistor r=202.392
    rA1_121 (A1_49 A1_79) resistor r=24.8333
    rA1_120 (A1_49 A1_76) resistor r=24.8333
    rA1_119 (A1_49 A1_87) resistor r=24.8333
    rA1_118 (A1_49 A1_84) resistor r=24.8333
    rA1_117 (A1_49 A1_100) resistor r=202.392
    rA1_116 (A1_49 A1_103) resistor r=202.392
    rA1_115 (A1_49 A1_52) resistor r=6.30933
    rA1_114 (A1_49 A1_79) resistor r=1.63969
    rA1_113 (A1_49 A1_87) resistor r=4.16253
    rA1_112 (A1_49 A1_55) resistor r=4.16253
    rA1_111 (A1_49 A1_76) resistor r=4.16253
    rA1_110 (A1_49 A1_100) resistor r=4.16253
    rA1_109 (A1_49 A1_84) resistor r=4.16253
    rA1_108 (A1_49 A1_103) resistor r=4.16253
    rA1_107 (A1_49 A1_248) resistor r=40.975
    rA1_106 (A1_49 A1_52) resistor r=202.392
    rA1_105 (A1_49 A1_55) resistor r=202.392
    rA1_104 (A1_49 A1_79) resistor r=24.8333
    rA1_103 (A1_49 A1_76) resistor r=24.8333
    rA1_102 (A1_49 A1_87) resistor r=24.8333
    rA1_101 (A1_49 A1_84) resistor r=24.8333
    rA1_100 (A1_49 A1_100) resistor r=202.392
    rA1_99 (A1_49 MM18_ELT_g) resistor r=7.45
    rA1_98 (A1_49 A1_52) resistor r=6.30933
    rA1_97 (A1_49 A1_79) resistor r=1.63969
    rA1_96 (A1_49 A1_87) resistor r=4.16253
    rA1_95 (A1_49 A1_55) resistor r=4.16253
    rA1_94 (A1_49 A1_76) resistor r=4.16253
    rA1_93 (A1_49 A1_100) resistor r=4.16253
    rA1_92 (A1_49 A1_84) resistor r=4.16253
    rA1_91 (A1_49 A1_103) resistor r=4.16253
    rA1_90 (A1_95 MM2_ELT_g) resistor r=50.9083
    rA1_89 (A1_103 MM18_ELT_g) resistor r=194.942
    rA1_88 (A1_108 A1_111) resistor r=14.9
    rA1_87 (A1_108 A1_111) resistor r=6.30933
    rA1_86 (A1_108 A1_111) resistor r=14.9
    rA1_85 (A1_108 A1_111) resistor r=6.30933
    rA1_84 (A1_111 A1_114) resistor r=202.392
    rA1_83 (A1_111 A1_117) resistor r=202.392
    rA1_82 (A1_111 A1_125) resistor r=24.8333
    rA1_81 (A1_111 A1_122) resistor r=24.8333
    rA1_80 (A1_111 A1_133) resistor r=24.8333
    rA1_79 (A1_111 A1_130) resistor r=24.8333
    rA1_78 (A1_111 A1_138) resistor r=202.392
    rA1_77 (A1_111 A1_141) resistor r=202.392
    rA1_76 (A1_111 A1_114) resistor r=6.30933
    rA1_75 (A1_111 A1_125) resistor r=1.63969
    rA1_74 (A1_111 A1_133) resistor r=4.16253
    rA1_73 (A1_111 A1_117) resistor r=4.16253
    rA1_72 (A1_111 A1_122) resistor r=4.16253
    rA1_71 (A1_111 A1_138) resistor r=4.16253
    rA1_70 (A1_111 A1_130) resistor r=4.16253
    rA1_69 (A1_111 A1_141) resistor r=4.16253
    rA1_68 (A1_111 A1_276) resistor r=40.975
    rA1_67 (A1_111 A1_114) resistor r=202.392
    rA1_66 (A1_111 A1_117) resistor r=202.392
    rA1_65 (A1_111 A1_125) resistor r=24.8333
    rA1_64 (A1_111 A1_122) resistor r=24.8333
    rA1_63 (A1_111 A1_133) resistor r=24.8333
    rA1_62 (A1_111 A1_130) resistor r=24.8333
    rA1_61 (A1_111 A1_138) resistor r=202.392
    rA1_60 (A1_111 MM10_ELT_g) resistor r=7.45
    rA1_59 (A1_111 A1_114) resistor r=6.30933
    rA1_58 (A1_111 A1_125) resistor r=1.63969
    rA1_57 (A1_111 A1_133) resistor r=4.16253
    rA1_56 (A1_111 A1_117) resistor r=4.16253
    rA1_55 (A1_111 A1_122) resistor r=4.16253
    rA1_54 (A1_111 A1_138) resistor r=4.16253
    rA1_53 (A1_111 A1_130) resistor r=4.16253
    rA1_52 (A1_111 A1_141) resistor r=4.16253
    rA1_51 (A1_141 MM10_ELT_g) resistor r=194.942
    rA1_50 (A1_196 A1_198) resistor r=0.14817
    rA1_49 (A1_196 A1_201) resistor r=0.0766115
    rA1_48 (A1_198 A1_199) resistor r=0.75
    rA1_47 (A1_199 A1_312) resistor r=10
    rA1_46 (A1_199 A1) resistor r=0.086861
    rA1_45 (A1_201 A1_202) resistor r=0.545889
    rA1_44 (A1_202 A1_204) resistor r=0.0767387
    rA1_43 (A1_203 A1_204) resistor r=2.21701
    rA1_42 (A1_203 A1_206) resistor r=0.0767387
    rA1_41 (A1_205 A1_206) resistor r=0.545889
    rA1_40 (A1_205 A1_210) resistor r=0.0383057
    rA1_39 (A1_210 A1_211) resistor r=0.75
    rA1_38 (A1_211 A1_316) resistor r=10
    rA1_37 (A1_246 A1_298) resistor r=10.0997
    rA1_36 (A1_248 A1_298) resistor r=10.0997
    rA1_35 (A1_276 A1_306) resistor r=4.38767
    rA1_34 (A1_297 A1_298) resistor r=0.877078
    rA1_33 (A1_297 A1_312) resistor r=14.2227
    rA1_32 (A1_305 A1_306) resistor r=3.71511
    rA1_31 (A1_305 A1_316) resistor r=9.48182
    rA4_159 (A4_32 A4_38) resistor r=202.392
    rA4_158 (A4_32 A4_38) resistor r=4.16253
    rA4_157 (A4_32 A4_38) resistor r=202.392
    rA4_156 (A4_32 A4_38) resistor r=4.16253
    rA4_155 (A4_35 A4_38) resistor r=202.392
    rA4_154 (A4_35 A4_38) resistor r=4.16253
    rA4_153 (A4_35 A4_38) resistor r=202.392
    rA4_152 (A4_35 A4_38) resistor r=4.16253
    rA4_151 (A4_38 A4_43) resistor r=24.8333
    rA4_150 (A4_38 A4_40) resistor r=24.8333
    rA4_149 (A4_38 A4_51) resistor r=24.8333
    rA4_148 (A4_38 A4_48) resistor r=24.8333
    rA4_147 (A4_38 A4_56) resistor r=14.9
    rA4_146 (A4_38 A4_62) resistor r=202.392
    rA4_145 (A4_38 A4_65) resistor r=202.392
    rA4_144 (A4_38 A4_43) resistor r=4.16253
    rA4_143 (A4_38 A4_51) resistor r=4.16253
    rA4_142 (A4_38 A4_62) resistor r=6.30933
    rA4_141 (A4_38 A4_56) resistor r=6.30933
    rA4_140 (A4_38 A4_40) resistor r=1.63969
    rA4_139 (A4_38 A4_48) resistor r=4.16253
    rA4_138 (A4_38 A4_65) resistor r=4.16253
    rA4_137 (A4_38 A4_43) resistor r=24.8333
    rA4_136 (A4_38 A4_40) resistor r=24.8333
    rA4_135 (A4_38 A4_51) resistor r=24.8333
    rA4_134 (A4_38 A4_48) resistor r=24.8333
    rA4_133 (A4_38 A4_251) resistor r=40.975
    rA4_132 (A4_38 A4_56) resistor r=14.9
    rA4_131 (A4_38 A4_62) resistor r=202.392
    rA4_130 (A4_38 MM16_ELT_g) resistor r=7.45
    rA4_129 (A4_38 A4_43) resistor r=4.16253
    rA4_128 (A4_38 A4_51) resistor r=4.16253
    rA4_127 (A4_38 A4_62) resistor r=6.30933
    rA4_126 (A4_38 A4_56) resistor r=6.30933
    rA4_125 (A4_38 A4_40) resistor r=1.63969
    rA4_124 (A4_38 A4_48) resistor r=4.16253
    rA4_123 (A4_38 A4_65) resistor r=4.16253
    rA4_122 (A4_65 MM16_ELT_g) resistor r=194.942
    rA4_121 (A4_70 A4_76) resistor r=58.3583
    rA4_120 (A4_70 A4_76) resistor r=4.16253
    rA4_119 (A4_70 A4_76) resistor r=58.3583
    rA4_118 (A4_70 A4_76) resistor r=4.16253
    rA4_117 (A4_73 A4_76) resistor r=58.3583
    rA4_116 (A4_73 A4_76) resistor r=6.30933
    rA4_115 (A4_73 A4_76) resistor r=58.3583
    rA4_114 (A4_73 A4_76) resistor r=6.30933
    rA4_113 (A4_76 A4_78) resistor r=14.9
    rA4_112 (A4_76 A4_101) resistor r=24.8333
    rA4_111 (A4_76 A4_98) resistor r=24.8333
    rA4_110 (A4_76 A4_109) resistor r=24.8333
    rA4_109 (A4_76 A4_106) resistor r=24.8333
    rA4_108 (A4_76 A4_130) resistor r=58.3583
    rA4_107 (A4_76 A4_133) resistor r=58.3583
    rA4_106 (A4_76 A4_101) resistor r=4.16253
    rA4_105 (A4_76 A4_78) resistor r=6.30933
    rA4_104 (A4_76 A4_109) resistor r=1.63969
    rA4_103 (A4_76 A4_98) resistor r=4.16253
    rA4_102 (A4_76 A4_130) resistor r=4.16253
    rA4_101 (A4_76 A4_106) resistor r=4.16253
    rA4_100 (A4_76 A4_133) resistor r=4.16253
    rA4_99 (A4_76 A4_78) resistor r=14.9
    rA4_98 (A4_76 A4_263) resistor r=40.975
    rA4_97 (A4_76 A4_101) resistor r=24.8333
    rA4_96 (A4_76 A4_98) resistor r=24.8333
    rA4_95 (A4_76 A4_109) resistor r=24.8333
    rA4_94 (A4_76 A4_106) resistor r=24.8333
    rA4_93 (A4_76 A4_130) resistor r=58.3583
    rA4_92 (A4_76 MM22_ELT_g) resistor r=7.45
    rA4_91 (A4_76 A4_101) resistor r=4.16253
    rA4_90 (A4_76 A4_78) resistor r=6.30933
    rA4_89 (A4_76 A4_109) resistor r=1.63969
    rA4_88 (A4_76 A4_98) resistor r=4.16253
    rA4_87 (A4_76 A4_130) resistor r=4.16253
    rA4_86 (A4_76 A4_106) resistor r=4.16253
    rA4_85 (A4_76 A4_133) resistor r=4.16253
    rA4_84 (A4_84 A4_87) resistor r=14.9
    rA4_83 (A4_84 A4_87) resistor r=6.30933
    rA4_82 (A4_84 A4_87) resistor r=14.9
    rA4_81 (A4_84 A4_87) resistor r=6.30933
    rA4_80 (A4_87 A4_90) resistor r=202.392
    rA4_79 (A4_87 A4_93) resistor r=202.392
    rA4_78 (A4_87 A4_117) resistor r=24.8333
    rA4_77 (A4_87 A4_114) resistor r=24.8333
    rA4_76 (A4_87 A4_125) resistor r=24.8333
    rA4_75 (A4_87 A4_122) resistor r=24.8333
    rA4_74 (A4_87 A4_138) resistor r=202.392
    rA4_73 (A4_87 A4_141) resistor r=202.392
    rA4_72 (A4_87 A4_90) resistor r=6.30933
    rA4_71 (A4_87 A4_117) resistor r=1.63969
    rA4_70 (A4_87 A4_125) resistor r=4.16253
    rA4_69 (A4_87 A4_93) resistor r=4.16253
    rA4_68 (A4_87 A4_114) resistor r=4.16253
    rA4_67 (A4_87 A4_138) resistor r=4.16253
    rA4_66 (A4_87 A4_122) resistor r=4.16253
    rA4_65 (A4_87 A4_141) resistor r=4.16253
    rA4_64 (A4_87 A4_265) resistor r=40.975
    rA4_63 (A4_87 A4_90) resistor r=202.392
    rA4_62 (A4_87 A4_93) resistor r=202.392
    rA4_61 (A4_87 A4_117) resistor r=24.8333
    rA4_60 (A4_87 A4_114) resistor r=24.8333
    rA4_59 (A4_87 A4_125) resistor r=24.8333
    rA4_58 (A4_87 A4_122) resistor r=24.8333
    rA4_57 (A4_87 A4_138) resistor r=202.392
    rA4_56 (A4_87 MM19_ELT_g) resistor r=7.45
    rA4_55 (A4_87 A4_90) resistor r=6.30933
    rA4_54 (A4_87 A4_117) resistor r=1.63969
    rA4_53 (A4_87 A4_125) resistor r=4.16253
    rA4_52 (A4_87 A4_93) resistor r=4.16253
    rA4_51 (A4_87 A4_114) resistor r=4.16253
    rA4_50 (A4_87 A4_138) resistor r=4.16253
    rA4_49 (A4_87 A4_122) resistor r=4.16253
    rA4_48 (A4_87 A4_141) resistor r=4.16253
    rA4_47 (A4_133 MM22_ELT_g) resistor r=50.9083
    rA4_46 (A4_141 MM19_ELT_g) resistor r=194.942
    rA4_45 (A4_196 A4_198) resistor r=0.14817
    rA4_44 (A4_196 A4_202) resistor r=0.0766115
    rA4_43 (A4_198 A4_199) resistor r=0.75
    rA4_42 (A4_199 A4_309) resistor r=10
    rA4_41 (A4_201 A4_202) resistor r=0.366526
    rA4_40 (A4_201 A4_204) resistor r=0.0767387
    rA4_39 (A4_203 A4_204) resistor r=2.89875
    rA4_38 (A4_203 A4_205) resistor r=0.0767387
    rA4_37 (A4_205 A4_206) resistor r=0.366526
    rA4_36 (A4_206 A4_210) resistor r=0.0383057
    rA4_35 (A4_210 A4_211) resistor r=0.75
    rA4_34 (A4_211 A4_313) resistor r=10
    rA4_33 (A4_211 A4) resistor r=0.127521
    rA4_32 (A4_251 A4_295) resistor r=9.29775
    rA4_31 (A4_263 A4_301) resistor r=10.0997
    rA4_30 (A4_265 A4_301) resistor r=10.0997
    rA4_29 (A4_295 A4_309) resistor r=35.2182
    rA4_28 (A4_300 A4_301) resistor r=0.877078
    rA4_27 (A4_300 A4_313) resistor r=6.09545
ends NR4D1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: MUX2ISO_LVT_ELT
// View name: calibre
subckt MUX2ISO_LVT_ELT VDD VSS in0 in1 out s
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet74_7 (net74_4 VSS) capacitor c=2.14818e-18
    cinet74_6 (net74_8 VSS) capacitor c=5.40001e-18
    cinet74_5 (net74_9 VSS) capacitor c=3.93978e-18
    cinet74_4 (MM11_ELT_d VSS) capacitor c=5.4695e-18
    cinet74_3 (net74_13 VSS) capacitor c=1.91958e-18
    cinet74_2 (net74_16 VSS) capacitor c=1.13997e-17
    cinet74_1 (net74_18 VSS) capacitor c=9.75809e-18
    cinet74_0 (net74 VSS) capacitor c=7.71422e-18
    cinet73_7 (net73_4 VSS) capacitor c=2.35978e-18
    cinet73_6 (net73_7 VSS) capacitor c=1.01306e-17
    cinet73_5 (net73_8 VSS) capacitor c=1.26338e-20
    cinet73_4 (net73_9 VSS) capacitor c=5.62367e-18
    cinet73_3 (MM1_ELT_s VSS) capacitor c=6.39409e-18
    cinet73_2 (net73_13 VSS) capacitor c=1.80205e-18
    cinet73_1 (net73_18 VSS) capacitor c=6.98422e-18
    cinet73_0 (net73 VSS) capacitor c=8.28695e-18
    cinet75_6 (MM9_ELT_s VSS) capacitor c=2.11824e-17
    cinet75_5 (net75_5 VSS) capacitor c=1.11099e-18
    cinet75_4 (net75_7 VSS) capacitor c=4.93743e-18
    cinet75_3 (MM8_ELT_d VSS) capacitor c=1.32762e-17
    cinet75_2 (net75_11 VSS) capacitor c=1.64325e-17
    cinet75_1 (net75_13 VSS) capacitor c=1.07074e-18
    cinet75_0 (net75_16 VSS) capacitor c=1.16765e-17
    cinet72_7 (MM2_ELT_s VSS) capacitor c=2.15362e-17
    cinet72_6 (net72_5 VSS) capacitor c=1.11099e-18
    cinet72_5 (net72_7 VSS) capacitor c=8.44654e-18
    cinet72_4 (net72_11 VSS) capacitor c=2.33177e-17
    cinet72_3 (net72_14 VSS) capacitor c=1.16765e-17
    cinet72_2 (net72_16 VSS) capacitor c=3.338e-18
    cinet72_1 (net72_19 VSS) capacitor c=2.11741e-17
    cinet72_0 (net72_20 VSS) capacitor c=1.50998e-18
    ciin1_14 (in1_22 VSS) capacitor c=4.27432e-18
    ciin1_13 (in1_25 VSS) capacitor c=7.16755e-18
    ciin1_12 (in1_28 VSS) capacitor c=1.50824e-16
    ciin1_11 (in1_30 VSS) capacitor c=6.63577e-18
    ciin1_10 (in1_33 VSS) capacitor c=4.30419e-18
    ciin1_9 (in1_36 VSS) capacitor c=4.41037e-16
    ciin1_8 (in1_38 VSS) capacitor c=2.5335e-17
    ciin1_7 (in1_46 VSS) capacitor c=2.41979e-17
    ciin1_6 (in1_54 VSS) capacitor c=1.21874e-17
    ciin1_5 (in1_62 VSS) capacitor c=1.78478e-17
    ciin1_4 (in1_70 VSS) capacitor c=2.14955e-18
    ciin1_3 (in1_93 VSS) capacitor c=2.22299e-18
    ciin1_2 (in1_133 VSS) capacitor c=3.50964e-17
    ciin1_1 (in1 VSS) capacitor c=4.99358e-17
    ciin1_0 (in1_199 VSS) capacitor c=9.79294e-18
    ciVDD_21 (VDD_2 VSS) capacitor c=6.96247e-17
    ciVDD_20 (VDD_11 VSS) capacitor c=2.54999e-16
    ciVDD_19 (VDD_19 VSS) capacitor c=2.03482e-17
    ciVDD_18 (VDD_20 VSS) capacitor c=1.08576e-16
    ciVDD_17 (VDD_33 VSS) capacitor c=1.29337e-16
    ciVDD_16 (VDD_34 VSS) capacitor c=3.15513e-16
    ciVDD_15 (VDD_42 VSS) capacitor c=8.4799e-17
    ciVDD_14 (VDD_52 VSS) capacitor c=1.45102e-16
    ciVDD_13 (VDD_53 VSS) capacitor c=3.08184e-16
    ciVDD_12 (VDD_63 VSS) capacitor c=5.99577e-17
    ciVDD_11 (VDD_66 VSS) capacitor c=3.58509e-18
    ciVDD_10 (VDD_67 VSS) capacitor c=3.58509e-18
    ciVDD_9 (VDD_68 VSS) capacitor c=3.58509e-18
    ciVDD_8 (MM4_ELT_s VSS) capacitor c=1.32762e-17
    ciVDD_7 (VDD_75 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_77 VSS) capacitor c=5.61912e-18
    ciVDD_5 (VDD_81 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_82 VSS) capacitor c=5.6958e-18
    ciVDD_3 (VDD_83 VSS) capacitor c=9.25359e-18
    ciVDD_2 (VDD_86 VSS) capacitor c=2.08371e-17
    ciVDD_1 (VDD_88 VSS) capacitor c=4.47712e-18
    ciVDD_0 (VDD_90 VSS) capacitor c=3.75918e-16
    ciVSS_17 (VSS_2 VSS) capacitor c=6.77092e-17
    ciVSS_16 (VSS_11 VSS) capacitor c=7.41365e-17
    ciVSS_15 (VSS_12 VSS) capacitor c=1.17598e-16
    ciVSS_14 (VSS_14 VSS) capacitor c=6.30896e-17
    ciVSS_13 (VSS_24 VSS) capacitor c=6.06963e-17
    ciVSS_12 (VSS_25 VSS) capacitor c=1.10027e-16
    ciVSS_11 (VSS_27 VSS) capacitor c=1.31599e-16
    ciVSS_10 (VSS_40 VSS) capacitor c=6.6617e-17
    ciVSS_9 (VSS_41 VSS) capacitor c=1.11195e-16
    ciVSS_8 (VSS_45 VSS) capacitor c=5.93324e-17
    ciVSS_7 (VSS_48 VSS) capacitor c=3.58509e-18
    ciVSS_6 (VSS_49 VSS) capacitor c=3.58509e-18
    ciVSS_5 (VSS_50 VSS) capacitor c=3.58509e-18
    ciVSS_4 (VSS_57 VSS) capacitor c=5.43154e-18
    ciVSS_3 (VSS_62 VSS) capacitor c=5.36761e-18
    ciVSS_2 (VSS_63 VSS) capacitor c=6.22897e-18
    ciVSS_1 (VSS_66 VSS) capacitor c=1.10376e-18
    ciVSS_0 (VSS_70 VSS) capacitor c=5.06452e-18
    ciout_13 (out_3 VSS) capacitor c=1.96869e-16
    ciout_12 (out_4 VSS) capacitor c=3.15415e-16
    ciout_11 (out_12 VSS) capacitor c=8.24647e-17
    ciout_10 (out_13 VSS) capacitor c=1.689e-17
    ciout_9 (out_16 VSS) capacitor c=4.23366e-17
    ciout_8 (out_17 VSS) capacitor c=1.08377e-16
    ciout_7 (out_19 VSS) capacitor c=9.14861e-17
    ciout_6 (out_23 VSS) capacitor c=4.69577e-17
    ciout_5 (out_24 VSS) capacitor c=1.08411e-16
    ciout_4 (out_28 VSS) capacitor c=1.8863e-16
    ciout_3 (out_29 VSS) capacitor c=3.11739e-16
    ciout_2 (out VSS) capacitor c=1.77164e-16
    ciout_1 (out_41 VSS) capacitor c=7.13323e-18
    ciout_0 (out_42 VSS) capacitor c=2.04659e-18
    ciin0_14 (in0_22 VSS) capacitor c=2.81221e-18
    ciin0_13 (in0_25 VSS) capacitor c=6.02325e-18
    ciin0_12 (in0_28 VSS) capacitor c=1.72141e-16
    ciin0_11 (in0_30 VSS) capacitor c=2.31786e-17
    ciin0_10 (in0_38 VSS) capacitor c=2.11991e-17
    ciin0_9 (in0_46 VSS) capacitor c=4.27432e-18
    ciin0_8 (in0_63 VSS) capacitor c=5.02213e-16
    ciin0_7 (in0_69 VSS) capacitor c=4.30419e-18
    ciin0_6 (in0_74 VSS) capacitor c=1.42703e-17
    ciin0_5 (in0_82 VSS) capacitor c=1.59705e-17
    ciin0_4 (in0_90 VSS) capacitor c=6.17292e-18
    ciin0_3 (in0_93 VSS) capacitor c=2.83193e-18
    ciin0_2 (in0 VSS) capacitor c=7.12839e-17
    ciin0_1 (in0_196 VSS) capacitor c=1.22411e-17
    ciin0_0 (in0_197 VSS) capacitor c=3.88863e-17
    cis0_30 (s0_25 VSS) capacitor c=4.93876e-16
    cis0_29 (s0_31 VSS) capacitor c=4.15066e-18
    cis0_28 (s0_36 VSS) capacitor c=1.76888e-17
    cis0_27 (s0_44 VSS) capacitor c=1.51948e-17
    cis0_26 (s0_52 VSS) capacitor c=6.90253e-18
    cis0_25 (s0_55 VSS) capacitor c=5.89798e-18
    cis0_24 (s0_60 VSS) capacitor c=4.09202e-18
    cis0_23 (s0_63 VSS) capacitor c=4.80839e-18
    cis0_22 (s0_66 VSS) capacitor c=1.65475e-16
    cis0_21 (s0_68 VSS) capacitor c=2.23868e-17
    cis0_20 (s0_76 VSS) capacitor c=2.37634e-17
    cis0_19 (s0_84 VSS) capacitor c=5.82454e-18
    cis0_18 (s0_133 VSS) capacitor c=5.33161e-17
    cis0_17 (s0_134 VSS) capacitor c=1.12744e-16
    cis0_16 (s0_138 VSS) capacitor c=1.80319e-16
    cis0_15 (s0_139 VSS) capacitor c=3.3757e-16
    cis0_14 (s0_147 VSS) capacitor c=1.65096e-17
    cis0_13 (s0_148 VSS) capacitor c=1.26522e-17
    cis0_12 (s0_149 VSS) capacitor c=2.81462e-17
    cis0_11 (s0_150 VSS) capacitor c=1.54384e-17
    cis0_10 (s0_152 VSS) capacitor c=4.32455e-18
    cis0_9 (s0_154 VSS) capacitor c=3.59519e-18
    cis0_8 (s0_156 VSS) capacitor c=1.48801e-17
    cis0_7 (s0_157 VSS) capacitor c=1.49758e-16
    cis0_6 (s0_159 VSS) capacitor c=6.70429e-17
    cis0_5 (s0_163 VSS) capacitor c=3.87851e-17
    cis0_4 (s0_165 VSS) capacitor c=6.4296e-17
    cis0_3 (s0_225 VSS) capacitor c=3.78915e-17
    cis0_2 (s0_234 VSS) capacitor c=1.21997e-17
    cis0_1 (s0_240 VSS) capacitor c=4.22751e-17
    cis0_0 (s0_241 VSS) capacitor c=7.86948e-17
    cis0B_43 (s0B_42 VSS) capacitor c=3.00043e-18
    cis0B_42 (s0B_48 VSS) capacitor c=1.97459e-16
    cis0B_41 (s0B_59 VSS) capacitor c=6.09971e-16
    cis0B_40 (s0B_65 VSS) capacitor c=3.00043e-18
    cis0B_39 (s0B_70 VSS) capacitor c=2.23747e-17
    cis0B_38 (s0B_78 VSS) capacitor c=2.01906e-17
    cis0B_37 (s0B_86 VSS) capacitor c=1.13359e-17
    cis0B_36 (s0B_94 VSS) capacitor c=1.51948e-17
    cis0B_35 (s0B_102 VSS) capacitor c=4.14955e-18
    cis0B_34 (s0B_105 VSS) capacitor c=4.14903e-18
    cis0B_33 (s0B_110 VSS) capacitor c=2.33219e-18
    cis0B_32 (s0B_113 VSS) capacitor c=4.15066e-18
    cis0B_31 (s0B_118 VSS) capacitor c=5.82454e-18
    cis0B_30 (s0B_121 VSS) capacitor c=6.56953e-18
    cis0B_29 (s0B_124 VSS) capacitor c=1.64003e-16
    cis0B_28 (s0B_126 VSS) capacitor c=2.24321e-17
    cis0B_27 (s0B_134 VSS) capacitor c=2.28764e-17
    cis0B_26 (s0B_142 VSS) capacitor c=4.09202e-18
    cis0B_25 (s0B_159 VSS) capacitor c=4.96192e-16
    cis0B_24 (s0B_165 VSS) capacitor c=4.22299e-18
    cis0B_23 (s0B_170 VSS) capacitor c=1.86878e-17
    cis0B_22 (s0B_178 VSS) capacitor c=1.51948e-17
    cis0B_21 (s0B_186 VSS) capacitor c=6.57711e-18
    cis0B_20 (s0B_189 VSS) capacitor c=5.89798e-18
    cis0B_19 (s0B_263 VSS) capacitor c=5.74499e-17
    cis0B_18 (s0B_264 VSS) capacitor c=1.11634e-16
    cis0B_17 (s0B_268 VSS) capacitor c=1.89006e-16
    cis0B_16 (s0B_269 VSS) capacitor c=3.29932e-16
    cis0B_15 (s0B_277 VSS) capacitor c=1.9692e-17
    cis0B_14 (s0B_278 VSS) capacitor c=1.25426e-17
    cis0B_13 (s0B_279 VSS) capacitor c=1.84079e-17
    cis0B_12 (s0B_280 VSS) capacitor c=1.25426e-17
    cis0B_11 (s0B_282 VSS) capacitor c=2.53006e-18
    cis0B_10 (s0B_284 VSS) capacitor c=2.13652e-18
    cis0B_9 (s0B_286 VSS) capacitor c=1.25812e-17
    cis0B_8 (s0B_287 VSS) capacitor c=1.413e-16
    cis0B_7 (s0B_290 VSS) capacitor c=5.93288e-17
    cis0B_6 (s0B_291 VSS) capacitor c=3.66261e-17
    cis0B_5 (s0B_296 VSS) capacitor c=6.72453e-17
    cis0B_4 (s0B_297 VSS) capacitor c=7.60952e-17
    cis0B_3 (s0B_413 VSS) capacitor c=2.48406e-17
    cis0B_2 (s0B_414 VSS) capacitor c=1.80002e-17
    cis0B_1 (s0B_425 VSS) capacitor c=1.47422e-17
    cis0B_0 (s0B_426 VSS) capacitor c=4.44231e-17
    cis_14 (s_22 VSS) capacitor c=2.22299e-18
    cis_13 (s_28 VSS) capacitor c=1.77988e-16
    cis_12 (s_39 VSS) capacitor c=5.6212e-16
    cis_11 (s_45 VSS) capacitor c=2.22299e-18
    cis_10 (s_50 VSS) capacitor c=2.23747e-17
    cis_9 (s_58 VSS) capacitor c=2.05221e-17
    cis_8 (s_66 VSS) capacitor c=1.40776e-17
    cis_7 (s_74 VSS) capacitor c=1.51948e-17
    cis_6 (s_82 VSS) capacitor c=4.20803e-18
    cis_5 (s_85 VSS) capacitor c=5.46028e-18
    cis_4 (s_90 VSS) capacitor c=5.87675e-18
    cis_3 (s_93 VSS) capacitor c=4.28147e-18
    cis_2 (s VSS) capacitor c=3.64991e-17
    cis_1 (s_196 VSS) capacitor c=1.51805e-17
    cis_0 (s_197 VSS) capacitor c=1.88416e-17
    rnet74_36 (net74_1 net74_4) resistor r=21.1301
    rnet74_35 (net74_1 net74_6) resistor r=9.43134
    rnet74_34 (net74_2 net74_4) resistor r=21.1301
    rnet74_33 (net74_2 net74_8) resistor r=9.4369
    rnet74_32 (MM10_ELT_s net74_4) resistor r=4.557
    rnet74_31 (MM10_ELT_s net74_7) resistor r=2.67027
    rnet74_30 (MM10_ELT_s net74_9) resistor r=12.8495
    rnet74_29 (MM10_ELT_s net74_9) resistor r=1.69926
    rnet74_28 (MM10_ELT_s net74_13) resistor r=4.22001
    rnet74_27 (MM10_ELT_s net74) resistor r=10.6787
    rnet74_26 (net74_5 net74_7) resistor r=15.1041
    rnet74_25 (net74_5 net74_20) resistor r=11.0157
    rnet74_24 (net74_6 net74_7) resistor r=15.1041
    rnet74_23 (net74_8 net74_9) resistor r=12.8495
    rnet74_22 (net74_10 net74_13) resistor r=4.22001
    rnet74_21 (net74_10 net74_20) resistor r=0.762262
    rnet74_20 (net74_11 net74_13) resistor r=4.22001
    rnet74_19 (net74_11 net74) resistor r=0.57282
    rnet74_18 (MM11_ELT_d net74_13) resistor r=4.22001
    rnet74_17 (MM11_ELT_d net74_16) resistor r=2.67027
    rnet74_16 (MM11_ELT_d net74_18) resistor r=12.8495
    rnet74_15 (MM11_ELT_d net74_18) resistor r=1.69926
    rnet74_14 (MM11_ELT_d net74_19) resistor r=18.0507
    rnet74_13 (net74_14 net74_16) resistor r=15.1041
    rnet74_12 (net74_14 net74_19) resistor r=9.43134
    rnet74_11 (net74_15 net74_16) resistor r=15.1041
    rnet74_10 (net74_15 net74_20) resistor r=11.0157
    rnet74_9 (net74_17 net74_18) resistor r=12.8495
    rnet74_8 (net74_17 net74) resistor r=10.6787
    rnet73_36 (net73_1 net73_4) resistor r=21.1301
    rnet73_35 (net73_1 net73_6) resistor r=9.43134
    rnet73_34 (net73_2 net73_4) resistor r=21.1301
    rnet73_33 (net73_2 net73_8) resistor r=9.4369
    rnet73_32 (MM3_ELT_d net73_4) resistor r=4.557
    rnet73_31 (MM3_ELT_d net73_7) resistor r=2.67027
    rnet73_30 (MM3_ELT_d net73_9) resistor r=12.8495
    rnet73_29 (MM3_ELT_d net73_9) resistor r=1.69926
    rnet73_28 (MM3_ELT_d net73_13) resistor r=4.22001
    rnet73_27 (MM3_ELT_d net73) resistor r=10.6787
    rnet73_26 (net73_5 net73_7) resistor r=15.1041
    rnet73_25 (net73_5 net73_20) resistor r=11.0157
    rnet73_24 (net73_6 net73_7) resistor r=15.1041
    rnet73_23 (net73_8 net73_9) resistor r=12.8495
    rnet73_22 (net73_10 net73_13) resistor r=4.22001
    rnet73_21 (net73_10 net73_20) resistor r=0.762262
    rnet73_20 (net73_11 net73_13) resistor r=4.22001
    rnet73_19 (net73_11 net73) resistor r=0.57282
    rnet73_18 (MM1_ELT_s net73_13) resistor r=4.22001
    rnet73_17 (MM1_ELT_s net73_16) resistor r=2.67027
    rnet73_16 (MM1_ELT_s net73_18) resistor r=12.8495
    rnet73_15 (MM1_ELT_s net73_18) resistor r=1.69926
    rnet73_14 (MM1_ELT_s net73_19) resistor r=18.0507
    rnet73_13 (net73_14 net73_16) resistor r=15.1041
    rnet73_12 (net73_14 net73_19) resistor r=9.43134
    rnet73_11 (net73_15 net73_16) resistor r=15.1041
    rnet73_10 (net73_15 net73_20) resistor r=11.0157
    rnet73_9 (net73_17 net73_18) resistor r=12.8495
    rnet73_8 (net73_17 net73) resistor r=10.6787
    rnet75_32 (MM9_ELT_s net75_2) resistor r=25.7298
    rnet75_31 (MM9_ELT_s net75_5) resistor r=2.55965
    rnet75_30 (MM9_ELT_s net75_7) resistor r=12.3172
    rnet75_29 (MM9_ELT_s net75_7) resistor r=1.62887
    rnet75_28 (MM9_ELT_s net75_11) resistor r=4.04518
    rnet75_27 (net75_2 net75_4) resistor r=9.04062
    rnet75_26 (net75_3 net75_5) resistor r=14.4784
    rnet75_25 (net75_3 net75) resistor r=10.5593
    rnet75_24 (net75_4 net75_5) resistor r=14.4784
    rnet75_23 (net75_6 net75_7) resistor r=12.3172
    rnet75_22 (net75_6 net75_18) resistor r=10.2363
    rnet75_21 (net75_8 net75_11) resistor r=4.04518
    rnet75_20 (net75_8 net75_18) resistor r=0.549089
    rnet75_19 (net75_9 net75_11) resistor r=4.04518
    rnet75_18 (net75_9 net75) resistor r=0.730683
    rnet75_17 (MM8_ELT_d net75_11) resistor r=4.04518
    rnet75_16 (MM8_ELT_d net75_13) resistor r=12.3172
    rnet75_15 (MM8_ELT_d net75_13) resistor r=1.62887
    rnet75_14 (MM8_ELT_d net75_16) resistor r=2.55965
    rnet75_13 (MM8_ELT_d net75_17) resistor r=25.7298
    rnet75_12 (net75_12 net75_13) resistor r=12.3172
    rnet75_11 (net75_12 net75_18) resistor r=10.2363
    rnet75_10 (net75_14 net75_16) resistor r=14.4784
    rnet75_9 (net75_14 net75_17) resistor r=9.04062
    rnet75_8 (net75_15 net75_16) resistor r=14.4784
    rnet75_7 (net75_15 net75) resistor r=10.5593
    rnet72_36 (MM2_ELT_s net72_2) resistor r=25.7298
    rnet72_35 (MM2_ELT_s net72_5) resistor r=2.55965
    rnet72_34 (MM2_ELT_s net72_7) resistor r=12.3172
    rnet72_33 (MM2_ELT_s net72_7) resistor r=1.62887
    rnet72_32 (MM2_ELT_s net72_11) resistor r=4.04518
    rnet72_31 (net72_2 net72_4) resistor r=9.04062
    rnet72_30 (net72_3 net72_5) resistor r=14.4784
    rnet72_29 (net72_3 net72) resistor r=10.5593
    rnet72_28 (net72_4 net72_5) resistor r=14.4784
    rnet72_27 (net72_6 net72_7) resistor r=12.3172
    rnet72_26 (net72_6 net72_20) resistor r=10.2363
    rnet72_25 (net72_8 net72_11) resistor r=4.04518
    rnet72_24 (net72_8 net72_20) resistor r=0.549089
    rnet72_23 (net72_9 net72_11) resistor r=4.04518
    rnet72_22 (net72_9 net72) resistor r=0.730683
    rnet72_21 (MM0_ELT_d net72_11) resistor r=4.04518
    rnet72_20 (MM0_ELT_d net72_14) resistor r=2.55965
    rnet72_19 (MM0_ELT_d net72_16) resistor r=12.3172
    rnet72_18 (MM0_ELT_d net72_16) resistor r=1.62887
    rnet72_17 (MM0_ELT_d net72_19) resistor r=6.12113
    rnet72_16 (MM0_ELT_d net72_20) resistor r=10.2363
    rnet72_15 (net72_12 net72_14) resistor r=14.4784
    rnet72_14 (net72_12 net72_18) resistor r=9.04062
    rnet72_13 (net72_13 net72_14) resistor r=14.4784
    rnet72_12 (net72_13 net72) resistor r=10.5593
    rnet72_11 (net72_15 net72_16) resistor r=12.3172
    rnet72_10 (net72_15 net72_17) resistor r=9.04595
    rnet72_9 (net72_17 net72_19) resistor r=31.2341
    rnet72_8 (net72_18 net72_19) resistor r=31.2341
    rin1_96 (in1_22 in1_28) resistor r=58.3583
    rin1_95 (in1_22 in1_28) resistor r=4.16253
    rin1_94 (in1_22 in1_28) resistor r=58.3583
    rin1_93 (in1_22 in1_28) resistor r=4.16253
    rin1_92 (in1_25 in1_28) resistor r=58.3583
    rin1_91 (in1_25 in1_28) resistor r=4.16253
    rin1_90 (in1_25 in1_28) resistor r=58.3583
    rin1_89 (in1_25 in1_28) resistor r=4.16253
    rin1_88 (in1_28 in1_41) resistor r=24.8333
    rin1_87 (in1_28 in1_38) resistor r=24.8333
    rin1_86 (in1_28 in1_49) resistor r=24.8333
    rin1_85 (in1_28 in1_46) resistor r=24.8333
    rin1_84 (in1_28 in1_70) resistor r=58.3583
    rin1_83 (in1_28 in1_73) resistor r=58.3583
    rin1_82 (in1_28 in1_78) resistor r=14.9
    rin1_81 (in1_28 in1_41) resistor r=4.16253
    rin1_80 (in1_28 in1_49) resistor r=4.16253
    rin1_79 (in1_28 in1_38) resistor r=4.16253
    rin1_78 (in1_28 in1_70) resistor r=4.16253
    rin1_77 (in1_28 in1_78) resistor r=6.30933
    rin1_76 (in1_28 in1_73) resistor r=6.30933
    rin1_75 (in1_28 in1_46) resistor r=1.63969
    rin1_74 (in1_28 in1_41) resistor r=24.8333
    rin1_73 (in1_28 in1_38) resistor r=24.8333
    rin1_72 (in1_28 in1_49) resistor r=24.8333
    rin1_71 (in1_28 in1_46) resistor r=24.8333
    rin1_70 (in1_28 in1_70) resistor r=58.3583
    rin1_69 (in1_28 MM11_ELT_g) resistor r=22.35
    rin1_68 (in1_28 in1_78) resistor r=14.9
    rin1_67 (in1_28 in1_182) resistor r=40.975
    rin1_66 (in1_28 in1_41) resistor r=4.16253
    rin1_65 (in1_28 in1_49) resistor r=4.16253
    rin1_64 (in1_28 in1_38) resistor r=4.16253
    rin1_63 (in1_28 in1_70) resistor r=4.16253
    rin1_62 (in1_28 in1_78) resistor r=6.30933
    rin1_61 (in1_28 in1_73) resistor r=6.30933
    rin1_60 (in1_28 in1_46) resistor r=1.63969
    rin1_59 (in1_30 in1_36) resistor r=202.392
    rin1_58 (in1_30 in1_36) resistor r=4.16253
    rin1_57 (in1_30 in1_36) resistor r=202.392
    rin1_56 (in1_30 in1_36) resistor r=4.16253
    rin1_55 (in1_33 in1_36) resistor r=202.392
    rin1_54 (in1_33 in1_36) resistor r=4.16253
    rin1_53 (in1_33 in1_36) resistor r=202.392
    rin1_52 (in1_33 in1_36) resistor r=4.16253
    rin1_51 (in1_36 in1_57) resistor r=24.8333
    rin1_50 (in1_36 in1_54) resistor r=24.8333
    rin1_49 (in1_36 in1_65) resistor r=24.8333
    rin1_48 (in1_36 in1_62) resistor r=24.8333
    rin1_47 (in1_36 in1_84) resistor r=14.9
    rin1_46 (in1_36 in1_90) resistor r=202.392
    rin1_45 (in1_36 in1_93) resistor r=202.392
    rin1_44 (in1_36 in1_57) resistor r=4.16253
    rin1_43 (in1_36 in1_65) resistor r=4.16253
    rin1_42 (in1_36 in1_90) resistor r=6.30933
    rin1_41 (in1_36 in1_84) resistor r=6.30933
    rin1_40 (in1_36 in1_54) resistor r=1.63969
    rin1_39 (in1_36 in1_62) resistor r=4.16253
    rin1_38 (in1_36 in1_93) resistor r=4.16253
    rin1_37 (in1_36 in1_57) resistor r=24.8333
    rin1_36 (in1_36 in1_54) resistor r=24.8333
    rin1_35 (in1_36 in1_65) resistor r=24.8333
    rin1_34 (in1_36 in1_62) resistor r=24.8333
    rin1_33 (in1_36 in1_184) resistor r=40.975
    rin1_32 (in1_36 in1_84) resistor r=14.9
    rin1_31 (in1_36 in1_90) resistor r=202.392
    rin1_30 (in1_36 MM8_ELT_g) resistor r=7.45
    rin1_29 (in1_36 in1_57) resistor r=4.16253
    rin1_28 (in1_36 in1_65) resistor r=4.16253
    rin1_27 (in1_36 in1_90) resistor r=6.30933
    rin1_26 (in1_36 in1_84) resistor r=6.30933
    rin1_25 (in1_36 in1_54) resistor r=1.63969
    rin1_24 (in1_36 in1_62) resistor r=4.16253
    rin1_23 (in1_36 in1_93) resistor r=4.16253
    rin1_22 (in1_73 MM11_ELT_g) resistor r=36.0083
    rin1_21 (in1_93 MM8_ELT_g) resistor r=194.942
    rin1_20 (in1_132 in1_133) resistor r=10
    rin1_19 (in1_132 in1) resistor r=0.0867842
    rin1_18 (in1_133 in1_198) resistor r=4.06364
    rin1_17 (in1_182 in1_199) resistor r=10.0997
    rin1_16 (in1_184 in1_199) resistor r=10.0997
    rin1_15 (in1_198 in1_199) resistor r=0.877078
    rVDD_108 (MM6_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_107 (MM2_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_106 (MM0_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_105 (MM9_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_104 (MM8_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_103 (MM4_ELT_b VDD_29) resistor r=8.66667
    rVDD_102 (MM4_ELT_b VDD_45) resistor r=8.66667
    rVDD_101 (MM4_ELT_b VDD_48) resistor r=8.66667
    rVDD_100 (MM4_ELT_b VDD_63) resistor r=13
    rVDD_99 (MM4_ELT_b VDD_27) resistor r=56.2667
    rVDD_98 (VDD_2 VDD_7) resistor r=0.146016
    rVDD_97 (VDD_2 VDD_66) resistor r=0.022118
    rVDD_96 (VDD VDD_7) resistor r=0.0887934
    rVDD_95 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_94 (VDD_8 VDD_24) resistor r=67.52
    rVDD_93 (VDD_9 VDD_18) resistor r=0.414023
    rVDD_92 (VDD_9 VDD_66) resistor r=0.0879208
    rVDD_91 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_90 (VDD_11 VDD_15) resistor r=0.699757
    rVDD_89 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_88 (VDD_15 VDD_18) resistor r=0.699757
    rVDD_87 (VDD_18 VDD_19) resistor r=8.66667
    rVDD_86 (VDD_19 MM6_ELT_s) resistor r=4.04518
    rVDD_85 (VDD_19 VDD_89) resistor r=4.04518
    rVDD_84 (VDD_19 MM4_ELT_s) resistor r=4.04518
    rVDD_83 (VDD_19 VDD_87) resistor r=4.04518
    rVDD_82 (VDD_20 VDD_29) resistor r=0.0118391
    rVDD_81 (VDD_20 VDD_67) resistor r=0.022118
    rVDD_80 (VDD_21 VDD_23) resistor r=0.0552493
    rVDD_79 (VDD_21 VDD_66) resistor r=0.022118
    rVDD_78 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_77 (VDD_23 VDD_26) resistor r=0.236783
    rVDD_76 (VDD_24 VDD_27) resistor r=67.52
    rVDD_75 (VDD_26 VDD_27) resistor r=8.66667
    rVDD_74 (VDD_26 VDD_29) resistor r=0.236783
    rVDD_73 (VDD_31 VDD_40) resistor r=0.447426
    rVDD_72 (VDD_31 VDD_67) resistor r=0.0879208
    rVDD_71 (VDD_33 VDD_34) resistor r=8.66667
    rVDD_70 (VDD_33 VDD_37) resistor r=0.583599
    rVDD_69 (VDD_34 MM0_ELT_s) resistor r=32.3614
    rVDD_68 (VDD_37 VDD_38) resistor r=8.66667
    rVDD_67 (VDD_37 VDD_40) resistor r=0.389066
    rVDD_66 (VDD_38 MM0_ELT_s) resistor r=16.1807
    rVDD_65 (VDD_38 VDD_41) resistor r=32.3614
    rVDD_64 (VDD_40 VDD_41) resistor r=26
    rVDD_63 (VDD_42 VDD_48) resistor r=0.0118391
    rVDD_62 (VDD_42 VDD_68) resistor r=0.022118
    rVDD_61 (VDD_43 VDD_45) resistor r=0.189426
    rVDD_60 (VDD_43 VDD_67) resistor r=0.022118
    rVDD_59 (VDD_45 VDD_48) resistor r=0.236783
    rVDD_58 (VDD_50 VDD_59) resistor r=0.447426
    rVDD_57 (VDD_50 VDD_68) resistor r=0.0879208
    rVDD_56 (VDD_52 VDD_53) resistor r=8.66667
    rVDD_55 (VDD_52 VDD_56) resistor r=0.583599
    rVDD_54 (VDD_53 MM8_ELT_s) resistor r=32.3614
    rVDD_53 (VDD_56 VDD_57) resistor r=8.66667
    rVDD_52 (VDD_56 VDD_59) resistor r=0.389066
    rVDD_51 (VDD_57 MM8_ELT_s) resistor r=16.1807
    rVDD_50 (VDD_57 VDD_60) resistor r=32.3614
    rVDD_49 (VDD_59 VDD_60) resistor r=26
    rVDD_48 (VDD_61 VDD_63) resistor r=0.110499
    rVDD_47 (VDD_61 VDD_68) resistor r=0.022118
    rVDD_46 (MM4_ELT_s VDD_72) resistor r=25.7298
    rVDD_45 (MM4_ELT_s VDD_75) resistor r=2.55965
    rVDD_44 (MM4_ELT_s VDD_77) resistor r=12.3172
    rVDD_43 (MM4_ELT_s VDD_77) resistor r=1.62887
    rVDD_42 (VDD_72 VDD_74) resistor r=9.04062
    rVDD_41 (VDD_73 VDD_75) resistor r=14.4784
    rVDD_40 (VDD_73 VDD_90) resistor r=10.5593
    rVDD_39 (VDD_74 VDD_75) resistor r=14.4784
    rVDD_38 (VDD_76 VDD_77) resistor r=12.3172
    rVDD_37 (VDD_76 VDD_88) resistor r=10.2363
    rVDD_36 (MM6_ELT_s VDD_81) resistor r=2.55965
    rVDD_35 (MM6_ELT_s VDD_83) resistor r=12.3172
    rVDD_34 (MM6_ELT_s VDD_83) resistor r=1.62887
    rVDD_33 (MM6_ELT_s VDD_86) resistor r=6.12113
    rVDD_32 (MM6_ELT_s VDD_88) resistor r=10.2363
    rVDD_31 (VDD_79 VDD_81) resistor r=14.4784
    rVDD_30 (VDD_79 VDD_85) resistor r=9.04062
    rVDD_29 (VDD_80 VDD_81) resistor r=14.4784
    rVDD_28 (VDD_80 VDD_90) resistor r=10.5593
    rVDD_27 (VDD_82 VDD_83) resistor r=12.3172
    rVDD_26 (VDD_82 VDD_84) resistor r=9.04595
    rVDD_25 (VDD_84 VDD_86) resistor r=31.2341
    rVDD_24 (VDD_85 VDD_86) resistor r=31.2341
    rVDD_23 (VDD_87 VDD_88) resistor r=0.549089
    rVDD_22 (VDD_89 VDD_90) resistor r=0.730683
    rVSS_88 (MM7_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_87 (MM3_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_86 (MM1_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_85 (MM10_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_84 (MM11_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_83 (MM5_ELT_b VSS_30) resistor r=8.66667
    rVSS_82 (MM5_ELT_b VSS_33) resistor r=8.66667
    rVSS_81 (MM5_ELT_b VSS_36) resistor r=8.66667
    rVSS_80 (MM5_ELT_b VSS_45) resistor r=13
    rVSS_79 (MM5_ELT_b VSS_21) resistor r=53.9357
    rVSS_78 (VSS_2 VSS_7) resistor r=0.146016
    rVSS_77 (VSS_2 VSS_48) resistor r=0.022118
    rVSS_76 (VSS VSS_7) resistor r=0.0887934
    rVSS_75 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_74 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_73 (VSS_9 VSS_11) resistor r=0.443179
    rVSS_72 (VSS_9 VSS_48) resistor r=0.0879208
    rVSS_71 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_70 (VSS_12 MM7_ELT_s) resistor r=4.22001
    rVSS_69 (VSS_12 VSS_69) resistor r=4.22001
    rVSS_68 (VSS_12 MM5_ELT_s) resistor r=4.22001
    rVSS_67 (VSS_12 VSS_67) resistor r=4.22001
    rVSS_66 (VSS_14 VSS_20) resistor r=0.0434101
    rVSS_65 (VSS_14 VSS_49) resistor r=0.022118
    rVSS_64 (VSS_15 VSS_17) resistor r=0.0552493
    rVSS_63 (VSS_15 VSS_48) resistor r=0.022118
    rVSS_62 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_61 (VSS_17 VSS_20) resistor r=0.236783
    rVSS_60 (VSS_18 VSS_21) resistor r=64.7228
    rVSS_59 (VSS_20 VSS_21) resistor r=8.66667
    rVSS_58 (VSS_22 VSS_24) resistor r=0.369612
    rVSS_57 (VSS_22 VSS_49) resistor r=0.0879208
    rVSS_56 (VSS_24 VSS_25) resistor r=13
    rVSS_55 (VSS_25 MM3_ELT_s) resistor r=8.44
    rVSS_54 (VSS_27 VSS_36) resistor r=0.0118391
    rVSS_53 (VSS_27 VSS_50) resistor r=0.022118
    rVSS_52 (VSS_28 VSS_30) resistor r=0.157855
    rVSS_51 (VSS_28 VSS_49) resistor r=0.022118
    rVSS_50 (VSS_30 VSS_33) resistor r=0.236783
    rVSS_49 (VSS_33 VSS_36) resistor r=0.236783
    rVSS_48 (VSS_38 VSS_40) resistor r=0.369612
    rVSS_47 (VSS_38 VSS_50) resistor r=0.0879208
    rVSS_46 (VSS_40 VSS_41) resistor r=13
    rVSS_45 (VSS_41 MM11_ELT_s) resistor r=8.44
    rVSS_44 (VSS_43 VSS_45) resistor r=0.110499
    rVSS_43 (VSS_43 VSS_50) resistor r=0.022118
    rVSS_42 (MM5_ELT_s VSS_52) resistor r=18.0507
    rVSS_41 (MM5_ELT_s VSS_55) resistor r=2.67027
    rVSS_40 (MM5_ELT_s VSS_57) resistor r=12.8495
    rVSS_39 (MM5_ELT_s VSS_57) resistor r=1.69926
    rVSS_38 (VSS_52 VSS_54) resistor r=9.43134
    rVSS_37 (VSS_53 VSS_55) resistor r=15.1041
    rVSS_36 (VSS_53 VSS_68) resistor r=11.0157
    rVSS_35 (VSS_54 VSS_55) resistor r=15.1041
    rVSS_34 (VSS_56 VSS_57) resistor r=12.8495
    rVSS_33 (VSS_56 VSS_70) resistor r=10.6787
    rVSS_32 (MM7_ELT_s VSS_61) resistor r=2.67027
    rVSS_31 (MM7_ELT_s VSS_63) resistor r=12.8495
    rVSS_30 (MM7_ELT_s VSS_63) resistor r=1.69926
    rVSS_29 (MM7_ELT_s VSS_66) resistor r=4.557
    rVSS_28 (MM7_ELT_s VSS_70) resistor r=10.6787
    rVSS_27 (VSS_59 VSS_61) resistor r=15.1041
    rVSS_26 (VSS_59 VSS_64) resistor r=9.43134
    rVSS_25 (VSS_60 VSS_61) resistor r=15.1041
    rVSS_24 (VSS_60 VSS_68) resistor r=11.0157
    rVSS_23 (VSS_62 VSS_63) resistor r=12.8495
    rVSS_22 (VSS_62 VSS_65) resistor r=9.4369
    rVSS_21 (VSS_64 VSS_66) resistor r=21.1301
    rVSS_20 (VSS_65 VSS_66) resistor r=21.1301
    rVSS_19 (VSS_67 VSS_68) resistor r=0.762262
    rVSS_18 (VSS_69 VSS_70) resistor r=0.57282
    rout_48 (out_1 out_3) resistor r=1.59073
    rout_47 (out_1 out_13) resistor r=0.0957689
    rout_46 (out_3 out_4) resistor r=8.66667
    rout_45 (out_3 out_6) resistor r=0.583599
    rout_44 (out_4 MM2_ELT_d) resistor r=32.3614
    rout_43 (out_6 out_7) resistor r=8.66667
    rout_42 (out_6 out_9) resistor r=0.389066
    rout_41 (out_7 MM2_ELT_d) resistor r=16.1807
    rout_40 (out_7 out_10) resistor r=32.3614
    rout_39 (out_9 out_10) resistor r=26
    rout_38 (out_12 out_13) resistor r=0.53577
    rout_37 (out_12 out_41) resistor r=0.0725806
    rout_36 (out_14 out_16) resistor r=0.389066
    rout_35 (out_14 out_41) resistor r=0.0188624
    rout_34 (out_16 out_17) resistor r=13
    rout_33 (out_17 MM1_ELT_d) resistor r=8.44
    rout_32 (out_19 out_20) resistor r=0.742837
    rout_31 (out_19 out_42) resistor r=0.0428513
    rout_30 (out_20 out_41) resistor r=0.0725806
    rout_29 (out_21 out_23) resistor r=0.389066
    rout_28 (out_21 out_42) resistor r=0.0428513
    rout_27 (out_23 out_24) resistor r=13
    rout_26 (out_24 MM10_ELT_d) resistor r=8.44
    rout_25 (out_26 out_28) resistor r=1.57091
    rout_24 (out_26 out_42) resistor r=0.0428513
    rout_23 (out_28 out_29) resistor r=8.66667
    rout_22 (out_28 out_31) resistor r=0.583599
    rout_21 (out_29 MM9_ELT_d) resistor r=32.3614
    rout_20 (out_31 out_32) resistor r=8.66667
    rout_19 (out_31 out_34) resistor r=0.389066
    rout_18 (out_32 MM9_ELT_d) resistor r=16.1807
    rout_17 (out_32 out_35) resistor r=32.3614
    rout_16 (out_34 out_35) resistor r=26
    rout_15 (out_37 out) resistor r=1.21392
    rout_14 (out_37 out_42) resistor r=0.0428513
    rin0_96 (in0_22 in0_28) resistor r=58.3583
    rin0_95 (in0_22 in0_28) resistor r=4.16253
    rin0_94 (in0_22 in0_28) resistor r=58.3583
    rin0_93 (in0_22 in0_28) resistor r=4.16253
    rin0_92 (in0_25 in0_28) resistor r=58.3583
    rin0_91 (in0_25 in0_28) resistor r=4.16253
    rin0_90 (in0_25 in0_28) resistor r=58.3583
    rin0_89 (in0_25 in0_28) resistor r=4.16253
    rin0_88 (in0_28 in0_33) resistor r=24.8333
    rin0_87 (in0_28 in0_30) resistor r=24.8333
    rin0_86 (in0_28 in0_41) resistor r=24.8333
    rin0_85 (in0_28 in0_38) resistor r=24.8333
    rin0_84 (in0_28 in0_46) resistor r=58.3583
    rin0_83 (in0_28 in0_49) resistor r=58.3583
    rin0_82 (in0_28 in0_54) resistor r=14.9
    rin0_81 (in0_28 in0_33) resistor r=4.16253
    rin0_80 (in0_28 in0_41) resistor r=4.16253
    rin0_79 (in0_28 in0_30) resistor r=4.16253
    rin0_78 (in0_28 in0_46) resistor r=4.16253
    rin0_77 (in0_28 in0_54) resistor r=6.30933
    rin0_76 (in0_28 in0_49) resistor r=6.30933
    rin0_75 (in0_28 in0_38) resistor r=1.63969
    rin0_74 (in0_28 in0_33) resistor r=24.8333
    rin0_73 (in0_28 in0_30) resistor r=24.8333
    rin0_72 (in0_28 in0_41) resistor r=24.8333
    rin0_71 (in0_28 in0_38) resistor r=24.8333
    rin0_70 (in0_28 in0_46) resistor r=58.3583
    rin0_69 (in0_28 MM3_ELT_g) resistor r=22.35
    rin0_68 (in0_28 in0_54) resistor r=14.9
    rin0_67 (in0_28 in0_173) resistor r=40.975
    rin0_66 (in0_28 in0_33) resistor r=4.16253
    rin0_65 (in0_28 in0_41) resistor r=4.16253
    rin0_64 (in0_28 in0_30) resistor r=4.16253
    rin0_63 (in0_28 in0_46) resistor r=4.16253
    rin0_62 (in0_28 in0_54) resistor r=6.30933
    rin0_61 (in0_28 in0_49) resistor r=6.30933
    rin0_60 (in0_28 in0_38) resistor r=1.63969
    rin0_59 (in0_49 MM3_ELT_g) resistor r=36.0083
    rin0_58 (in0_60 in0_63) resistor r=14.9
    rin0_57 (in0_60 in0_63) resistor r=6.30933
    rin0_56 (in0_60 in0_63) resistor r=14.9
    rin0_55 (in0_60 in0_63) resistor r=6.30933
    rin0_54 (in0_63 in0_66) resistor r=202.392
    rin0_53 (in0_63 in0_69) resistor r=202.392
    rin0_52 (in0_63 in0_77) resistor r=24.8333
    rin0_51 (in0_63 in0_74) resistor r=24.8333
    rin0_50 (in0_63 in0_85) resistor r=24.8333
    rin0_49 (in0_63 in0_82) resistor r=24.8333
    rin0_48 (in0_63 in0_90) resistor r=202.392
    rin0_47 (in0_63 in0_93) resistor r=202.392
    rin0_46 (in0_63 in0_66) resistor r=6.30933
    rin0_45 (in0_63 in0_77) resistor r=1.63969
    rin0_44 (in0_63 in0_85) resistor r=4.16253
    rin0_43 (in0_63 in0_69) resistor r=4.16253
    rin0_42 (in0_63 in0_74) resistor r=4.16253
    rin0_41 (in0_63 in0_90) resistor r=4.16253
    rin0_40 (in0_63 in0_82) resistor r=4.16253
    rin0_39 (in0_63 in0_93) resistor r=4.16253
    rin0_38 (in0_63 in0_175) resistor r=40.975
    rin0_37 (in0_63 in0_66) resistor r=202.392
    rin0_36 (in0_63 in0_69) resistor r=202.392
    rin0_35 (in0_63 in0_77) resistor r=24.8333
    rin0_34 (in0_63 in0_74) resistor r=24.8333
    rin0_33 (in0_63 in0_85) resistor r=24.8333
    rin0_32 (in0_63 in0_82) resistor r=24.8333
    rin0_31 (in0_63 in0_90) resistor r=202.392
    rin0_30 (in0_63 MM0_ELT_g) resistor r=7.45
    rin0_29 (in0_63 in0_66) resistor r=6.30933
    rin0_28 (in0_63 in0_77) resistor r=1.63969
    rin0_27 (in0_63 in0_85) resistor r=4.16253
    rin0_26 (in0_63 in0_69) resistor r=4.16253
    rin0_25 (in0_63 in0_74) resistor r=4.16253
    rin0_24 (in0_63 in0_90) resistor r=4.16253
    rin0_23 (in0_63 in0_82) resistor r=4.16253
    rin0_22 (in0_63 in0_93) resistor r=4.16253
    rin0_21 (in0_93 MM0_ELT_g) resistor r=194.942
    rin0_20 (in0_132 in0_133) resistor r=10
    rin0_19 (in0_132 in0) resistor r=0.0867842
    rin0_18 (in0_133 in0_196) resistor r=4.06364
    rin0_17 (in0_133 in0_197) resistor r=23.0273
    rin0_16 (in0_173 in0_196) resistor r=9.29775
    rin0_15 (in0_175 in0_197) resistor r=9.29775
    rs0_143 (MM6_ELT_d s0) resistor r=0.01
    rs0_142 (s0_22 s0_25) resistor r=14.9
    rs0_141 (s0_22 s0_25) resistor r=6.30933
    rs0_140 (s0_22 s0_25) resistor r=14.9
    rs0_139 (s0_22 s0_25) resistor r=6.30933
    rs0_138 (s0_25 s0_28) resistor r=202.392
    rs0_137 (s0_25 s0_31) resistor r=202.392
    rs0_136 (s0_25 s0_39) resistor r=24.8333
    rs0_135 (s0_25 s0_36) resistor r=24.8333
    rs0_134 (s0_25 s0_47) resistor r=24.8333
    rs0_133 (s0_25 s0_44) resistor r=24.8333
    rs0_132 (s0_25 s0_52) resistor r=202.392
    rs0_131 (s0_25 s0_55) resistor r=202.392
    rs0_130 (s0_25 s0_28) resistor r=6.30933
    rs0_129 (s0_25 s0_39) resistor r=1.63969
    rs0_128 (s0_25 s0_47) resistor r=4.16253
    rs0_127 (s0_25 s0_31) resistor r=4.16253
    rs0_126 (s0_25 s0_36) resistor r=4.16253
    rs0_125 (s0_25 s0_52) resistor r=4.16253
    rs0_124 (s0_25 s0_44) resistor r=4.16253
    rs0_123 (s0_25 s0_55) resistor r=4.16253
    rs0_122 (s0_25 s0_191) resistor r=40.975
    rs0_121 (s0_25 s0_28) resistor r=202.392
    rs0_120 (s0_25 s0_31) resistor r=202.392
    rs0_119 (s0_25 s0_39) resistor r=24.8333
    rs0_118 (s0_25 s0_36) resistor r=24.8333
    rs0_117 (s0_25 s0_47) resistor r=24.8333
    rs0_116 (s0_25 s0_44) resistor r=24.8333
    rs0_115 (s0_25 s0_52) resistor r=202.392
    rs0_114 (s0_25 MM2_ELT_g) resistor r=7.45
    rs0_113 (s0_25 s0_28) resistor r=6.30933
    rs0_112 (s0_25 s0_39) resistor r=1.63969
    rs0_111 (s0_25 s0_47) resistor r=4.16253
    rs0_110 (s0_25 s0_31) resistor r=4.16253
    rs0_109 (s0_25 s0_36) resistor r=4.16253
    rs0_108 (s0_25 s0_52) resistor r=4.16253
    rs0_107 (s0_25 s0_44) resistor r=4.16253
    rs0_106 (s0_25 s0_55) resistor r=4.16253
    rs0_105 (s0_55 MM2_ELT_g) resistor r=194.942
    rs0_104 (s0_60 s0_66) resistor r=58.3583
    rs0_103 (s0_60 s0_66) resistor r=4.16253
    rs0_102 (s0_60 s0_66) resistor r=58.3583
    rs0_101 (s0_60 s0_66) resistor r=4.16253
    rs0_100 (s0_63 s0_66) resistor r=58.3583
    rs0_99 (s0_63 s0_66) resistor r=4.16253
    rs0_98 (s0_63 s0_66) resistor r=58.3583
    rs0_97 (s0_63 s0_66) resistor r=4.16253
    rs0_96 (s0_66 s0_71) resistor r=24.8333
    rs0_95 (s0_66 s0_68) resistor r=24.8333
    rs0_94 (s0_66 s0_79) resistor r=24.8333
    rs0_93 (s0_66 s0_76) resistor r=24.8333
    rs0_92 (s0_66 s0_84) resistor r=58.3583
    rs0_91 (s0_66 s0_87) resistor r=58.3583
    rs0_90 (s0_66 s0_92) resistor r=14.9
    rs0_89 (s0_66 s0_71) resistor r=4.16253
    rs0_88 (s0_66 s0_79) resistor r=4.16253
    rs0_87 (s0_66 s0_68) resistor r=4.16253
    rs0_86 (s0_66 s0_84) resistor r=4.16253
    rs0_85 (s0_66 s0_92) resistor r=6.30933
    rs0_84 (s0_66 s0_87) resistor r=6.30933
    rs0_83 (s0_66 s0_76) resistor r=1.63969
    rs0_82 (s0_66 s0_71) resistor r=24.8333
    rs0_81 (s0_66 s0_68) resistor r=24.8333
    rs0_80 (s0_66 s0_79) resistor r=24.8333
    rs0_79 (s0_66 s0_76) resistor r=24.8333
    rs0_78 (s0_66 s0_84) resistor r=58.3583
    rs0_77 (s0_66 MM10_ELT_g) resistor r=22.35
    rs0_76 (s0_66 s0_92) resistor r=14.9
    rs0_75 (s0_66 s0_223) resistor r=40.975
    rs0_74 (s0_66 s0_71) resistor r=4.16253
    rs0_73 (s0_66 s0_79) resistor r=4.16253
    rs0_72 (s0_66 s0_68) resistor r=4.16253
    rs0_71 (s0_66 s0_84) resistor r=4.16253
    rs0_70 (s0_66 s0_92) resistor r=6.30933
    rs0_69 (s0_66 s0_87) resistor r=6.30933
    rs0_68 (s0_66 s0_76) resistor r=1.63969
    rs0_67 (s0_87 MM10_ELT_g) resistor r=36.0083
    rs0_66 (s0_131 s0_133) resistor r=0.424908
    rs0_65 (s0_131 s0_148) resistor r=0.0957689
    rs0_64 (s0_133 s0_134) resistor r=13
    rs0_63 (s0_134 MM7_ELT_d) resistor r=8.44
    rs0_62 (s0_136 s0_138) resistor r=0.50989
    rs0_61 (s0_136 s0_150) resistor r=0.0957689
    rs0_60 (s0_138 s0_139) resistor r=8.66667
    rs0_59 (s0_138 s0_141) resistor r=0.637362
    rs0_58 (s0_139 s0) resistor r=32.3614
    rs0_57 (s0_141 s0_142) resistor r=8.66667
    rs0_56 (s0_141 s0_144) resistor r=0.424908
    rs0_55 (s0_142 s0) resistor r=16.1807
    rs0_54 (s0_142 s0_145) resistor r=32.3614
    rs0_53 (s0_144 s0_145) resistor r=26
    rs0_52 (s0_147 s0_148) resistor r=0.111856
    rs0_51 (s0_147 s0_151) resistor r=0.0957689
    rs0_50 (s0_149 s0_150) resistor r=0.111856
    rs0_49 (s0_149 s0_154) resistor r=0.0957689
    rs0_48 (s0_151 s0_152) resistor r=0.0924031
    rs0_47 (s0_152 s0_156) resistor r=0.123521
    rs0_46 (s0_153 s0_154) resistor r=0.0924031
    rs0_45 (s0_153 s0_156) resistor r=0.123521
    rs0_44 (s0_156 s0_163) resistor r=0.0143737
    rs0_43 (s0_157 s0_158) resistor r=1.03836
    rs0_42 (s0_157 s0_165) resistor r=0.0590974
    rs0_41 (s0_158 s0_159) resistor r=0.0590974
    rs0_40 (s0_159 s0_162) resistor r=0.0898721
    rs0_39 (s0_162 s0_163) resistor r=0.75
    rs0_38 (s0_163 s0_236) resistor r=10
    rs0_37 (s0_165 s0_168) resistor r=0.0898331
    rs0_36 (s0_168 s0_241) resistor r=0.75
    rs0_35 (s0_191 s0_225) resistor r=9.29775
    rs0_34 (s0_223 s0_234) resistor r=9.29775
    rs0_33 (s0_225 s0_236) resistor r=30.4773
    rs0_32 (s0_234 s0_240) resistor r=4.06364
    rs0_31 (s0_240 s0_241) resistor r=10
    rs0B_236 (MM4_ELT_d s0B) resistor r=0.01
    rs0B_235 (s0B_42 s0B_48) resistor r=58.3583
    rs0B_234 (s0B_42 s0B_48) resistor r=4.16253
    rs0B_233 (s0B_42 s0B_48) resistor r=58.3583
    rs0B_232 (s0B_42 s0B_48) resistor r=4.16253
    rs0B_231 (s0B_45 s0B_48) resistor r=58.3583
    rs0B_230 (s0B_45 s0B_48) resistor r=6.30933
    rs0B_229 (s0B_45 s0B_48) resistor r=58.3583
    rs0B_228 (s0B_45 s0B_48) resistor r=6.30933
    rs0B_227 (s0B_48 s0B_50) resistor r=14.9
    rs0B_226 (s0B_48 s0B_73) resistor r=24.8333
    rs0B_225 (s0B_48 s0B_70) resistor r=24.8333
    rs0B_224 (s0B_48 s0B_81) resistor r=24.8333
    rs0B_223 (s0B_48 s0B_78) resistor r=24.8333
    rs0B_222 (s0B_48 s0B_102) resistor r=58.3583
    rs0B_221 (s0B_48 s0B_105) resistor r=58.3583
    rs0B_220 (s0B_48 s0B_73) resistor r=4.16253
    rs0B_219 (s0B_48 s0B_50) resistor r=6.30933
    rs0B_218 (s0B_48 s0B_81) resistor r=1.63969
    rs0B_217 (s0B_48 s0B_70) resistor r=4.16253
    rs0B_216 (s0B_48 s0B_102) resistor r=4.16253
    rs0B_215 (s0B_48 s0B_78) resistor r=4.16253
    rs0B_214 (s0B_48 s0B_105) resistor r=4.16253
    rs0B_213 (s0B_48 s0B_50) resistor r=14.9
    rs0B_212 (s0B_48 s0B_345) resistor r=40.975
    rs0B_211 (s0B_48 s0B_73) resistor r=24.8333
    rs0B_210 (s0B_48 s0B_70) resistor r=24.8333
    rs0B_209 (s0B_48 s0B_81) resistor r=24.8333
    rs0B_208 (s0B_48 s0B_78) resistor r=24.8333
    rs0B_207 (s0B_48 s0B_102) resistor r=58.3583
    rs0B_206 (s0B_48 MM7_ELT_g) resistor r=7.45
    rs0B_205 (s0B_48 s0B_73) resistor r=4.16253
    rs0B_204 (s0B_48 s0B_50) resistor r=6.30933
    rs0B_203 (s0B_48 s0B_81) resistor r=1.63969
    rs0B_202 (s0B_48 s0B_70) resistor r=4.16253
    rs0B_201 (s0B_48 s0B_102) resistor r=4.16253
    rs0B_200 (s0B_48 s0B_78) resistor r=4.16253
    rs0B_199 (s0B_48 s0B_105) resistor r=4.16253
    rs0B_198 (s0B_56 s0B_59) resistor r=14.9
    rs0B_197 (s0B_56 s0B_59) resistor r=6.30933
    rs0B_196 (s0B_56 s0B_59) resistor r=14.9
    rs0B_195 (s0B_56 s0B_59) resistor r=6.30933
    rs0B_194 (s0B_59 s0B_62) resistor r=202.392
    rs0B_193 (s0B_59 s0B_65) resistor r=202.392
    rs0B_192 (s0B_59 s0B_89) resistor r=24.8333
    rs0B_191 (s0B_59 s0B_86) resistor r=24.8333
    rs0B_190 (s0B_59 s0B_97) resistor r=24.8333
    rs0B_189 (s0B_59 s0B_94) resistor r=24.8333
    rs0B_188 (s0B_59 s0B_110) resistor r=202.392
    rs0B_187 (s0B_59 s0B_113) resistor r=202.392
    rs0B_186 (s0B_59 s0B_62) resistor r=6.30933
    rs0B_185 (s0B_59 s0B_89) resistor r=1.63969
    rs0B_184 (s0B_59 s0B_97) resistor r=4.16253
    rs0B_183 (s0B_59 s0B_65) resistor r=4.16253
    rs0B_182 (s0B_59 s0B_86) resistor r=4.16253
    rs0B_181 (s0B_59 s0B_110) resistor r=4.16253
    rs0B_180 (s0B_59 s0B_94) resistor r=4.16253
    rs0B_179 (s0B_59 s0B_113) resistor r=4.16253
    rs0B_178 (s0B_59 s0B_347) resistor r=40.975
    rs0B_177 (s0B_59 s0B_62) resistor r=202.392
    rs0B_176 (s0B_59 s0B_65) resistor r=202.392
    rs0B_175 (s0B_59 s0B_89) resistor r=24.8333
    rs0B_174 (s0B_59 s0B_86) resistor r=24.8333
    rs0B_173 (s0B_59 s0B_97) resistor r=24.8333
    rs0B_172 (s0B_59 s0B_94) resistor r=24.8333
    rs0B_171 (s0B_59 s0B_110) resistor r=202.392
    rs0B_170 (s0B_59 MM6_ELT_g) resistor r=7.45
    rs0B_169 (s0B_59 s0B_62) resistor r=6.30933
    rs0B_168 (s0B_59 s0B_89) resistor r=1.63969
    rs0B_167 (s0B_59 s0B_97) resistor r=4.16253
    rs0B_166 (s0B_59 s0B_65) resistor r=4.16253
    rs0B_165 (s0B_59 s0B_86) resistor r=4.16253
    rs0B_164 (s0B_59 s0B_110) resistor r=4.16253
    rs0B_163 (s0B_59 s0B_94) resistor r=4.16253
    rs0B_162 (s0B_59 s0B_113) resistor r=4.16253
    rs0B_161 (s0B_105 MM7_ELT_g) resistor r=50.9083
    rs0B_160 (s0B_113 MM6_ELT_g) resistor r=194.942
    rs0B_159 (s0B_118 s0B_124) resistor r=58.3583
    rs0B_158 (s0B_118 s0B_124) resistor r=4.16253
    rs0B_157 (s0B_118 s0B_124) resistor r=58.3583
    rs0B_156 (s0B_118 s0B_124) resistor r=4.16253
    rs0B_155 (s0B_121 s0B_124) resistor r=58.3583
    rs0B_154 (s0B_121 s0B_124) resistor r=4.16253
    rs0B_153 (s0B_121 s0B_124) resistor r=58.3583
    rs0B_152 (s0B_121 s0B_124) resistor r=4.16253
    rs0B_151 (s0B_124 s0B_129) resistor r=24.8333
    rs0B_150 (s0B_124 s0B_126) resistor r=24.8333
    rs0B_149 (s0B_124 s0B_137) resistor r=24.8333
    rs0B_148 (s0B_124 s0B_134) resistor r=24.8333
    rs0B_147 (s0B_124 s0B_142) resistor r=58.3583
    rs0B_146 (s0B_124 s0B_145) resistor r=58.3583
    rs0B_145 (s0B_124 s0B_150) resistor r=14.9
    rs0B_144 (s0B_124 s0B_129) resistor r=4.16253
    rs0B_143 (s0B_124 s0B_137) resistor r=4.16253
    rs0B_142 (s0B_124 s0B_126) resistor r=4.16253
    rs0B_141 (s0B_124 s0B_142) resistor r=4.16253
    rs0B_140 (s0B_124 s0B_150) resistor r=6.30933
    rs0B_139 (s0B_124 s0B_145) resistor r=6.30933
    rs0B_138 (s0B_124 s0B_134) resistor r=1.63969
    rs0B_137 (s0B_124 s0B_129) resistor r=24.8333
    rs0B_136 (s0B_124 s0B_126) resistor r=24.8333
    rs0B_135 (s0B_124 s0B_137) resistor r=24.8333
    rs0B_134 (s0B_124 s0B_134) resistor r=24.8333
    rs0B_133 (s0B_124 s0B_142) resistor r=58.3583
    rs0B_132 (s0B_124 MM1_ELT_g) resistor r=22.35
    rs0B_131 (s0B_124 s0B_150) resistor r=14.9
    rs0B_130 (s0B_124 s0B_392) resistor r=40.975
    rs0B_129 (s0B_124 s0B_129) resistor r=4.16253
    rs0B_128 (s0B_124 s0B_137) resistor r=4.16253
    rs0B_127 (s0B_124 s0B_126) resistor r=4.16253
    rs0B_126 (s0B_124 s0B_142) resistor r=4.16253
    rs0B_125 (s0B_124 s0B_150) resistor r=6.30933
    rs0B_124 (s0B_124 s0B_145) resistor r=6.30933
    rs0B_123 (s0B_124 s0B_134) resistor r=1.63969
    rs0B_122 (s0B_145 MM1_ELT_g) resistor r=36.0083
    rs0B_121 (s0B_156 s0B_159) resistor r=14.9
    rs0B_120 (s0B_156 s0B_159) resistor r=6.30933
    rs0B_119 (s0B_156 s0B_159) resistor r=14.9
    rs0B_118 (s0B_156 s0B_159) resistor r=6.30933
    rs0B_117 (s0B_159 s0B_162) resistor r=202.392
    rs0B_116 (s0B_159 s0B_165) resistor r=202.392
    rs0B_115 (s0B_159 s0B_173) resistor r=24.8333
    rs0B_114 (s0B_159 s0B_170) resistor r=24.8333
    rs0B_113 (s0B_159 s0B_181) resistor r=24.8333
    rs0B_112 (s0B_159 s0B_178) resistor r=24.8333
    rs0B_111 (s0B_159 s0B_186) resistor r=202.392
    rs0B_110 (s0B_159 s0B_189) resistor r=202.392
    rs0B_109 (s0B_159 s0B_162) resistor r=6.30933
    rs0B_108 (s0B_159 s0B_173) resistor r=1.63969
    rs0B_107 (s0B_159 s0B_181) resistor r=4.16253
    rs0B_106 (s0B_159 s0B_165) resistor r=4.16253
    rs0B_105 (s0B_159 s0B_170) resistor r=4.16253
    rs0B_104 (s0B_159 s0B_186) resistor r=4.16253
    rs0B_103 (s0B_159 s0B_178) resistor r=4.16253
    rs0B_102 (s0B_159 s0B_189) resistor r=4.16253
    rs0B_101 (s0B_159 s0B_394) resistor r=40.975
    rs0B_100 (s0B_159 s0B_162) resistor r=202.392
    rs0B_99 (s0B_159 s0B_165) resistor r=202.392
    rs0B_98 (s0B_159 s0B_173) resistor r=24.8333
    rs0B_97 (s0B_159 s0B_170) resistor r=24.8333
    rs0B_96 (s0B_159 s0B_181) resistor r=24.8333
    rs0B_95 (s0B_159 s0B_178) resistor r=24.8333
    rs0B_94 (s0B_159 s0B_186) resistor r=202.392
    rs0B_93 (s0B_159 MM9_ELT_g) resistor r=7.45
    rs0B_92 (s0B_159 s0B_162) resistor r=6.30933
    rs0B_91 (s0B_159 s0B_173) resistor r=1.63969
    rs0B_90 (s0B_159 s0B_181) resistor r=4.16253
    rs0B_89 (s0B_159 s0B_165) resistor r=4.16253
    rs0B_88 (s0B_159 s0B_170) resistor r=4.16253
    rs0B_87 (s0B_159 s0B_186) resistor r=4.16253
    rs0B_86 (s0B_159 s0B_178) resistor r=4.16253
    rs0B_85 (s0B_159 s0B_189) resistor r=4.16253
    rs0B_84 (s0B_189 MM9_ELT_g) resistor r=194.942
    rs0B_83 (s0B_261 s0B_263) resistor r=0.424908
    rs0B_82 (s0B_261 s0B_278) resistor r=0.0957689
    rs0B_81 (s0B_263 s0B_264) resistor r=13
    rs0B_80 (s0B_264 MM5_ELT_d) resistor r=8.44
    rs0B_79 (s0B_266 s0B_268) resistor r=0.50989
    rs0B_78 (s0B_266 s0B_280) resistor r=0.0957689
    rs0B_77 (s0B_268 s0B_269) resistor r=8.66667
    rs0B_76 (s0B_268 s0B_271) resistor r=0.637362
    rs0B_75 (s0B_269 s0B) resistor r=32.3614
    rs0B_74 (s0B_271 s0B_272) resistor r=8.66667
    rs0B_73 (s0B_271 s0B_274) resistor r=0.424908
    rs0B_72 (s0B_272 s0B) resistor r=16.1807
    rs0B_71 (s0B_272 s0B_275) resistor r=32.3614
    rs0B_70 (s0B_274 s0B_275) resistor r=26
    rs0B_69 (s0B_277 s0B_278) resistor r=0.106993
    rs0B_68 (s0B_277 s0B_281) resistor r=0.0957689
    rs0B_67 (s0B_279 s0B_280) resistor r=0.106993
    rs0B_66 (s0B_279 s0B_284) resistor r=0.0957689
    rs0B_65 (s0B_281 s0B_282) resistor r=0.0924031
    rs0B_64 (s0B_282 s0B_286) resistor r=0.123521
    rs0B_63 (s0B_283 s0B_284) resistor r=0.0924031
    rs0B_62 (s0B_283 s0B_286) resistor r=0.123521
    rs0B_61 (s0B_286 s0B_291) resistor r=0.0143737
    rs0B_60 (s0B_287 s0B_288) resistor r=0.936967
    rs0B_59 (s0B_287 s0B_299) resistor r=0.0590974
    rs0B_58 (s0B_288 s0B_293) resistor r=0.0590974
    rs0B_57 (s0B_290 s0B_291) resistor r=0.75
    rs0B_56 (s0B_290 s0B_293) resistor r=0.0898721
    rs0B_55 (s0B_291 s0B_432) resistor r=10
    rs0B_54 (s0B_296 s0B_297) resistor r=0.75
    rs0B_53 (s0B_296 s0B_299) resistor r=0.0898331
    rs0B_52 (s0B_297 s0B_436) resistor r=10
    rs0B_51 (s0B_345 s0B_414) resistor r=3.725
    rs0B_50 (s0B_347 s0B_414) resistor r=3.725
    rs0B_49 (s0B_392 s0B_425) resistor r=9.29775
    rs0B_48 (s0B_394 s0B_426) resistor r=9.29775
    rs0B_47 (s0B_413 s0B_414) resistor r=3.725
    rs0B_46 (s0B_413 s0B_432) resistor r=9.48182
    rs0B_45 (s0B_425 s0B_436) resistor r=11.5136
    rs0B_44 (s0B_426 s0B_436) resistor r=37.25
    rs_96 (s_22 s_28) resistor r=58.3583
    rs_95 (s_22 s_28) resistor r=4.16253
    rs_94 (s_22 s_28) resistor r=58.3583
    rs_93 (s_22 s_28) resistor r=4.16253
    rs_92 (s_25 s_28) resistor r=58.3583
    rs_91 (s_25 s_28) resistor r=6.30933
    rs_90 (s_25 s_28) resistor r=58.3583
    rs_89 (s_25 s_28) resistor r=6.30933
    rs_88 (s_28 s_30) resistor r=14.9
    rs_87 (s_28 s_53) resistor r=24.8333
    rs_86 (s_28 s_50) resistor r=24.8333
    rs_85 (s_28 s_61) resistor r=24.8333
    rs_84 (s_28 s_58) resistor r=24.8333
    rs_83 (s_28 s_82) resistor r=58.3583
    rs_82 (s_28 s_85) resistor r=58.3583
    rs_81 (s_28 s_53) resistor r=4.16253
    rs_80 (s_28 s_30) resistor r=6.30933
    rs_79 (s_28 s_61) resistor r=1.63969
    rs_78 (s_28 s_50) resistor r=4.16253
    rs_77 (s_28 s_82) resistor r=4.16253
    rs_76 (s_28 s_58) resistor r=4.16253
    rs_75 (s_28 s_85) resistor r=4.16253
    rs_74 (s_28 s_30) resistor r=14.9
    rs_73 (s_28 s_162) resistor r=40.975
    rs_72 (s_28 s_53) resistor r=24.8333
    rs_71 (s_28 s_50) resistor r=24.8333
    rs_70 (s_28 s_61) resistor r=24.8333
    rs_69 (s_28 s_58) resistor r=24.8333
    rs_68 (s_28 s_82) resistor r=58.3583
    rs_67 (s_28 MM5_ELT_g) resistor r=7.45
    rs_66 (s_28 s_53) resistor r=4.16253
    rs_65 (s_28 s_30) resistor r=6.30933
    rs_64 (s_28 s_61) resistor r=1.63969
    rs_63 (s_28 s_50) resistor r=4.16253
    rs_62 (s_28 s_82) resistor r=4.16253
    rs_61 (s_28 s_58) resistor r=4.16253
    rs_60 (s_28 s_85) resistor r=4.16253
    rs_59 (s_36 s_39) resistor r=14.9
    rs_58 (s_36 s_39) resistor r=6.30933
    rs_57 (s_36 s_39) resistor r=14.9
    rs_56 (s_36 s_39) resistor r=6.30933
    rs_55 (s_39 s_42) resistor r=202.392
    rs_54 (s_39 s_45) resistor r=202.392
    rs_53 (s_39 s_69) resistor r=24.8333
    rs_52 (s_39 s_66) resistor r=24.8333
    rs_51 (s_39 s_77) resistor r=24.8333
    rs_50 (s_39 s_74) resistor r=24.8333
    rs_49 (s_39 s_90) resistor r=202.392
    rs_48 (s_39 s_93) resistor r=202.392
    rs_47 (s_39 s_42) resistor r=6.30933
    rs_46 (s_39 s_69) resistor r=1.63969
    rs_45 (s_39 s_77) resistor r=4.16253
    rs_44 (s_39 s_45) resistor r=4.16253
    rs_43 (s_39 s_66) resistor r=4.16253
    rs_42 (s_39 s_90) resistor r=4.16253
    rs_41 (s_39 s_74) resistor r=4.16253
    rs_40 (s_39 s_93) resistor r=4.16253
    rs_39 (s_39 s_164) resistor r=40.975
    rs_38 (s_39 s_42) resistor r=202.392
    rs_37 (s_39 s_45) resistor r=202.392
    rs_36 (s_39 s_69) resistor r=24.8333
    rs_35 (s_39 s_66) resistor r=24.8333
    rs_34 (s_39 s_77) resistor r=24.8333
    rs_33 (s_39 s_74) resistor r=24.8333
    rs_32 (s_39 s_90) resistor r=202.392
    rs_31 (s_39 MM4_ELT_g) resistor r=7.45
    rs_30 (s_39 s_42) resistor r=6.30933
    rs_29 (s_39 s_69) resistor r=1.63969
    rs_28 (s_39 s_77) resistor r=4.16253
    rs_27 (s_39 s_45) resistor r=4.16253
    rs_26 (s_39 s_66) resistor r=4.16253
    rs_25 (s_39 s_90) resistor r=4.16253
    rs_24 (s_39 s_74) resistor r=4.16253
    rs_23 (s_39 s_93) resistor r=4.16253
    rs_22 (s_85 MM5_ELT_g) resistor r=50.9083
    rs_21 (s_93 MM4_ELT_g) resistor r=194.942
    rs_20 (s_132 s_133) resistor r=10
    rs_19 (s_132 s) resistor r=0.084529
    rs_18 (s_133 s_196) resistor r=9.48182
    rs_17 (s_162 s_197) resistor r=3.725
    rs_16 (s_164 s_197) resistor r=3.725
    rs_15 (s_196 s_197) resistor r=3.725
ends MUX2ISO_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DDFQD1_LVT_ELT
// View name: calibre
subckt DDFQD1_LVT_ELT CP D Q VDD VSS
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 \
        ps=4.76e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.41375e-13 pd=1.34e-06 \
        ps=5.62e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.31325e-13 pd=3.66e-06 \
        ps=9.4e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.41375e-13 pd=1.34e-06 \
        ps=5.62e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciQ_6 (Q_3 VSS) capacitor c=4.47358e-17
    ciQ_5 (Q_4 VSS) capacitor c=1.11627e-16
    ciQ_4 (Q_8 VSS) capacitor c=1.73882e-16
    ciQ_3 (Q_9 VSS) capacitor c=3.31106e-16
    ciQ_2 (Q VSS) capacitor c=7.73273e-17
    ciQ_1 (Q_23 VSS) capacitor c=2.46487e-17
    ciQ_0 (Q_27 VSS) capacitor c=1.79428e-17
    ciVDD_31 (VDD_4 VSS) capacitor c=4.69326e-17
    ciVDD_30 (VDD_7 VSS) capacitor c=4.55872e-17
    ciVDD_29 (VDD_8 VSS) capacitor c=2.63453e-17
    ciVDD_28 (VDD_14 VSS) capacitor c=6.67095e-17
    ciVDD_27 (VDD_15 VSS) capacitor c=8.25587e-17
    ciVDD_26 (VDD_17 VSS) capacitor c=8.57847e-17
    ciVDD_25 (VDD_24 VSS) capacitor c=5.01429e-17
    ciVDD_24 (VDD_25 VSS) capacitor c=7.37419e-17
    ciVDD_23 (VDD_27 VSS) capacitor c=3.89957e-17
    ciVDD_22 (VDD_34 VSS) capacitor c=1.64508e-16
    ciVDD_21 (VDD_45 VSS) capacitor c=6.18418e-17
    ciVDD_20 (VDD_53 VSS) capacitor c=3.58509e-18
    ciVDD_19 (VDD_56 VSS) capacitor c=3.58509e-18
    ciVDD_18 (VDD_58 VSS) capacitor c=3.58509e-18
    ciVDD_17 (VDD_64 VSS) capacitor c=1.71175e-18
    ciVDD_16 (VDD_65 VSS) capacitor c=5.32543e-18
    ciVDD_15 (VDD_66 VSS) capacitor c=1.64973e-18
    ciVDD_14 (VDD_69 VSS) capacitor c=8.5829e-18
    ciVDD_13 (VDD_72 VSS) capacitor c=1.64973e-18
    ciVDD_12 (VDD_75 VSS) capacitor c=1.71175e-18
    ciVDD_11 (VDD_77 VSS) capacitor c=1.64973e-18
    ciVDD_10 (VDD_80 VSS) capacitor c=1.20012e-17
    ciVDD_9 (MM8_ELT_s VSS) capacitor c=8.22979e-18
    ciVDD_8 (VDD_85 VSS) capacitor c=1.71175e-18
    ciVDD_7 (VDD_86 VSS) capacitor c=5.67632e-18
    ciVDD_6 (VDD_87 VSS) capacitor c=8.77515e-18
    ciVDD_5 (VDD_91 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_92 VSS) capacitor c=5.8958e-18
    ciVDD_3 (VDD_93 VSS) capacitor c=3.56459e-18
    ciVDD_2 (VDD_96 VSS) capacitor c=1.62337e-17
    ciVDD_1 (VDD_97 VSS) capacitor c=7.61352e-17
    ciVDD_0 (VDD_102 VSS) capacitor c=2.16631e-16
    ciVSS_24 (VSS_4 VSS) capacitor c=5.23932e-17
    ciVSS_23 (VSS_10 VSS) capacitor c=4.59055e-17
    ciVSS_22 (VSS_11 VSS) capacitor c=2.63636e-17
    ciVSS_21 (VSS_17 VSS) capacitor c=7.75028e-17
    ciVSS_20 (VSS_18 VSS) capacitor c=7.92333e-19
    ciVSS_19 (VSS_23 VSS) capacitor c=8.59865e-17
    ciVSS_18 (VSS_30 VSS) capacitor c=5.52464e-17
    ciVSS_17 (VSS_36 VSS) capacitor c=3.92179e-17
    ciVSS_16 (VSS_43 VSS) capacitor c=5.51775e-17
    ciVSS_15 (VSS_51 VSS) capacitor c=5.95865e-17
    ciVSS_14 (VSS_59 VSS) capacitor c=3.58509e-18
    ciVSS_13 (VSS_62 VSS) capacitor c=3.58509e-18
    ciVSS_12 (VSS_64 VSS) capacitor c=3.58509e-18
    ciVSS_11 (MM1_ELT_s VSS) capacitor c=5.08702e-18
    ciVSS_10 (VSS_70 VSS) capacitor c=6.77529e-18
    ciVSS_9 (VSS_82 VSS) capacitor c=7.67129e-18
    ciVSS_8 (MM3_ELT_s VSS) capacitor c=4.12817e-18
    ciVSS_7 (VSS_89 VSS) capacitor c=2.50536e-18
    ciVSS_6 (VSS_94 VSS) capacitor c=5.8958e-18
    ciVSS_5 (VSS_95 VSS) capacitor c=1.89829e-18
    ciVSS_4 (VSS_98 VSS) capacitor c=1.96647e-18
    ciVSS_3 (VSS_102 VSS) capacitor c=7.00288e-17
    ciVSS_2 (VSS_107 VSS) capacitor c=7.02138e-17
    ciVSS_1 (VSS_109 VSS) capacitor c=7.18053e-17
    ciVSS_0 (VSS_111 VSS) capacitor c=7.23249e-17
    ciU_24 (U_22 VSS) capacitor c=4.28147e-18
    ciU_23 (U_28 VSS) capacitor c=1.98152e-16
    ciU_22 (U_39 VSS) capacitor c=5.89325e-16
    ciU_21 (U_45 VSS) capacitor c=4.73887e-18
    ciU_20 (U_50 VSS) capacitor c=2.23559e-17
    ciU_19 (U_58 VSS) capacitor c=1.51948e-17
    ciU_18 (U_66 VSS) capacitor c=2.05388e-17
    ciU_17 (U_74 VSS) capacitor c=1.23131e-17
    ciU_16 (U_82 VSS) capacitor c=2.11871e-18
    ciU_15 (U_85 VSS) capacitor c=3.9912e-18
    ciU_14 (U_90 VSS) capacitor c=4.02575e-18
    ciU_13 (U_93 VSS) capacitor c=2.22299e-18
    ciU_12 (U_133 VSS) capacitor c=7.45292e-17
    ciU_11 (U_134 VSS) capacitor c=1.24827e-16
    ciU_10 (U_136 VSS) capacitor c=3.25005e-17
    ciU_9 (U_137 VSS) capacitor c=1.31337e-17
    ciU_8 (U_141 VSS) capacitor c=1.07226e-16
    ciU_7 (U_142 VSS) capacitor c=1.11279e-16
    ciU_6 (U_143 VSS) capacitor c=4.52726e-17
    ciU_5 (U_144 VSS) capacitor c=1.5466e-17
    ciU_4 (U_146 VSS) capacitor c=1.36282e-17
    ciU_3 (U_147 VSS) capacitor c=1.13246e-17
    ciU_2 (U_149 VSS) capacitor c=4.97617e-17
    ciU_1 (U_208 VSS) capacitor c=2.88388e-17
    ciU_0 (U_209 VSS) capacitor c=1.33475e-17
    cinet24_9 (net24_2 VSS) capacitor c=1.06665e-16
    cinet24_8 (net24_5 VSS) capacitor c=3.9547e-17
    cinet24_7 (net24_6 VSS) capacitor c=1.12803e-16
    cinet24_6 (net24_10 VSS) capacitor c=8.31411e-17
    cinet24_5 (net24_15 VSS) capacitor c=3.2259e-17
    cinet24_4 (net24_19 VSS) capacitor c=3.4843e-17
    cinet24_3 (net24_24 VSS) capacitor c=5.82523e-18
    cinet24_2 (net24_26 VSS) capacitor c=5.85055e-19
    cinet24_1 (net24_29 VSS) capacitor c=1.08003e-17
    cinet24_0 (net24_30 VSS) capacitor c=1.20445e-16
    ciY_26 (Y_22 VSS) capacitor c=4.04637e-18
    ciY_25 (Y_28 VSS) capacitor c=2.26241e-16
    ciY_24 (Y_39 VSS) capacitor c=2.06196e-16
    ciY_23 (Y_45 VSS) capacitor c=4.15066e-18
    ciY_22 (Y_50 VSS) capacitor c=2.23923e-17
    ciY_21 (Y_58 VSS) capacitor c=2.67343e-17
    ciY_20 (Y_66 VSS) capacitor c=2.20308e-17
    ciY_19 (Y_74 VSS) capacitor c=2.23936e-17
    ciY_18 (Y_82 VSS) capacitor c=3.00043e-18
    ciY_17 (Y_85 VSS) capacitor c=5.54754e-18
    ciY_16 (Y_90 VSS) capacitor c=4.46095e-18
    ciY_15 (Y_93 VSS) capacitor c=3.75247e-18
    ciY_14 (Y_133 VSS) capacitor c=4.2349e-17
    ciY_13 (Y_134 VSS) capacitor c=1.5313e-16
    ciY_12 (Y_136 VSS) capacitor c=3.80314e-17
    ciY_11 (Y_137 VSS) capacitor c=1.52055e-17
    ciY_10 (Y_140 VSS) capacitor c=4.92049e-17
    ciY_9 (Y_141 VSS) capacitor c=1.39927e-16
    ciY_8 (Y_144 VSS) capacitor c=2.40647e-17
    ciY_7 (Y_146 VSS) capacitor c=2.8161e-17
    ciY_6 (Y_149 VSS) capacitor c=2.30399e-17
    ciY_5 (Y_154 VSS) capacitor c=2.9443e-17
    ciY_4 (Y_156 VSS) capacitor c=1.03301e-17
    ciY_3 (Y_178 VSS) capacitor c=1.74726e-16
    ciY_2 (Y_216 VSS) capacitor c=1.15936e-17
    ciY_1 (Y_217 VSS) capacitor c=2.44854e-17
    ciY_0 (Y_218 VSS) capacitor c=2.22737e-17
    cinet25_15 (net25_3 VSS) capacitor c=7.59431e-17
    cinet25_14 (net25_4 VSS) capacitor c=9.34376e-17
    cinet25_13 (net25_8 VSS) capacitor c=3.9547e-17
    cinet25_12 (net25_9 VSS) capacitor c=1.37932e-16
    cinet25_11 (net25_11 VSS) capacitor c=7.05091e-17
    cinet25_10 (net25_12 VSS) capacitor c=1.52434e-17
    cinet25_9 (net25_13 VSS) capacitor c=4.3995e-17
    cinet25_8 (net25_14 VSS) capacitor c=1.55932e-17
    cinet25_7 (net25_16 VSS) capacitor c=7.13069e-17
    cinet25_6 (net25_18 VSS) capacitor c=9.40503e-19
    cinet25_5 (net25_19 VSS) capacitor c=4.93738e-19
    cinet25_4 (net25_20 VSS) capacitor c=1.13444e-18
    cinet25_3 (net25_21 VSS) capacitor c=4.79352e-19
    cinet25_2 (net25_23 VSS) capacitor c=1.9733e-18
    cinet25_1 (net25_24 VSS) capacitor c=2.02724e-18
    cinet25_0 (net25_27 VSS) capacitor c=7.92452e-18
    ciX_20 (X_14 VSS) capacitor c=3.00043e-18
    ciX_19 (X_17 VSS) capacitor c=2.05848e-18
    ciX_18 (X_20 VSS) capacitor c=2.18716e-16
    ciX_17 (X_22 VSS) capacitor c=2.23559e-17
    ciX_16 (X_30 VSS) capacitor c=1.3338e-17
    ciX_15 (X_44 VSS) capacitor c=1.34086e-17
    ciX_14 (X_52 VSS) capacitor c=4.04637e-18
    ciX_13 (X_55 VSS) capacitor c=3.49319e-18
    ciX_12 (X_82 VSS) capacitor c=5.38965e-17
    ciX_11 (X_83 VSS) capacitor c=1.24359e-16
    ciX_10 (X_87 VSS) capacitor c=4.07328e-17
    ciX_9 (X_88 VSS) capacitor c=1.13426e-16
    ciX_8 (X_90 VSS) capacitor c=2.58634e-17
    ciX_7 (X_91 VSS) capacitor c=1.54899e-17
    ciX_6 (X_93 VSS) capacitor c=4.78603e-17
    ciX_5 (X_95 VSS) capacitor c=4.14537e-17
    ciX_4 (X_98 VSS) capacitor c=1.12382e-16
    ciX_3 (X_103 VSS) capacitor c=2.82152e-17
    ciX_2 (X_105 VSS) capacitor c=1.17457e-17
    ciX_1 (X_143 VSS) capacitor c=2.24862e-17
    ciX_0 (X_144 VSS) capacitor c=4.16838e-17
    cinet31_10 (net31_3 VSS) capacitor c=4.46447e-17
    cinet31_9 (net31_4 VSS) capacitor c=1.28339e-16
    cinet31_8 (net31_6 VSS) capacitor c=2.40078e-17
    cinet31_7 (net31_7 VSS) capacitor c=1.48583e-17
    cinet31_6 (net31_10 VSS) capacitor c=1.16326e-16
    cinet31_5 (net31_11 VSS) capacitor c=5.86337e-18
    cinet31_4 (MM10_ELT_s VSS) capacitor c=3.97088e-18
    cinet31_3 (net31_15 VSS) capacitor c=1.06911e-16
    cinet31_2 (net31_17 VSS) capacitor c=1.71175e-18
    cinet31_1 (net31_18 VSS) capacitor c=3.55173e-18
    cinet31_0 (net31_19 VSS) capacitor c=7.55329e-18
    ciCP_47 (CP_49 VSS) capacitor c=1.71822e-16
    ciCP_46 (CP_55 VSS) capacitor c=3.55739e-18
    ciCP_45 (CP_60 VSS) capacitor c=2.50576e-17
    ciCP_44 (CP_68 VSS) capacitor c=2.76145e-17
    ciCP_43 (CP_76 VSS) capacitor c=9.39633e-18
    ciCP_42 (CP_79 VSS) capacitor c=5.8276e-18
    ciCP_41 (CP_84 VSS) capacitor c=2.20805e-18
    ciCP_40 (CP_87 VSS) capacitor c=3.25905e-18
    ciCP_39 (CP_90 VSS) capacitor c=2.25367e-16
    ciCP_38 (CP_92 VSS) capacitor c=1.33632e-17
    ciCP_37 (CP_100 VSS) capacitor c=2.23559e-17
    ciCP_36 (CP_114 VSS) capacitor c=9.15866e-18
    ciCP_35 (CP_117 VSS) capacitor c=2.37624e-18
    ciCP_34 (CP_120 VSS) capacitor c=2.40103e-16
    ciCP_33 (CP_122 VSS) capacitor c=1.34861e-17
    ciCP_32 (CP_130 VSS) capacitor c=3.0617e-17
    ciCP_31 (CP_138 VSS) capacitor c=1.34977e-17
    ciCP_30 (CP_146 VSS) capacitor c=3.78631e-18
    ciCP_29 (CP_149 VSS) capacitor c=4.04637e-18
    ciCP_28 (CP_160 VSS) capacitor c=1.48136e-17
    ciCP_27 (CP_168 VSS) capacitor c=8.26936e-18
    ciCP_26 (CP_171 VSS) capacitor c=8.11547e-18
    ciCP_25 (CP_179 VSS) capacitor c=2.02147e-16
    ciCP_24 (CP_185 VSS) capacitor c=4.3786e-18
    ciCP_23 (CP_190 VSS) capacitor c=1.80403e-17
    ciCP_22 (CP_198 VSS) capacitor c=2.29187e-17
    ciCP_21 (CP_206 VSS) capacitor c=4.11004e-18
    ciCP_20 (CP_209 VSS) capacitor c=7.04096e-19
    ciCP_19 (CP_289 VSS) capacitor c=4.61829e-17
    ciCP_18 (CP_299 VSS) capacitor c=1.44812e-17
    ciCP_17 (CP_300 VSS) capacitor c=2.00088e-17
    ciCP_16 (CP_302 VSS) capacitor c=4.98462e-17
    ciCP_15 (CP_303 VSS) capacitor c=7.24219e-18
    ciCP_14 (CP_305 VSS) capacitor c=8.61327e-17
    ciCP_13 (CP_306 VSS) capacitor c=9.0036e-17
    ciCP_12 (CP_308 VSS) capacitor c=1.27872e-17
    ciCP_11 (CP_310 VSS) capacitor c=2.35141e-17
    ciCP_10 (CP_311 VSS) capacitor c=4.40096e-17
    ciCP_9 (CP_313 VSS) capacitor c=1.07641e-17
    ciCP_8 (CP_314 VSS) capacitor c=5.48698e-18
    ciCP_7 (CP_317 VSS) capacitor c=7.84244e-18
    ciCP_6 (CP_319 VSS) capacitor c=2.13223e-17
    ciCP_5 (CP_320 VSS) capacitor c=5.76762e-17
    ciCP_4 (CP_397 VSS) capacitor c=2.1621e-17
    ciCP_3 (CP_447 VSS) capacitor c=2.00035e-17
    ciCP_2 (CP_448 VSS) capacitor c=7.29748e-18
    ciCP_1 (CP_467 VSS) capacitor c=5.49658e-17
    ciCP_0 (CP_473 VSS) capacitor c=5.5204e-17
    ciD_18 (D_22 VSS) capacitor c=2.9802e-18
    ciD_17 (D_25 VSS) capacitor c=5.03564e-18
    ciD_16 (D_28 VSS) capacitor c=2.19709e-16
    ciD_15 (D_33 VSS) capacitor c=2.05228e-16
    ciD_14 (D_39 VSS) capacitor c=3.74555e-18
    ciD_13 (D_44 VSS) capacitor c=2.23446e-17
    ciD_12 (D_52 VSS) capacitor c=2.58117e-17
    ciD_11 (D_60 VSS) capacitor c=1.92953e-17
    ciD_10 (D_68 VSS) capacitor c=2.23559e-17
    ciD_9 (D_76 VSS) capacitor c=3.24866e-18
    ciD_8 (D_90 VSS) capacitor c=4.35642e-18
    ciD_7 (D_93 VSS) capacitor c=3.76211e-18
    ciD_6 (D VSS) capacitor c=4.01335e-17
    ciD_5 (D_173 VSS) capacitor c=7.0045e-17
    ciD_4 (D_194 VSS) capacitor c=3.10956e-17
    ciD_3 (D_195 VSS) capacitor c=1.05112e-17
    ciD_2 (D_197 VSS) capacitor c=1.86532e-16
    ciD_1 (D_200 VSS) capacitor c=2.43222e-17
    ciD_0 (D_201 VSS) capacitor c=4.44047e-18
    rQ_26 (Q_1 Q_3) resistor r=0.303827
    rQ_25 (Q_1 Q_21) resistor r=0.0101023
    rQ_24 (Q_3 Q_4) resistor r=13
    rQ_23 (Q_4 MM4_ELT_d) resistor r=8.44
    rQ_22 (Q_6 Q_8) resistor r=0.341139
    rQ_21 (Q_6 Q_25) resistor r=0.0101023
    rQ_20 (Q_8 Q_9) resistor r=8.66667
    rQ_19 (Q_8 Q_11) resistor r=0.639636
    rQ_18 (Q_9 MM7_ELT_d) resistor r=32.3614
    rQ_17 (Q_11 Q_12) resistor r=8.66667
    rQ_16 (Q_11 Q_14) resistor r=0.426424
    rQ_15 (Q_12 MM7_ELT_d) resistor r=16.1807
    rQ_14 (Q_12 Q_15) resistor r=32.3614
    rQ_13 (Q_14 Q_15) resistor r=26
    rQ_12 (Q_17 Q) resistor r=0.156181
    rQ_11 (Q_17 Q_23) resistor r=0.0101023
    rQ_10 (Q_18 Q) resistor r=0.619259
    rQ_9 (Q_18 Q_27) resistor r=0.0101023
    rQ_8 (Q_21 Q_23) resistor r=0.126897
    rQ_7 (Q_25 Q_27) resistor r=0.126897
    rVDD_135 (MM11_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_134 (MM9_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_133 (MM8_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_132 (MM7_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_131 (MM10_ELT_b VDD_30) resistor r=8.66667
    rVDD_130 (MM10_ELT_b VDD_45) resistor r=13
    rVDD_129 (MM10_ELT_b VDD_56) resistor r=8.66667
    rVDD_128 (MM10_ELT_b VDD_21) resistor r=22.5067
    rVDD_127 (VDD_2 VDD_4) resistor r=0.511709
    rVDD_126 (VDD_2 VDD_51) resistor r=0.119145
    rVDD_125 (VDD_4 VDD_5) resistor r=8.66667
    rVDD_124 (VDD_5 MM11_ELT_s) resistor r=2.78649
    rVDD_123 (VDD_5 VDD_97) resistor r=11.6377
    rVDD_122 (VDD_7 VDD_10) resistor r=0.221266
    rVDD_121 (VDD_7 VDD_53) resistor r=0.0221449
    rVDD_120 (VDD_8 VDD_10) resistor r=0.033585
    rVDD_119 (VDD_8 VDD_51) resistor r=0.0177803
    rVDD_118 (VDD_10 VDD_11) resistor r=8.66667
    rVDD_117 (VDD_11 VDD_54) resistor r=67.52
    rVDD_116 (VDD_12 VDD_14) resistor r=0.511709
    rVDD_115 (VDD_12 VDD_53) resistor r=0.0882604
    rVDD_114 (VDD_14 VDD_15) resistor r=8.66667
    rVDD_113 (VDD_15 VDD_99) resistor r=16.4995
    rVDD_112 (VDD_15 VDD_98) resistor r=16.4995
    rVDD_111 (VDD_15 MM9_ELT_s) resistor r=3.29107
    rVDD_110 (VDD_17 VDD_20) resistor r=0.221266
    rVDD_109 (VDD_17 VDD_56) resistor r=0.0221449
    rVDD_108 (VDD_18 VDD_20) resistor r=0.217315
    rVDD_107 (VDD_18 VDD_53) resistor r=0.0221449
    rVDD_106 (VDD_20 VDD_21) resistor r=8.66667
    rVDD_105 (VDD_21 VDD_54) resistor r=67.52
    rVDD_104 (VDD_22 VDD_24) resistor r=0.511709
    rVDD_103 (VDD_22 VDD_56) resistor r=0.0882604
    rVDD_102 (VDD_24 VDD_25) resistor r=8.66667
    rVDD_101 (VDD_25 VDD_101) resistor r=6.94965
    rVDD_100 (VDD_25 VDD_100) resistor r=6.94965
    rVDD_99 (VDD_25 MM8_ELT_s) resistor r=1.69908
    rVDD_98 (VDD_27 VDD_30) resistor r=0.0158047
    rVDD_97 (VDD_27 VDD_58) resistor r=0.0221449
    rVDD_96 (VDD_28 VDD_30) resistor r=0.217315
    rVDD_95 (VDD_28 VDD_56) resistor r=0.0221449
    rVDD_94 (VDD_32 VDD_41) resistor r=0.490387
    rVDD_93 (VDD_32 VDD_58) resistor r=0.0882604
    rVDD_92 (VDD_34 VDD_42) resistor r=8.66667
    rVDD_91 (VDD_34 VDD_38) resistor r=0.639636
    rVDD_90 (VDD_38 VDD_42) resistor r=8.66667
    rVDD_89 (VDD_38 VDD_41) resistor r=0.639636
    rVDD_88 (VDD_41 VDD_42) resistor r=8.66667
    rVDD_87 (VDD_42 MM7_ELT_s) resistor r=1.847
    rVDD_86 (VDD_42 VDD_102) resistor r=20.317
    rVDD_85 (VDD_43 VDD_45) resistor r=0.106682
    rVDD_84 (VDD_43 VDD_58) resistor r=0.0221449
    rVDD_83 (VDD VDD_51) resistor r=0.0513653
    rVDD_82 (VDD_53 VDD_54) resistor r=8.66667
    rVDD_81 (MM11_ELT_s VDD_64) resistor r=2.55965
    rVDD_80 (MM11_ELT_s VDD_66) resistor r=12.3172
    rVDD_79 (MM11_ELT_s VDD_66) resistor r=1.62887
    rVDD_78 (MM11_ELT_s VDD_69) resistor r=4.36821
    rVDD_77 (VDD_62 VDD_64) resistor r=14.4784
    rVDD_76 (VDD_62 VDD_68) resistor r=9.04062
    rVDD_75 (VDD_63 VDD_64) resistor r=14.4784
    rVDD_74 (VDD_63 VDD_97) resistor r=9.48555
    rVDD_73 (VDD_65 VDD_66) resistor r=12.3172
    rVDD_72 (VDD_65 VDD_67) resistor r=9.04595
    rVDD_71 (VDD_67 VDD_69) resistor r=20.2547
    rVDD_70 (VDD_68 VDD_69) resistor r=20.2547
    rVDD_69 (MM9_ELT_s VDD_72) resistor r=7.31976
    rVDD_68 (MM9_ELT_s VDD_72) resistor r=1.40052
    rVDD_67 (MM9_ELT_s VDD_75) resistor r=2.55965
    rVDD_66 (MM9_ELT_s VDD_77) resistor r=7.31976
    rVDD_65 (MM9_ELT_s VDD_77) resistor r=1.40052
    rVDD_64 (MM9_ELT_s VDD_80) resistor r=4.36821
    rVDD_63 (VDD_71 VDD_72) resistor r=7.31976
    rVDD_62 (VDD_71 VDD_98) resistor r=9.39461
    rVDD_61 (VDD_73 VDD_75) resistor r=14.4784
    rVDD_60 (VDD_73 VDD_79) resistor r=9.04062
    rVDD_59 (VDD_74 VDD_75) resistor r=14.4784
    rVDD_58 (VDD_74 VDD_99) resistor r=9.48555
    rVDD_57 (VDD_76 VDD_77) resistor r=7.31976
    rVDD_56 (VDD_76 VDD_78) resistor r=9.04595
    rVDD_55 (VDD_78 VDD_80) resistor r=20.2547
    rVDD_54 (VDD_79 VDD_80) resistor r=20.2547
    rVDD_53 (MM8_ELT_s VDD_82) resistor r=17.3029
    rVDD_52 (MM8_ELT_s VDD_85) resistor r=2.55965
    rVDD_51 (MM8_ELT_s VDD_87) resistor r=12.3172
    rVDD_50 (MM8_ELT_s VDD_87) resistor r=1.62887
    rVDD_49 (VDD_82 VDD_84) resistor r=9.04062
    rVDD_48 (VDD_83 VDD_85) resistor r=14.4784
    rVDD_47 (VDD_83 VDD_101) resistor r=15.7625
    rVDD_46 (VDD_84 VDD_85) resistor r=14.4784
    rVDD_45 (VDD_86 VDD_87) resistor r=12.3172
    rVDD_44 (VDD_86 VDD_100) resistor r=15.4517
    rVDD_43 (MM7_ELT_s VDD_91) resistor r=2.55965
    rVDD_42 (MM7_ELT_s VDD_93) resistor r=11.6604
    rVDD_41 (MM7_ELT_s VDD_93) resistor r=1.30988
    rVDD_40 (MM7_ELT_s VDD_96) resistor r=6.12113
    rVDD_39 (VDD_89 VDD_91) resistor r=14.4784
    rVDD_38 (VDD_89 VDD_95) resistor r=9.04062
    rVDD_37 (VDD_90 VDD_91) resistor r=14.4784
    rVDD_36 (VDD_90 VDD_102) resistor r=9.48555
    rVDD_35 (VDD_92 VDD_93) resistor r=11.6604
    rVDD_34 (VDD_92 VDD_94) resistor r=9.04595
    rVDD_33 (VDD_94 VDD_96) resistor r=31.2341
    rVDD_32 (VDD_95 VDD_96) resistor r=31.2341
    rVSS_135 (MM2_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_134 (MM6_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_133 (MM3_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_132 (MM5_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_131 (MM4_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_130 (MM1_ELT_b VSS_39) resistor r=8.66667
    rVSS_129 (MM1_ELT_b VSS_51) resistor r=13
    rVSS_128 (MM1_ELT_b VSS_62) resistor r=8.66667
    rVSS_127 (MM1_ELT_b VSS_27) resistor r=21.5743
    rVSS_126 (VSS_2 VSS_4) resistor r=0.405103
    rVSS_125 (VSS_2 VSS_57) resistor r=0.119145
    rVSS_124 (VSS_4 VSS_5) resistor r=8.66667
    rVSS_123 (VSS_4 VSS_7) resistor r=0.426424
    rVSS_122 (VSS_5 VSS_107) resistor r=17.2126
    rVSS_121 (VSS_5 VSS_99) resistor r=17.2126
    rVSS_120 (VSS_5 MM1_ELT_s) resistor r=3.43331
    rVSS_119 (VSS_7 VSS_8) resistor r=26
    rVSS_118 (VSS_8 VSS_69) resistor r=5.7452
    rVSS_117 (VSS_8 VSS_107) resistor r=4.05543
    rVSS_116 (VSS_10 VSS_13) resistor r=0.221266
    rVSS_115 (VSS_10 VSS_59) resistor r=0.0221449
    rVSS_114 (VSS_11 VSS_13) resistor r=0.033585
    rVSS_113 (VSS_11 VSS_57) resistor r=0.0177803
    rVSS_112 (VSS_13 VSS_14) resistor r=8.66667
    rVSS_111 (VSS_14 VSS_60) resistor r=64.7228
    rVSS_110 (VSS_15 VSS_17) resistor r=0.405103
    rVSS_109 (VSS_15 VSS_59) resistor r=0.0882604
    rVSS_108 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_107 (VSS_17 VSS_20) resistor r=0.4312
    rVSS_106 (VSS_18 VSS_109) resistor r=17.2126
    rVSS_105 (VSS_18 VSS_100) resistor r=17.2126
    rVSS_104 (VSS_18 MM2_ELT_s) resistor r=3.43331
    rVSS_103 (VSS_20 VSS_21) resistor r=26
    rVSS_102 (VSS_21 VSS_76) resistor r=5.7452
    rVSS_101 (VSS_21 VSS_109) resistor r=4.05543
    rVSS_100 (VSS_23 VSS_26) resistor r=0.221266
    rVSS_99 (VSS_23 VSS_62) resistor r=0.0221449
    rVSS_98 (VSS_24 VSS_26) resistor r=0.217315
    rVSS_97 (VSS_24 VSS_59) resistor r=0.0221449
    rVSS_96 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_95 (VSS_27 VSS_60) resistor r=64.7228
    rVSS_94 (VSS_28 VSS_30) resistor r=0.399772
    rVSS_93 (VSS_28 VSS_62) resistor r=0.0882604
    rVSS_92 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_91 (VSS_30 VSS_33) resistor r=0.426424
    rVSS_90 (VSS_31 VSS_111) resistor r=7.25
    rVSS_89 (VSS_31 VSS_101) resistor r=7.25
    rVSS_88 (VSS_31 MM3_ELT_s) resistor r=1.77251
    rVSS_87 (VSS_33 VSS_34) resistor r=26
    rVSS_86 (VSS_34 VSS_88) resistor r=13.3562
    rVSS_85 (VSS_34 VSS_111) resistor r=2.76334
    rVSS_84 (VSS_36 VSS_39) resistor r=0.0158047
    rVSS_83 (VSS_36 VSS_64) resistor r=0.0221449
    rVSS_82 (VSS_37 VSS_39) resistor r=0.217315
    rVSS_81 (VSS_37 VSS_62) resistor r=0.0221449
    rVSS_80 (VSS_41 VSS_43) resistor r=0.399772
    rVSS_79 (VSS_41 VSS_64) resistor r=0.0882604
    rVSS_78 (VSS_43 VSS_47) resistor r=8.66667
    rVSS_77 (VSS_43 VSS_46) resistor r=0.426424
    rVSS_76 (VSS_46 VSS_47) resistor r=26
    rVSS_75 (VSS_47 MM4_ELT_s) resistor r=2.90692
    rVSS_74 (VSS_47 VSS_102) resistor r=12.1406
    rVSS_73 (VSS_49 VSS_51) resistor r=0.106682
    rVSS_72 (VSS_49 VSS_64) resistor r=0.0221449
    rVSS_71 (VSS VSS_57) resistor r=0.0493897
    rVSS_70 (VSS_59 VSS_60) resistor r=8.66667
    rVSS_69 (MM1_ELT_s VSS_68) resistor r=2.67027
    rVSS_68 (MM1_ELT_s VSS_70) resistor r=12.8495
    rVSS_67 (MM1_ELT_s VSS_70) resistor r=1.69926
    rVSS_66 (MM1_ELT_s VSS_71) resistor r=18.0507
    rVSS_65 (VSS_66 VSS_68) resistor r=15.1041
    rVSS_64 (VSS_66 VSS_71) resistor r=9.43134
    rVSS_63 (VSS_67 VSS_68) resistor r=15.1041
    rVSS_62 (VSS_67 VSS_99) resistor r=9.89549
    rVSS_61 (VSS_69 VSS_70) resistor r=12.8495
    rVSS_60 (MM2_ELT_s VSS_75) resistor r=2.67027
    rVSS_59 (MM2_ELT_s VSS_77) resistor r=7.63611
    rVSS_58 (MM2_ELT_s VSS_77) resistor r=1.46105
    rVSS_57 (MM2_ELT_s VSS_79) resistor r=7.63611
    rVSS_56 (MM2_ELT_s VSS_79) resistor r=1.46105
    rVSS_55 (MM2_ELT_s VSS_82) resistor r=4.557
    rVSS_54 (VSS_73 VSS_75) resistor r=15.1041
    rVSS_53 (VSS_73 VSS_80) resistor r=9.43134
    rVSS_52 (VSS_74 VSS_75) resistor r=15.1041
    rVSS_51 (VSS_74 VSS_100) resistor r=9.89549
    rVSS_50 (VSS_76 VSS_77) resistor r=7.63611
    rVSS_49 (VSS_78 VSS_79) resistor r=7.63611
    rVSS_48 (VSS_78 VSS_81) resistor r=9.4369
    rVSS_47 (VSS_80 VSS_82) resistor r=21.1301
    rVSS_46 (VSS_81 VSS_82) resistor r=21.1301
    rVSS_45 (MM3_ELT_s VSS_84) resistor r=18.0507
    rVSS_44 (MM3_ELT_s VSS_87) resistor r=2.67027
    rVSS_43 (MM3_ELT_s VSS_89) resistor r=12.8495
    rVSS_42 (MM3_ELT_s VSS_89) resistor r=1.69926
    rVSS_41 (VSS_84 VSS_86) resistor r=9.43134
    rVSS_40 (VSS_85 VSS_87) resistor r=15.1041
    rVSS_39 (VSS_85 VSS_101) resistor r=16.4437
    rVSS_38 (VSS_86 VSS_87) resistor r=15.1041
    rVSS_37 (VSS_88 VSS_89) resistor r=12.8495
    rVSS_36 (MM4_ELT_s VSS_93) resistor r=2.67027
    rVSS_35 (MM4_ELT_s VSS_95) resistor r=12.1643
    rVSS_34 (MM4_ELT_s VSS_95) resistor r=1.36649
    rVSS_33 (MM4_ELT_s VSS_98) resistor r=4.557
    rVSS_32 (VSS_91 VSS_93) resistor r=15.1041
    rVSS_31 (VSS_91 VSS_96) resistor r=9.43134
    rVSS_30 (VSS_92 VSS_93) resistor r=15.1041
    rVSS_29 (VSS_92 VSS_102) resistor r=9.89549
    rVSS_28 (VSS_94 VSS_95) resistor r=12.1643
    rVSS_27 (VSS_94 VSS_97) resistor r=9.4369
    rVSS_26 (VSS_96 VSS_98) resistor r=21.1301
    rVSS_25 (VSS_97 VSS_98) resistor r=21.1301
    rU_122 (MM8_ELT_d U) resistor r=0.01
    rU_121 (U_22 U_28) resistor r=58.3583
    rU_120 (U_22 U_28) resistor r=4.16253
    rU_119 (U_22 U_28) resistor r=58.3583
    rU_118 (U_22 U_28) resistor r=4.16253
    rU_117 (U_25 U_28) resistor r=58.3583
    rU_116 (U_25 U_28) resistor r=5.53947
    rU_115 (U_25 U_28) resistor r=58.3583
    rU_114 (U_25 U_28) resistor r=5.53947
    rU_113 (U_28 U_30) resistor r=11.175
    rU_112 (U_28 U_53) resistor r=24.8333
    rU_111 (U_28 U_50) resistor r=24.8333
    rU_110 (U_28 U_69) resistor r=22.35
    rU_109 (U_28 U_66) resistor r=22.35
    rU_108 (U_28 U_82) resistor r=58.3583
    rU_107 (U_28 U_85) resistor r=58.3583
    rU_106 (U_28 U_53) resistor r=4.16253
    rU_105 (U_28 U_30) resistor r=5.53947
    rU_104 (U_28 U_69) resistor r=2.32428
    rU_103 (U_28 U_50) resistor r=4.16253
    rU_102 (U_28 U_82) resistor r=4.16253
    rU_101 (U_28 U_66) resistor r=4.16253
    rU_100 (U_28 U_85) resistor r=4.16253
    rU_99 (U_28 U_30) resistor r=11.175
    rU_98 (U_28 U_176) resistor r=29.8
    rU_97 (U_28 U_53) resistor r=24.8333
    rU_96 (U_28 U_50) resistor r=24.8333
    rU_95 (U_28 U_69) resistor r=22.35
    rU_94 (U_28 U_66) resistor r=22.35
    rU_93 (U_28 U_82) resistor r=58.3583
    rU_92 (U_28 MM4_ELT_g) resistor r=7.45
    rU_91 (U_28 U_53) resistor r=4.16253
    rU_90 (U_28 U_30) resistor r=5.53947
    rU_89 (U_28 U_69) resistor r=2.32428
    rU_88 (U_28 U_50) resistor r=4.16253
    rU_87 (U_28 U_82) resistor r=4.16253
    rU_86 (U_28 U_66) resistor r=4.16253
    rU_85 (U_28 U_85) resistor r=4.16253
    rU_84 (U_36 U_39) resistor r=11.175
    rU_83 (U_36 U_39) resistor r=5.53947
    rU_82 (U_36 U_39) resistor r=11.175
    rU_81 (U_36 U_39) resistor r=5.53947
    rU_80 (U_39 U_42) resistor r=202.392
    rU_79 (U_39 U_45) resistor r=202.392
    rU_78 (U_39 U_61) resistor r=24.8333
    rU_77 (U_39 U_58) resistor r=24.8333
    rU_76 (U_39 U_77) resistor r=22.35
    rU_75 (U_39 U_74) resistor r=22.35
    rU_74 (U_39 U_90) resistor r=202.392
    rU_73 (U_39 U_93) resistor r=202.392
    rU_72 (U_39 U_42) resistor r=5.53947
    rU_71 (U_39 U_77) resistor r=2.32428
    rU_70 (U_39 U_61) resistor r=4.16253
    rU_69 (U_39 U_45) resistor r=4.16253
    rU_68 (U_39 U_74) resistor r=4.16253
    rU_67 (U_39 U_90) resistor r=4.16253
    rU_66 (U_39 U_58) resistor r=4.16253
    rU_65 (U_39 U_93) resistor r=4.16253
    rU_64 (U_39 U_178) resistor r=31.6625
    rU_63 (U_39 U_42) resistor r=202.392
    rU_62 (U_39 U_45) resistor r=202.392
    rU_61 (U_39 U_61) resistor r=24.8333
    rU_60 (U_39 U_58) resistor r=24.8333
    rU_59 (U_39 U_77) resistor r=22.35
    rU_58 (U_39 U_74) resistor r=22.35
    rU_57 (U_39 U_90) resistor r=202.392
    rU_56 (U_39 MM7_ELT_g) resistor r=7.45
    rU_55 (U_39 U_42) resistor r=5.53947
    rU_54 (U_39 U_77) resistor r=2.32428
    rU_53 (U_39 U_61) resistor r=4.16253
    rU_52 (U_39 U_45) resistor r=4.16253
    rU_51 (U_39 U_74) resistor r=4.16253
    rU_50 (U_39 U_90) resistor r=4.16253
    rU_49 (U_39 U_58) resistor r=4.16253
    rU_48 (U_39 U_93) resistor r=4.16253
    rU_47 (U_85 MM4_ELT_g) resistor r=50.9083
    rU_46 (U_93 MM7_ELT_g) resistor r=194.942
    rU_45 (U_131 U_133) resistor r=0.318519
    rU_44 (U_131 U_137) resistor r=0.0961106
    rU_43 (U_133 U_134) resistor r=13
    rU_42 (U_134 U) resistor r=8.09035
    rU_41 (U_136 U_137) resistor r=0.228932
    rU_40 (U_136 U_139) resistor r=0.0961106
    rU_39 (U_138 U_141) resistor r=0.0906151
    rU_38 (U_138 U_144) resistor r=0.0961106
    rU_37 (U_139 U_141) resistor r=0.874169
    rU_36 (U_141 U_142) resistor r=13
    rU_35 (U_142 MM5_ELT_d) resistor r=8.44
    rU_34 (U_143 U_144) resistor r=0.34762
    rU_33 (U_143 U_146) resistor r=0.0961106
    rU_32 (U_145 U_146) resistor r=0.190346
    rU_31 (U_145 U_147) resistor r=0.101225
    rU_30 (U_147 U_149) resistor r=0.161225
    rU_29 (U_149 U_150) resistor r=10
    rU_28 (U_150 U_208) resistor r=16.2545
    rU_27 (U_176 U_209) resistor r=8.1518
    rU_26 (U_178 U_209) resistor r=8.1518
    rU_25 (U_208 U_209) resistor r=0.275023
    rnet24_36 (MM3_ELT_d net24) resistor r=0.01
    rnet24_35 (net24_1 net24_2) resistor r=0.773917
    rnet24_34 (net24_1 net24_13) resistor r=0.0101023
    rnet24_33 (net24_2 net24_17) resistor r=0.0101023
    rnet24_32 (net24_3 net24_5) resistor r=0.303827
    rnet24_31 (net24_3 net24_15) resistor r=0.0101023
    rnet24_30 (net24_5 net24_6) resistor r=13
    rnet24_29 (net24_6 net24) resistor r=8.44
    rnet24_28 (net24_8 net24_10) resistor r=0.309157
    rnet24_27 (net24_8 net24_19) resistor r=0.0101023
    rnet24_26 (net24_10 net24_11) resistor r=8.66667
    rnet24_25 (net24_11 MM5_ELT_s) resistor r=2.90692
    rnet24_24 (net24_11 net24_30) resistor r=12.1406
    rnet24_23 (net24_13 net24_15) resistor r=0.131778
    rnet24_22 (net24_17 net24_19) resistor r=0.181777
    rnet24_21 (MM5_ELT_s net24_24) resistor r=2.67027
    rnet24_20 (MM5_ELT_s net24_26) resistor r=12.8495
    rnet24_19 (MM5_ELT_s net24_26) resistor r=1.69926
    rnet24_18 (MM5_ELT_s net24_29) resistor r=4.557
    rnet24_17 (net24_22 net24_24) resistor r=15.1041
    rnet24_16 (net24_22 net24_28) resistor r=9.43134
    rnet24_15 (net24_23 net24_24) resistor r=15.1041
    rnet24_14 (net24_23 net24_30) resistor r=9.89549
    rnet24_13 (net24_25 net24_26) resistor r=12.8495
    rnet24_12 (net24_25 net24_27) resistor r=9.4369
    rnet24_11 (net24_27 net24_29) resistor r=21.1301
    rnet24_10 (net24_28 net24_29) resistor r=21.1301
    rY_128 (MM9_ELT_d Y) resistor r=0.01
    rY_127 (Y_22 Y_28) resistor r=58.3583
    rY_126 (Y_22 Y_28) resistor r=4.16253
    rY_125 (Y_22 Y_28) resistor r=58.3583
    rY_124 (Y_22 Y_28) resistor r=4.16253
    rY_123 (Y_25 Y_28) resistor r=58.3583
    rY_122 (Y_25 Y_28) resistor r=6.30933
    rY_121 (Y_25 Y_28) resistor r=58.3583
    rY_120 (Y_25 Y_28) resistor r=6.30933
    rY_119 (Y_28 Y_30) resistor r=14.9
    rY_118 (Y_28 Y_53) resistor r=24.8333
    rY_117 (Y_28 Y_50) resistor r=24.8333
    rY_116 (Y_28 Y_61) resistor r=24.8333
    rY_115 (Y_28 Y_58) resistor r=24.8333
    rY_114 (Y_28 Y_82) resistor r=58.3583
    rY_113 (Y_28 Y_85) resistor r=58.3583
    rY_112 (Y_28 Y_53) resistor r=4.16253
    rY_111 (Y_28 Y_30) resistor r=6.30933
    rY_110 (Y_28 Y_61) resistor r=1.63969
    rY_109 (Y_28 Y_50) resistor r=4.16253
    rY_108 (Y_28 Y_82) resistor r=4.16253
    rY_107 (Y_28 Y_58) resistor r=4.16253
    rY_106 (Y_28 Y_85) resistor r=4.16253
    rY_105 (Y_28 Y_30) resistor r=14.9
    rY_104 (Y_28 Y_215) resistor r=45.9417
    rY_103 (Y_28 Y_53) resistor r=24.8333
    rY_102 (Y_28 Y_50) resistor r=24.8333
    rY_101 (Y_28 Y_61) resistor r=24.8333
    rY_100 (Y_28 Y_58) resistor r=24.8333
    rY_99 (Y_28 Y_82) resistor r=58.3583
    rY_98 (Y_28 MM3_ELT_g) resistor r=7.45
    rY_97 (Y_28 Y_53) resistor r=4.16253
    rY_96 (Y_28 Y_30) resistor r=6.30933
    rY_95 (Y_28 Y_61) resistor r=1.63969
    rY_94 (Y_28 Y_50) resistor r=4.16253
    rY_93 (Y_28 Y_82) resistor r=4.16253
    rY_92 (Y_28 Y_58) resistor r=4.16253
    rY_91 (Y_28 Y_85) resistor r=4.16253
    rY_90 (Y_36 Y_39) resistor r=14.9
    rY_89 (Y_36 Y_39) resistor r=6.30933
    rY_88 (Y_36 Y_39) resistor r=14.9
    rY_87 (Y_36 Y_39) resistor r=6.30933
    rY_86 (Y_39 Y_42) resistor r=58.3583
    rY_85 (Y_39 Y_45) resistor r=58.3583
    rY_84 (Y_39 Y_69) resistor r=24.8333
    rY_83 (Y_39 Y_66) resistor r=24.8333
    rY_82 (Y_39 Y_77) resistor r=24.8333
    rY_81 (Y_39 Y_74) resistor r=24.8333
    rY_80 (Y_39 Y_90) resistor r=58.3583
    rY_79 (Y_39 Y_93) resistor r=58.3583
    rY_78 (Y_39 Y_42) resistor r=6.30933
    rY_77 (Y_39 Y_69) resistor r=1.63969
    rY_76 (Y_39 Y_77) resistor r=4.16253
    rY_75 (Y_39 Y_45) resistor r=4.16253
    rY_74 (Y_39 Y_66) resistor r=4.16253
    rY_73 (Y_39 Y_90) resistor r=4.16253
    rY_72 (Y_39 Y_74) resistor r=4.16253
    rY_71 (Y_39 Y_93) resistor r=4.16253
    rY_70 (Y_39 Y_185) resistor r=54.6333
    rY_69 (Y_39 Y_42) resistor r=58.3583
    rY_68 (Y_39 Y_45) resistor r=58.3583
    rY_67 (Y_39 Y_69) resistor r=24.8333
    rY_66 (Y_39 Y_66) resistor r=24.8333
    rY_65 (Y_39 Y_77) resistor r=24.8333
    rY_64 (Y_39 Y_74) resistor r=24.8333
    rY_63 (Y_39 Y_90) resistor r=58.3583
    rY_62 (Y_39 MM8_ELT_g) resistor r=7.45
    rY_61 (Y_39 Y_42) resistor r=6.30933
    rY_60 (Y_39 Y_69) resistor r=1.63969
    rY_59 (Y_39 Y_77) resistor r=4.16253
    rY_58 (Y_39 Y_45) resistor r=4.16253
    rY_57 (Y_39 Y_66) resistor r=4.16253
    rY_56 (Y_39 Y_90) resistor r=4.16253
    rY_55 (Y_39 Y_74) resistor r=4.16253
    rY_54 (Y_39 Y_93) resistor r=4.16253
    rY_53 (Y_85 MM3_ELT_g) resistor r=50.9083
    rY_52 (Y_93 MM8_ELT_g) resistor r=50.9083
    rY_51 (Y_131 Y_133) resistor r=0.0906151
    rY_50 (Y_131 Y_137) resistor r=0.0961106
    rY_49 (Y_133 Y_134) resistor r=13
    rY_48 (Y_134 Y) resistor r=8.09035
    rY_47 (Y_136 Y_137) resistor r=0.263556
    rY_46 (Y_136 Y_146) resistor r=0.0961106
    rY_45 (Y_138 Y_140) resistor r=0.303827
    rY_44 (Y_138 Y_152) resistor r=0.0101023
    rY_43 (Y_140 Y_141) resistor r=13
    rY_42 (Y_141 MM6_ELT_d) resistor r=8.44
    rY_41 (Y_143 Y_144) resistor r=0.332451
    rY_40 (Y_143 Y_154) resistor r=0.0101023
    rY_39 (Y_144 Y_156) resistor r=0.0728396
    rY_38 (Y_145 Y_146) resistor r=0.409289
    rY_37 (Y_145 Y_156) resistor r=0.0728396
    rY_36 (Y_147 Y_149) resistor r=0.0195227
    rY_35 (Y_147 Y_156) resistor r=0.0189297
    rY_34 (Y_149 Y_150) resistor r=10
    rY_33 (Y_150 Y_217) resistor r=12.1909
    rY_32 (Y_152 Y_154) resistor r=0.16829
    rY_31 (Y_178 Y_216) resistor r=254.542
    rY_30 (Y_178 Y_218) resistor r=3.725
    rY_29 (Y_185 Y_218) resistor r=3.725
    rY_28 (Y_215 Y_216) resistor r=13.5246
    rY_27 (Y_217 Y_218) resistor r=3.725
    rnet25_47 (MM2_ELT_d net25) resistor r=0.01
    rnet25_46 (net25_1 net25_3) resistor r=0.309157
    rnet25_45 (net25_1 net25_12) resistor r=0.0961106
    rnet25_44 (net25_3 net25_4) resistor r=8.66667
    rnet25_43 (net25_4 net25_29) resistor r=17.2126
    rnet25_42 (net25_4 net25_28) resistor r=17.2126
    rnet25_41 (net25_4 MM6_ELT_s) resistor r=3.43331
    rnet25_40 (net25_6 net25_8) resistor r=0.303827
    rnet25_39 (net25_6 net25_14) resistor r=0.0961106
    rnet25_38 (net25_8 net25_9) resistor r=13
    rnet25_37 (net25_9 net25) resistor r=8.44
    rnet25_36 (net25_11 net25_12) resistor r=0.541329
    rnet25_35 (net25_11 net25_16) resistor r=0.0961106
    rnet25_34 (net25_13 net25_14) resistor r=0.262334
    rnet25_33 (net25_13 net25_15) resistor r=0.0961106
    rnet25_32 (net25_15 net25_16) resistor r=0.773917
    rnet25_31 (MM6_ELT_s net25_20) resistor r=2.67027
    rnet25_30 (MM6_ELT_s net25_22) resistor r=7.63611
    rnet25_29 (MM6_ELT_s net25_22) resistor r=1.46105
    rnet25_28 (MM6_ELT_s net25_24) resistor r=7.63611
    rnet25_27 (MM6_ELT_s net25_24) resistor r=1.46105
    rnet25_26 (MM6_ELT_s net25_27) resistor r=4.557
    rnet25_25 (net25_18 net25_20) resistor r=15.1041
    rnet25_24 (net25_18 net25_25) resistor r=9.43134
    rnet25_23 (net25_19 net25_20) resistor r=15.1041
    rnet25_22 (net25_19 net25_28) resistor r=9.89549
    rnet25_21 (net25_21 net25_22) resistor r=7.63611
    rnet25_20 (net25_21 net25_29) resistor r=9.80063
    rnet25_19 (net25_23 net25_24) resistor r=7.63611
    rnet25_18 (net25_23 net25_26) resistor r=9.4369
    rnet25_17 (net25_25 net25_27) resistor r=21.1301
    rnet25_16 (net25_26 net25_27) resistor r=21.1301
    rX_89 (MM10_ELT_d X) resistor r=0.01
    rX_88 (X_14 X_20) resistor r=58.3583
    rX_87 (X_14 X_20) resistor r=4.16253
    rX_86 (X_14 X_20) resistor r=58.3583
    rX_85 (X_14 X_20) resistor r=4.16253
    rX_84 (X_17 X_20) resistor r=58.3583
    rX_83 (X_17 X_20) resistor r=4.16253
    rX_82 (X_17 X_20) resistor r=58.3583
    rX_81 (X_17 X_20) resistor r=4.16253
    rX_80 (X_20 X_25) resistor r=24.8333
    rX_79 (X_20 X_22) resistor r=24.8333
    rX_78 (X_20 X_33) resistor r=8.69167
    rX_77 (X_20 X_30) resistor r=8.69167
    rX_76 (X_20 X_38) resistor r=14.9
    rX_75 (X_20 X_47) resistor r=8.69167
    rX_74 (X_20 X_44) resistor r=8.69167
    rX_73 (X_20 X_52) resistor r=58.3583
    rX_72 (X_20 X_55) resistor r=58.3583
    rX_71 (X_20 X_25) resistor r=4.16253
    rX_70 (X_20 X_33) resistor r=4.16253
    rX_69 (X_20 X_47) resistor r=6.30933
    rX_68 (X_20 X_30) resistor r=6.30933
    rX_67 (X_20 X_38) resistor r=1.63969
    rX_66 (X_20 X_22) resistor r=4.16253
    rX_65 (X_20 X_52) resistor r=4.16253
    rX_64 (X_20 X_44) resistor r=4.16253
    rX_63 (X_20 X_55) resistor r=4.16253
    rX_62 (X_20 X_25) resistor r=24.8333
    rX_61 (X_20 X_22) resistor r=24.8333
    rX_60 (X_20 X_33) resistor r=8.69167
    rX_59 (X_20 X_30) resistor r=8.69167
    rX_58 (X_20 X_38) resistor r=14.9
    rX_57 (X_20 X_128) resistor r=39.7333
    rX_56 (X_20 X_47) resistor r=8.69167
    rX_55 (X_20 X_44) resistor r=8.69167
    rX_54 (X_20 X_52) resistor r=58.3583
    rX_53 (X_20 MM2_ELT_g) resistor r=7.45
    rX_52 (X_20 X_25) resistor r=4.16253
    rX_51 (X_20 X_33) resistor r=4.16253
    rX_50 (X_20 X_47) resistor r=6.30933
    rX_49 (X_20 X_30) resistor r=6.30933
    rX_48 (X_20 X_38) resistor r=1.63969
    rX_47 (X_20 X_22) resistor r=4.16253
    rX_46 (X_20 X_52) resistor r=4.16253
    rX_45 (X_20 X_44) resistor r=4.16253
    rX_44 (X_20 X_55) resistor r=4.16253
    rX_43 (X_55 MM2_ELT_g) resistor r=50.9083
    rX_42 (X_80 X_82) resistor r=0.159909
    rX_41 (X_80 X_91) resistor r=0.0961106
    rX_40 (X_82 X_83) resistor r=13
    rX_39 (X_83 X) resistor r=8.09035
    rX_38 (X_85 X_87) resistor r=0.303827
    rX_37 (X_85 X_101) resistor r=0.0101023
    rX_36 (X_87 X_88) resistor r=13
    rX_35 (X_88 MM1_ELT_d) resistor r=8.44
    rX_34 (X_90 X_91) resistor r=0.0927327
    rX_33 (X_90 X_95) resistor r=0.0961106
    rX_32 (X_92 X_93) resistor r=0.309918
    rX_31 (X_92 X_103) resistor r=0.0101023
    rX_30 (X_93 X_105) resistor r=0.0728396
    rX_29 (X_94 X_95) resistor r=0.306171
    rX_28 (X_94 X_105) resistor r=0.0728396
    rX_27 (X_96 X_98) resistor r=0.732043
    rX_26 (X_96 X_105) resistor r=0.0189297
    rX_25 (X_98 X_99) resistor r=10
    rX_24 (X_99 X_143) resistor r=4.74091
    rX_23 (X_101 X_103) resistor r=0.126897
    rX_22 (X_128 X_144) resistor r=4.38767
    rX_21 (X_143 X_144) resistor r=3.71511
    rnet31_32 (MM11_ELT_d net31) resistor r=0.01
    rnet31_31 (net31_1 net31_3) resistor r=0.0906151
    rnet31_30 (net31_1 net31_7) resistor r=0.0961106
    rnet31_29 (net31_3 net31_4) resistor r=13
    rnet31_28 (net31_4 net31) resistor r=8.09035
    rnet31_27 (net31_6 net31_7) resistor r=0.112255
    rnet31_26 (net31_6 net31_8) resistor r=0.0961106
    rnet31_25 (net31_8 net31_10) resistor r=0.804229
    rnet31_24 (net31_10 net31_11) resistor r=8.66667
    rnet31_23 (net31_11 net31_21) resistor r=16.4995
    rnet31_22 (net31_11 net31_20) resistor r=16.4995
    rnet31_21 (net31_11 MM10_ELT_s) resistor r=3.29107
    rnet31_20 (MM10_ELT_s net31_14) resistor r=17.3029
    rnet31_19 (MM10_ELT_s net31_17) resistor r=2.55965
    rnet31_18 (MM10_ELT_s net31_19) resistor r=12.3172
    rnet31_17 (MM10_ELT_s net31_19) resistor r=1.62887
    rnet31_16 (net31_14 net31_16) resistor r=9.04062
    rnet31_15 (net31_15 net31_17) resistor r=14.4784
    rnet31_14 (net31_15 net31_21) resistor r=9.48555
    rnet31_13 (net31_16 net31_17) resistor r=14.4784
    rnet31_12 (net31_18 net31_19) resistor r=12.3172
    rnet31_11 (net31_18 net31_20) resistor r=9.39461
    rCP_248 (CP_46 CP_49) resistor r=14.9
    rCP_247 (CP_46 CP_49) resistor r=6.30933
    rCP_246 (CP_46 CP_49) resistor r=14.9
    rCP_245 (CP_46 CP_49) resistor r=6.30933
    rCP_244 (CP_49 CP_52) resistor r=58.3583
    rCP_243 (CP_49 CP_55) resistor r=58.3583
    rCP_242 (CP_49 CP_63) resistor r=24.8333
    rCP_241 (CP_49 CP_60) resistor r=24.8333
    rCP_240 (CP_49 CP_71) resistor r=24.8333
    rCP_239 (CP_49 CP_68) resistor r=24.8333
    rCP_238 (CP_49 CP_76) resistor r=58.3583
    rCP_237 (CP_49 CP_79) resistor r=58.3583
    rCP_236 (CP_49 CP_52) resistor r=6.30933
    rCP_235 (CP_49 CP_63) resistor r=1.63969
    rCP_234 (CP_49 CP_71) resistor r=4.16253
    rCP_233 (CP_49 CP_55) resistor r=4.16253
    rCP_232 (CP_49 CP_60) resistor r=4.16253
    rCP_231 (CP_49 CP_76) resistor r=4.16253
    rCP_230 (CP_49 CP_68) resistor r=4.16253
    rCP_229 (CP_49 CP_79) resistor r=4.16253
    rCP_228 (CP_49 CP_365) resistor r=39.7333
    rCP_227 (CP_49 CP_52) resistor r=58.3583
    rCP_226 (CP_49 CP_55) resistor r=58.3583
    rCP_225 (CP_49 CP_63) resistor r=24.8333
    rCP_224 (CP_49 CP_60) resistor r=24.8333
    rCP_223 (CP_49 CP_71) resistor r=24.8333
    rCP_222 (CP_49 CP_68) resistor r=24.8333
    rCP_221 (CP_49 CP_76) resistor r=58.3583
    rCP_220 (CP_49 MM10_ELT_g) resistor r=7.45
    rCP_219 (CP_49 CP_52) resistor r=6.30933
    rCP_218 (CP_49 CP_63) resistor r=1.63969
    rCP_217 (CP_49 CP_71) resistor r=4.16253
    rCP_216 (CP_49 CP_55) resistor r=4.16253
    rCP_215 (CP_49 CP_60) resistor r=4.16253
    rCP_214 (CP_49 CP_76) resistor r=4.16253
    rCP_213 (CP_49 CP_68) resistor r=4.16253
    rCP_212 (CP_49 CP_79) resistor r=4.16253
    rCP_211 (CP_79 MM10_ELT_g) resistor r=50.9083
    rCP_210 (CP_84 CP_90) resistor r=58.3583
    rCP_209 (CP_84 CP_90) resistor r=4.16253
    rCP_208 (CP_84 CP_90) resistor r=58.3583
    rCP_207 (CP_84 CP_90) resistor r=4.16253
    rCP_206 (CP_87 CP_90) resistor r=58.3583
    rCP_205 (CP_87 CP_90) resistor r=4.16253
    rCP_204 (CP_87 CP_90) resistor r=58.3583
    rCP_203 (CP_87 CP_90) resistor r=4.16253
    rCP_202 (CP_90 CP_95) resistor r=8.69167
    rCP_201 (CP_90 CP_92) resistor r=8.69167
    rCP_200 (CP_90 CP_103) resistor r=24.8333
    rCP_199 (CP_90 CP_100) resistor r=24.8333
    rCP_198 (CP_90 CP_108) resistor r=14.9
    rCP_197 (CP_90 CP_125) resistor r=8.69167
    rCP_196 (CP_90 CP_122) resistor r=8.69167
    rCP_195 (CP_90 CP_146) resistor r=58.3583
    rCP_194 (CP_90 CP_149) resistor r=58.3583
    rCP_193 (CP_90 CP_95) resistor r=4.16253
    rCP_192 (CP_90 CP_103) resistor r=4.16253
    rCP_191 (CP_90 CP_125) resistor r=6.30933
    rCP_190 (CP_90 CP_92) resistor r=6.30933
    rCP_189 (CP_90 CP_108) resistor r=1.63969
    rCP_188 (CP_90 CP_122) resistor r=4.16253
    rCP_187 (CP_90 CP_146) resistor r=4.16253
    rCP_186 (CP_90 CP_100) resistor r=4.16253
    rCP_185 (CP_90 CP_149) resistor r=4.16253
    rCP_184 (CP_90 CP_95) resistor r=8.69167
    rCP_183 (CP_90 CP_92) resistor r=8.69167
    rCP_182 (CP_90 CP_103) resistor r=24.8333
    rCP_181 (CP_90 CP_100) resistor r=24.8333
    rCP_180 (CP_90 CP_391) resistor r=54.6333
    rCP_179 (CP_90 CP_108) resistor r=14.9
    rCP_178 (CP_90 CP_125) resistor r=8.69167
    rCP_177 (CP_90 CP_122) resistor r=8.69167
    rCP_176 (CP_90 CP_146) resistor r=58.3583
    rCP_175 (CP_90 MM9_ELT_g) resistor r=7.45
    rCP_174 (CP_90 CP_95) resistor r=4.16253
    rCP_173 (CP_90 CP_103) resistor r=4.16253
    rCP_172 (CP_90 CP_125) resistor r=6.30933
    rCP_171 (CP_90 CP_92) resistor r=6.30933
    rCP_170 (CP_90 CP_108) resistor r=1.63969
    rCP_169 (CP_90 CP_122) resistor r=4.16253
    rCP_168 (CP_90 CP_146) resistor r=4.16253
    rCP_167 (CP_90 CP_100) resistor r=4.16253
    rCP_166 (CP_90 CP_149) resistor r=4.16253
    rCP_165 (CP_114 CP_120) resistor r=58.3583
    rCP_164 (CP_114 CP_120) resistor r=4.16253
    rCP_163 (CP_114 CP_120) resistor r=58.3583
    rCP_162 (CP_114 CP_120) resistor r=4.16253
    rCP_161 (CP_117 CP_120) resistor r=58.3583
    rCP_160 (CP_117 CP_120) resistor r=4.16253
    rCP_159 (CP_117 CP_120) resistor r=58.3583
    rCP_158 (CP_117 CP_120) resistor r=4.16253
    rCP_157 (CP_120 CP_133) resistor r=24.8333
    rCP_156 (CP_120 CP_130) resistor r=24.8333
    rCP_155 (CP_120 CP_141) resistor r=8.69167
    rCP_154 (CP_120 CP_138) resistor r=8.69167
    rCP_153 (CP_120 CP_154) resistor r=14.9
    rCP_152 (CP_120 CP_163) resistor r=8.69167
    rCP_151 (CP_120 CP_160) resistor r=8.69167
    rCP_150 (CP_120 CP_168) resistor r=58.3583
    rCP_149 (CP_120 CP_171) resistor r=58.3583
    rCP_148 (CP_120 CP_133) resistor r=4.16253
    rCP_147 (CP_120 CP_141) resistor r=4.16253
    rCP_146 (CP_120 CP_163) resistor r=6.30933
    rCP_145 (CP_120 CP_138) resistor r=6.30933
    rCP_144 (CP_120 CP_154) resistor r=1.63969
    rCP_143 (CP_120 CP_130) resistor r=4.16253
    rCP_142 (CP_120 CP_168) resistor r=4.16253
    rCP_141 (CP_120 CP_160) resistor r=4.16253
    rCP_140 (CP_120 CP_171) resistor r=4.16253
    rCP_139 (CP_120 CP_133) resistor r=24.8333
    rCP_138 (CP_120 CP_130) resistor r=24.8333
    rCP_137 (CP_120 CP_141) resistor r=8.69167
    rCP_136 (CP_120 CP_138) resistor r=8.69167
    rCP_135 (CP_120 CP_154) resistor r=14.9
    rCP_134 (CP_120 CP_414) resistor r=40.975
    rCP_133 (CP_120 CP_163) resistor r=8.69167
    rCP_132 (CP_120 CP_160) resistor r=8.69167
    rCP_131 (CP_120 CP_168) resistor r=58.3583
    rCP_130 (CP_120 MM6_ELT_g) resistor r=7.45
    rCP_129 (CP_120 CP_133) resistor r=4.16253
    rCP_128 (CP_120 CP_141) resistor r=4.16253
    rCP_127 (CP_120 CP_163) resistor r=6.30933
    rCP_126 (CP_120 CP_138) resistor r=6.30933
    rCP_125 (CP_120 CP_154) resistor r=1.63969
    rCP_124 (CP_120 CP_130) resistor r=4.16253
    rCP_123 (CP_120 CP_168) resistor r=4.16253
    rCP_122 (CP_120 CP_160) resistor r=4.16253
    rCP_121 (CP_120 CP_171) resistor r=4.16253
    rCP_120 (CP_149 MM9_ELT_g) resistor r=50.9083
    rCP_119 (CP_171 MM6_ELT_g) resistor r=50.9083
    rCP_118 (CP_176 CP_179) resistor r=14.9
    rCP_117 (CP_176 CP_179) resistor r=6.30933
    rCP_116 (CP_176 CP_179) resistor r=14.9
    rCP_115 (CP_176 CP_179) resistor r=6.30933
    rCP_114 (CP_179 CP_182) resistor r=58.3583
    rCP_113 (CP_179 CP_185) resistor r=58.3583
    rCP_112 (CP_179 CP_193) resistor r=24.8333
    rCP_111 (CP_179 CP_190) resistor r=24.8333
    rCP_110 (CP_179 CP_201) resistor r=24.8333
    rCP_109 (CP_179 CP_198) resistor r=24.8333
    rCP_108 (CP_179 CP_206) resistor r=58.3583
    rCP_107 (CP_179 CP_209) resistor r=58.3583
    rCP_106 (CP_179 CP_182) resistor r=6.30933
    rCP_105 (CP_179 CP_193) resistor r=1.63969
    rCP_104 (CP_179 CP_201) resistor r=4.16253
    rCP_103 (CP_179 CP_185) resistor r=4.16253
    rCP_102 (CP_179 CP_190) resistor r=4.16253
    rCP_101 (CP_179 CP_206) resistor r=4.16253
    rCP_100 (CP_179 CP_198) resistor r=4.16253
    rCP_99 (CP_179 CP_209) resistor r=4.16253
    rCP_98 (CP_179 CP_424) resistor r=39.7333
    rCP_97 (CP_179 CP_182) resistor r=58.3583
    rCP_96 (CP_179 CP_185) resistor r=58.3583
    rCP_95 (CP_179 CP_193) resistor r=24.8333
    rCP_94 (CP_179 CP_190) resistor r=24.8333
    rCP_93 (CP_179 CP_201) resistor r=24.8333
    rCP_92 (CP_179 CP_198) resistor r=24.8333
    rCP_91 (CP_179 CP_206) resistor r=58.3583
    rCP_90 (CP_179 MM5_ELT_g) resistor r=7.45
    rCP_89 (CP_179 CP_182) resistor r=6.30933
    rCP_88 (CP_179 CP_193) resistor r=1.63969
    rCP_87 (CP_179 CP_201) resistor r=4.16253
    rCP_86 (CP_179 CP_185) resistor r=4.16253
    rCP_85 (CP_179 CP_190) resistor r=4.16253
    rCP_84 (CP_179 CP_206) resistor r=4.16253
    rCP_83 (CP_179 CP_198) resistor r=4.16253
    rCP_82 (CP_179 CP_209) resistor r=4.16253
    rCP_81 (CP_209 MM5_ELT_g) resistor r=50.9083
    rCP_80 (CP_289 CP) resistor r=0.0423078
    rCP_79 (CP_289 CP_296) resistor r=0.103486
    rCP_78 (CP_291 CP_292) resistor r=10
    rCP_77 (CP_291 CP) resistor r=0.0864108
    rCP_76 (CP_292 CP_467) resistor r=7.88824
    rCP_75 (CP_296 CP_300) resistor r=0.0413004
    rCP_74 (CP_297 CP_299) resistor r=0.163531
    rCP_73 (CP_297 CP_303) resistor r=0.0771588
    rCP_72 (CP_299 CP_300) resistor r=0.75
    rCP_71 (CP_302 CP_303) resistor r=0.382984
    rCP_70 (CP_302 CP_317) resistor r=0.0578524
    rCP_69 (CP_304 CP_305) resistor r=0.606081
    rCP_68 (CP_304 CP_317) resistor r=0.0150348
    rCP_67 (CP_305 CP_308) resistor r=0.0763353
    rCP_66 (CP_306 CP_307) resistor r=0.598644
    rCP_65 (CP_306 CP_314) resistor r=0.0763353
    rCP_64 (CP_307 CP_317) resistor r=0.0578524
    rCP_63 (CP_308 CP_310) resistor r=0.0446195
    rCP_62 (CP_310 CP_311) resistor r=0.75
    rCP_61 (CP_311 CP_462) resistor r=10
    rCP_60 (CP_313 CP_314) resistor r=0.0632109
    rCP_59 (CP_313 CP_319) resistor r=0.0414208
    rCP_58 (CP_319 CP_320) resistor r=0.75
    rCP_57 (CP_320 CP_470) resistor r=10
    rCP_56 (CP_365 CP_467) resistor r=8.45489
    rCP_55 (CP_391 CP_448) resistor r=4.38767
    rCP_54 (CP_397 CP_398) resistor r=17.6091
    rCP_53 (CP_397 CP_414) resistor r=9.29775
    rCP_52 (CP_398 CP_448) resistor r=3.71511
    rCP_51 (CP_424 CP_473) resistor r=5.23411
    rCP_50 (CP_447 CP_448) resistor r=3.71511
    rCP_49 (CP_447 CP_462) resistor r=4.74091
    rCP_48 (CP_470 CP_473) resistor r=5.41818
    rD_106 (D_22 D_28) resistor r=58.3583
    rD_105 (D_22 D_28) resistor r=4.16253
    rD_104 (D_22 D_28) resistor r=58.3583
    rD_103 (D_22 D_28) resistor r=4.16253
    rD_102 (D_25 D_28) resistor r=58.3583
    rD_101 (D_25 D_28) resistor r=4.16253
    rD_100 (D_25 D_28) resistor r=58.3583
    rD_99 (D_25 D_28) resistor r=4.16253
    rD_98 (D_28 D_47) resistor r=24.8333
    rD_97 (D_28 D_44) resistor r=24.8333
    rD_96 (D_28 D_55) resistor r=24.8333
    rD_95 (D_28 D_52) resistor r=24.8333
    rD_94 (D_28 D_76) resistor r=58.3583
    rD_93 (D_28 D_79) resistor r=58.3583
    rD_92 (D_28 D_84) resistor r=14.9
    rD_91 (D_28 D_47) resistor r=4.16253
    rD_90 (D_28 D_55) resistor r=4.16253
    rD_89 (D_28 D_44) resistor r=4.16253
    rD_88 (D_28 D_76) resistor r=4.16253
    rD_87 (D_28 D_84) resistor r=6.30933
    rD_86 (D_28 D_79) resistor r=6.30933
    rD_85 (D_28 D_52) resistor r=1.63969
    rD_84 (D_28 D_47) resistor r=24.8333
    rD_83 (D_28 D_44) resistor r=24.8333
    rD_82 (D_28 D_55) resistor r=24.8333
    rD_81 (D_28 D_52) resistor r=24.8333
    rD_80 (D_28 D_76) resistor r=58.3583
    rD_79 (D_28 MM1_ELT_g) resistor r=22.35
    rD_78 (D_28 D_84) resistor r=14.9
    rD_77 (D_28 D_187) resistor r=39.7333
    rD_76 (D_28 D_47) resistor r=4.16253
    rD_75 (D_28 D_55) resistor r=4.16253
    rD_74 (D_28 D_44) resistor r=4.16253
    rD_73 (D_28 D_76) resistor r=4.16253
    rD_72 (D_28 D_84) resistor r=6.30933
    rD_71 (D_28 D_79) resistor r=6.30933
    rD_70 (D_28 D_52) resistor r=1.63969
    rD_69 (D_30 D_33) resistor r=14.9
    rD_68 (D_30 D_33) resistor r=6.30933
    rD_67 (D_30 D_33) resistor r=14.9
    rD_66 (D_30 D_33) resistor r=6.30933
    rD_65 (D_33 D_36) resistor r=58.3583
    rD_64 (D_33 D_39) resistor r=58.3583
    rD_63 (D_33 D_63) resistor r=24.8333
    rD_62 (D_33 D_60) resistor r=24.8333
    rD_61 (D_33 D_71) resistor r=24.8333
    rD_60 (D_33 D_68) resistor r=24.8333
    rD_59 (D_33 D_90) resistor r=58.3583
    rD_58 (D_33 D_93) resistor r=58.3583
    rD_57 (D_33 D_36) resistor r=6.30933
    rD_56 (D_33 D_63) resistor r=1.63969
    rD_55 (D_33 D_71) resistor r=4.16253
    rD_54 (D_33 D_39) resistor r=4.16253
    rD_53 (D_33 D_60) resistor r=4.16253
    rD_52 (D_33 D_90) resistor r=4.16253
    rD_51 (D_33 D_68) resistor r=4.16253
    rD_50 (D_33 D_93) resistor r=4.16253
    rD_49 (D_33 D_161) resistor r=39.7333
    rD_48 (D_33 D_36) resistor r=58.3583
    rD_47 (D_33 D_39) resistor r=58.3583
    rD_46 (D_33 D_63) resistor r=24.8333
    rD_45 (D_33 D_60) resistor r=24.8333
    rD_44 (D_33 D_71) resistor r=24.8333
    rD_43 (D_33 D_68) resistor r=24.8333
    rD_42 (D_33 D_90) resistor r=58.3583
    rD_41 (D_33 MM11_ELT_g) resistor r=7.45
    rD_40 (D_33 D_36) resistor r=6.30933
    rD_39 (D_33 D_63) resistor r=1.63969
    rD_38 (D_33 D_71) resistor r=4.16253
    rD_37 (D_33 D_39) resistor r=4.16253
    rD_36 (D_33 D_60) resistor r=4.16253
    rD_35 (D_33 D_90) resistor r=4.16253
    rD_34 (D_33 D_68) resistor r=4.16253
    rD_33 (D_33 D_93) resistor r=4.16253
    rD_32 (D_79 MM1_ELT_g) resistor r=36.0083
    rD_31 (D_93 MM11_ELT_g) resistor r=50.9083
    rD_30 (D_132 D_133) resistor r=10
    rD_29 (D_132 D) resistor r=0.0784616
    rD_28 (D_133 D_200) resistor r=13.5455
    rD_27 (D_161 D_201) resistor r=4.38767
    rD_26 (D_173 D_174) resistor r=57.5682
    rD_25 (D_173 D_197) resistor r=9.29775
    rD_24 (D_174 D_201) resistor r=3.71511
    rD_23 (D_187 D_195) resistor r=8.32506
    rD_22 (D_194 D_195) resistor r=40.975
    rD_21 (D_194 D_196) resistor r=8.32506
    rD_20 (D_196 D_197) resistor r=275.65
    rD_19 (D_200 D_201) resistor r=3.71511
ends DDFQD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: ND2D1_LVT_ELT
// View name: calibre
subckt ND2D1_LVT_ELT A1 A2 VDD VSS ZN
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciVDD_15 (VDD_2 VSS) capacitor c=6.33973e-17
    ciVDD_14 (VDD_11 VSS) capacitor c=1.88221e-16
    ciVDD_13 (VDD_20 VSS) capacitor c=7.825e-17
    ciVDD_12 (VDD_30 VSS) capacitor c=1.22578e-16
    ciVDD_11 (VDD_38 VSS) capacitor c=1.2163e-17
    ciVDD_10 (VDD_39 VSS) capacitor c=3.58509e-18
    ciVDD_9 (VDD_45 VSS) capacitor c=1.32762e-17
    ciVDD_8 (VDD_47 VSS) capacitor c=4.02905e-18
    ciVDD_7 (VDD_48 VSS) capacitor c=2.09391e-16
    ciVDD_6 (VDD_50 VSS) capacitor c=1.11099e-18
    ciVDD_5 (MM11_ELT_s VSS) capacitor c=1.63171e-17
    ciVDD_4 (VDD_53 VSS) capacitor c=1.87212e-16
    ciVDD_3 (VDD_55 VSS) capacitor c=1.11099e-18
    ciVDD_2 (VDD_56 VSS) capacitor c=5.77375e-18
    ciVDD_1 (VDD_57 VSS) capacitor c=2.77877e-18
    ciVDD_0 (VDD_58 VSS) capacitor c=1.84269e-17
    ciVSS_6 (VSS_2 VSS) capacitor c=1.65509e-16
    ciVSS_5 (VSS_17 VSS) capacitor c=4.06628e-17
    ciVSS_4 (VSS_18 VSS) capacitor c=5.8627e-17
    ciVSS_3 (MM1_ELT_s VSS) capacitor c=1.0086e-17
    ciVSS_2 (VSS_23 VSS) capacitor c=5.64253e-19
    ciVSS_1 (VSS_25 VSS) capacitor c=5.77404e-18
    ciVSS_0 (VSS_26 VSS) capacitor c=2.37891e-18
    ciZN_11 (ZN_3 VSS) capacitor c=5.52385e-17
    ciZN_10 (ZN_4 VSS) capacitor c=1.09775e-16
    ciZN_9 (ZN_8 VSS) capacitor c=1.87785e-16
    ciZN_8 (ZN_9 VSS) capacitor c=3.31103e-16
    ciZN_7 (ZN_18 VSS) capacitor c=4.5673e-17
    ciZN_6 (ZN_19 VSS) capacitor c=6.60784e-17
    ciZN_5 (ZN_20 VSS) capacitor c=3.15373e-17
    ciZN_4 (ZN_23 VSS) capacitor c=1.75933e-16
    ciZN_3 (ZN_24 VSS) capacitor c=3.40341e-16
    ciZN_2 (ZN_32 VSS) capacitor c=2.38898e-17
    ciZN_1 (ZN VSS) capacitor c=5.56176e-17
    ciZN_0 (ZN_38 VSS) capacitor c=4.06868e-17
    ciA2_14 (A2_22 VSS) capacitor c=7.01511e-18
    ciA2_13 (A2_28 VSS) capacitor c=2.15915e-16
    ciA2_12 (A2_39 VSS) capacitor c=6.16398e-16
    ciA2_11 (A2_45 VSS) capacitor c=3.35294e-18
    ciA2_10 (A2_50 VSS) capacitor c=2.23218e-17
    ciA2_9 (A2_58 VSS) capacitor c=1.78864e-17
    ciA2_8 (A2_66 VSS) capacitor c=2.02831e-17
    ciA2_7 (A2_74 VSS) capacitor c=1.51948e-17
    ciA2_6 (A2_82 VSS) capacitor c=4.2013e-18
    ciA2_5 (A2_85 VSS) capacitor c=5.24083e-18
    ciA2_4 (A2_90 VSS) capacitor c=5.29748e-18
    ciA2_3 (A2_93 VSS) capacitor c=3.00043e-18
    ciA2_2 (A2 VSS) capacitor c=6.88542e-17
    ciA2_1 (A2_194 VSS) capacitor c=3.67405e-17
    ciA2_0 (A2_195 VSS) capacitor c=1.51792e-17
    cinet014_4 (net014_5 VSS) capacitor c=9.27739e-17
    cinet014_3 (net014_6 VSS) capacitor c=1.1105e-16
    cinet014_2 (net014_9 VSS) capacitor c=4.15894e-17
    cinet014_1 (net014_19 VSS) capacitor c=3.00243e-18
    cinet014_0 (net014_20 VSS) capacitor c=8.95238e-17
    ciA1_12 (A1_22 VSS) capacitor c=2.22299e-18
    ciA1_11 (A1_28 VSS) capacitor c=1.77106e-16
    ciA1_10 (A1_33 VSS) capacitor c=2.22299e-18
    ciA1_9 (A1_36 VSS) capacitor c=5.71853e-16
    ciA1_8 (A1_38 VSS) capacitor c=2.23697e-17
    ciA1_7 (A1_46 VSS) capacitor c=2.4443e-17
    ciA1_6 (A1_54 VSS) capacitor c=1.49901e-17
    ciA1_5 (A1_62 VSS) capacitor c=1.51948e-17
    ciA1_4 (A1_70 VSS) capacitor c=2.79902e-17
    ciA1_3 (A1_93 VSS) capacitor c=4.28147e-18
    ciA1_2 (A1 VSS) capacitor c=4.49577e-17
    ciA1_1 (A1_198 VSS) capacitor c=2.75557e-17
    ciA1_0 (A1_199 VSS) capacitor c=1.1684e-17
    rVDD_68 (MM11_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_67 (MM10_ELT_b VDD_23) resistor r=8.66667
    rVDD_66 (MM10_ELT_b VDD_26) resistor r=13
    rVDD_65 (MM10_ELT_b VDD_8) resistor r=56.2667
    rVDD_64 (VDD_2 VDD_7) resistor r=0.11464
    rVDD_63 (VDD_2 VDD_39) resistor r=0.0221557
    rVDD_62 (VDD VDD_7) resistor r=0.102781
    rVDD_61 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_60 (VDD_9 VDD_18) resistor r=0.378317
    rVDD_59 (VDD_9 VDD_39) resistor r=0.0882198
    rVDD_58 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_57 (VDD_11 VDD_15) resistor r=0.639409
    rVDD_56 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_55 (VDD_15 VDD_18) resistor r=0.639409
    rVDD_54 (VDD_18 VDD_19) resistor r=8.66667
    rVDD_53 (VDD_19 MM10_ELT_s) resistor r=1.847
    rVDD_52 (VDD_19 VDD_58) resistor r=20.317
    rVDD_51 (VDD_20 VDD_26) resistor r=0.00988276
    rVDD_50 (VDD_20 VDD_28) resistor r=0.142361
    rVDD_49 (VDD_21 VDD_23) resistor r=0.0869683
    rVDD_48 (VDD_21 VDD_39) resistor r=0.0221557
    rVDD_47 (VDD_23 VDD_26) resistor r=0.158124
    rVDD_46 (VDD_28 VDD_37) resistor r=0.378317
    rVDD_45 (VDD_30 VDD_38) resistor r=8.66667
    rVDD_44 (VDD_30 VDD_34) resistor r=0.639409
    rVDD_43 (VDD_34 VDD_38) resistor r=8.66667
    rVDD_42 (VDD_34 VDD_37) resistor r=0.639409
    rVDD_41 (VDD_37 VDD_38) resistor r=8.66667
    rVDD_40 (VDD_38 VDD_60) resistor r=27.2424
    rVDD_39 (VDD_38 VDD_59) resistor r=27.2424
    rVDD_38 (VDD_38 MM11_ELT_s) resistor r=5.66484
    rVDD_37 (VDD_42 VDD_45) resistor r=31.2341
    rVDD_36 (VDD_42 VDD_46) resistor r=9.04595
    rVDD_35 (VDD_43 VDD_45) resistor r=31.2341
    rVDD_34 (VDD_43 VDD_49) resistor r=9.04062
    rVDD_33 (MM10_ELT_s VDD_45) resistor r=6.12113
    rVDD_32 (MM10_ELT_s VDD_47) resistor r=12.3172
    rVDD_31 (MM10_ELT_s VDD_47) resistor r=1.62887
    rVDD_30 (MM10_ELT_s VDD_50) resistor r=2.55965
    rVDD_29 (VDD_46 VDD_47) resistor r=12.3172
    rVDD_28 (VDD_48 VDD_50) resistor r=14.4784
    rVDD_27 (VDD_48 VDD_58) resistor r=9.48555
    rVDD_26 (VDD_49 VDD_50) resistor r=14.4784
    rVDD_25 (MM11_ELT_s VDD_52) resistor r=25.7298
    rVDD_24 (MM11_ELT_s VDD_55) resistor r=2.55965
    rVDD_23 (MM11_ELT_s VDD_57) resistor r=12.3172
    rVDD_22 (MM11_ELT_s VDD_57) resistor r=1.62887
    rVDD_21 (VDD_52 VDD_54) resistor r=9.04062
    rVDD_20 (VDD_53 VDD_55) resistor r=14.4784
    rVDD_19 (VDD_53 VDD_60) resistor r=9.48555
    rVDD_18 (VDD_54 VDD_55) resistor r=14.4784
    rVDD_17 (VDD_56 VDD_57) resistor r=12.3172
    rVDD_16 (VDD_56 VDD_59) resistor r=9.39461
    rVSS_31 (MM1_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_30 (MM2_ELT_b VSS_10) resistor r=8.66667
    rVSS_29 (MM2_ELT_b VSS_13) resistor r=13
    rVSS_28 (MM2_ELT_b VSS_8) resistor r=53.9357
    rVSS_27 (VSS_2 VSS_13) resistor r=0.00988276
    rVSS_26 (VSS_2 VSS_15) resistor r=0.142361
    rVSS_25 (VSS VSS_7) resistor r=0.100804
    rVSS_24 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_23 (VSS_7 VSS_10) resistor r=0.237528
    rVSS_22 (VSS_10 VSS_13) resistor r=0.158124
    rVSS_21 (VSS_15 VSS_17) resistor r=0.404959
    rVSS_20 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_19 (VSS_18 VSS_28) resistor r=17.2126
    rVSS_18 (VSS_18 VSS_27) resistor r=17.2126
    rVSS_17 (VSS_18 MM1_ELT_s) resistor r=3.43331
    rVSS_16 (MM1_ELT_s VSS_21) resistor r=18.0507
    rVSS_15 (MM1_ELT_s VSS_24) resistor r=2.67027
    rVSS_14 (MM1_ELT_s VSS_26) resistor r=12.8495
    rVSS_13 (MM1_ELT_s VSS_26) resistor r=1.69926
    rVSS_12 (VSS_21 VSS_23) resistor r=9.43134
    rVSS_11 (VSS_22 VSS_24) resistor r=15.1041
    rVSS_10 (VSS_22 VSS_27) resistor r=9.89549
    rVSS_9 (VSS_23 VSS_24) resistor r=15.1041
    rVSS_8 (VSS_25 VSS_26) resistor r=12.8495
    rVSS_7 (VSS_25 VSS_28) resistor r=9.80063
    rZN_44 (ZN_1 ZN_3) resistor r=0.399631
    rZN_43 (ZN_1 ZN_38) resistor r=0.193127
    rZN_42 (ZN_3 ZN_4) resistor r=13
    rZN_41 (ZN_4 MM2_ELT_d) resistor r=8.44
    rZN_40 (ZN_6 ZN_8) resistor r=0.50087
    rZN_39 (ZN_6 ZN_40) resistor r=0.0269214
    rZN_38 (ZN_8 ZN_9) resistor r=8.66667
    rZN_37 (ZN_8 ZN_11) resistor r=0.639409
    rZN_36 (ZN_9 MM10_ELT_d) resistor r=32.3614
    rZN_35 (ZN_11 ZN_12) resistor r=8.66667
    rZN_34 (ZN_11 ZN_14) resistor r=0.426273
    rZN_33 (ZN_12 MM10_ELT_d) resistor r=16.1807
    rZN_32 (ZN_12 ZN_15) resistor r=32.3614
    rZN_31 (ZN_14 ZN_15) resistor r=26
    rZN_30 (ZN_17 ZN_18) resistor r=0.506767
    rZN_29 (ZN_17 ZN_38) resistor r=0.0373261
    rZN_28 (ZN_18 ZN_42) resistor r=0.0269214
    rZN_27 (ZN_19 ZN_20) resistor r=0.667702
    rZN_26 (ZN_19 ZN_43) resistor r=0.0423696
    rZN_25 (ZN_20 ZN_42) resistor r=0.0518304
    rZN_24 (ZN_21 ZN_23) resistor r=0.50087
    rZN_23 (ZN_21 ZN_43) resistor r=0.0269214
    rZN_22 (ZN_23 ZN_24) resistor r=8.66667
    rZN_21 (ZN_23 ZN_26) resistor r=0.639409
    rZN_20 (ZN_24 MM11_ELT_d) resistor r=32.3614
    rZN_19 (ZN_26 ZN_27) resistor r=8.66667
    rZN_18 (ZN_26 ZN_29) resistor r=0.426273
    rZN_17 (ZN_27 MM11_ELT_d) resistor r=16.1807
    rZN_16 (ZN_27 ZN_30) resistor r=32.3614
    rZN_15 (ZN_29 ZN_30) resistor r=26
    rZN_14 (ZN_32 ZN) resistor r=0.265521
    rZN_13 (ZN_32 ZN_43) resistor r=0.14594
    rZN_12 (ZN_40 ZN_42) resistor r=0.21308
    rA2_96 (A2_22 A2_28) resistor r=58.3583
    rA2_95 (A2_22 A2_28) resistor r=4.16253
    rA2_94 (A2_22 A2_28) resistor r=58.3583
    rA2_93 (A2_22 A2_28) resistor r=4.16253
    rA2_92 (A2_25 A2_28) resistor r=58.3583
    rA2_91 (A2_25 A2_28) resistor r=6.30933
    rA2_90 (A2_25 A2_28) resistor r=58.3583
    rA2_89 (A2_25 A2_28) resistor r=6.30933
    rA2_88 (A2_28 A2_30) resistor r=14.9
    rA2_87 (A2_28 A2_53) resistor r=24.8333
    rA2_86 (A2_28 A2_50) resistor r=24.8333
    rA2_85 (A2_28 A2_61) resistor r=24.8333
    rA2_84 (A2_28 A2_58) resistor r=24.8333
    rA2_83 (A2_28 A2_82) resistor r=58.3583
    rA2_82 (A2_28 A2_85) resistor r=58.3583
    rA2_81 (A2_28 A2_53) resistor r=4.16253
    rA2_80 (A2_28 A2_30) resistor r=6.30933
    rA2_79 (A2_28 A2_61) resistor r=1.63969
    rA2_78 (A2_28 A2_50) resistor r=4.16253
    rA2_77 (A2_28 A2_82) resistor r=4.16253
    rA2_76 (A2_28 A2_58) resistor r=4.16253
    rA2_75 (A2_28 A2_85) resistor r=4.16253
    rA2_74 (A2_28 A2_30) resistor r=14.9
    rA2_73 (A2_28 A2_162) resistor r=40.975
    rA2_72 (A2_28 A2_53) resistor r=24.8333
    rA2_71 (A2_28 A2_50) resistor r=24.8333
    rA2_70 (A2_28 A2_61) resistor r=24.8333
    rA2_69 (A2_28 A2_58) resistor r=24.8333
    rA2_68 (A2_28 A2_82) resistor r=58.3583
    rA2_67 (A2_28 MM1_ELT_g) resistor r=7.45
    rA2_66 (A2_28 A2_53) resistor r=4.16253
    rA2_65 (A2_28 A2_30) resistor r=6.30933
    rA2_64 (A2_28 A2_61) resistor r=1.63969
    rA2_63 (A2_28 A2_50) resistor r=4.16253
    rA2_62 (A2_28 A2_82) resistor r=4.16253
    rA2_61 (A2_28 A2_58) resistor r=4.16253
    rA2_60 (A2_28 A2_85) resistor r=4.16253
    rA2_59 (A2_36 A2_39) resistor r=14.9
    rA2_58 (A2_36 A2_39) resistor r=6.30933
    rA2_57 (A2_36 A2_39) resistor r=14.9
    rA2_56 (A2_36 A2_39) resistor r=6.30933
    rA2_55 (A2_39 A2_42) resistor r=202.392
    rA2_54 (A2_39 A2_45) resistor r=202.392
    rA2_53 (A2_39 A2_69) resistor r=24.8333
    rA2_52 (A2_39 A2_66) resistor r=24.8333
    rA2_51 (A2_39 A2_77) resistor r=24.8333
    rA2_50 (A2_39 A2_74) resistor r=24.8333
    rA2_49 (A2_39 A2_90) resistor r=202.392
    rA2_48 (A2_39 A2_93) resistor r=202.392
    rA2_47 (A2_39 A2_42) resistor r=6.30933
    rA2_46 (A2_39 A2_69) resistor r=1.63969
    rA2_45 (A2_39 A2_77) resistor r=4.16253
    rA2_44 (A2_39 A2_45) resistor r=4.16253
    rA2_43 (A2_39 A2_66) resistor r=4.16253
    rA2_42 (A2_39 A2_90) resistor r=4.16253
    rA2_41 (A2_39 A2_74) resistor r=4.16253
    rA2_40 (A2_39 A2_93) resistor r=4.16253
    rA2_39 (A2_39 A2_164) resistor r=40.975
    rA2_38 (A2_39 A2_42) resistor r=202.392
    rA2_37 (A2_39 A2_45) resistor r=202.392
    rA2_36 (A2_39 A2_69) resistor r=24.8333
    rA2_35 (A2_39 A2_66) resistor r=24.8333
    rA2_34 (A2_39 A2_77) resistor r=24.8333
    rA2_33 (A2_39 A2_74) resistor r=24.8333
    rA2_32 (A2_39 A2_90) resistor r=202.392
    rA2_31 (A2_39 MM11_ELT_g) resistor r=7.45
    rA2_30 (A2_39 A2_42) resistor r=6.30933
    rA2_29 (A2_39 A2_69) resistor r=1.63969
    rA2_28 (A2_39 A2_77) resistor r=4.16253
    rA2_27 (A2_39 A2_45) resistor r=4.16253
    rA2_26 (A2_39 A2_66) resistor r=4.16253
    rA2_25 (A2_39 A2_90) resistor r=4.16253
    rA2_24 (A2_39 A2_74) resistor r=4.16253
    rA2_23 (A2_39 A2_93) resistor r=4.16253
    rA2_22 (A2_85 MM1_ELT_g) resistor r=50.9083
    rA2_21 (A2_93 MM11_ELT_g) resistor r=194.942
    rA2_20 (A2_132 A2_133) resistor r=10
    rA2_19 (A2_132 A2) resistor r=0.0869116
    rA2_18 (A2_133 A2_194) resistor r=19.6409
    rA2_17 (A2_162 A2_195) resistor r=10.0997
    rA2_16 (A2_164 A2_195) resistor r=10.0997
    rA2_15 (A2_194 A2_195) resistor r=0.877078
    rnet014_24 (MM1_ELT_d net014) resistor r=0.01
    rnet014_23 (net014_3 net014_5) resistor r=0.148705
    rnet014_22 (net014_3 net014_9) resistor r=0.0295103
    rnet014_21 (net014_5 net014_6) resistor r=13
    rnet014_20 (net014_6 net014) resistor r=8.44
    rnet014_19 (net014_9 net014_10) resistor r=8.66667
    rnet014_18 (net014_10 MM2_ELT_s) resistor r=2.90692
    rnet014_17 (net014_10 net014_20) resistor r=12.1406
    rnet014_16 (net014_11 net014_14) resistor r=21.1301
    rnet014_15 (net014_11 net014_16) resistor r=9.43134
    rnet014_14 (net014_12 net014_14) resistor r=21.1301
    rnet014_13 (net014_12 net014_18) resistor r=9.4369
    rnet014_12 (MM2_ELT_s net014_14) resistor r=4.557
    rnet014_11 (MM2_ELT_s net014_17) resistor r=2.67027
    rnet014_10 (MM2_ELT_s net014_19) resistor r=12.8495
    rnet014_9 (MM2_ELT_s net014_19) resistor r=1.69926
    rnet014_8 (net014_15 net014_17) resistor r=15.1041
    rnet014_7 (net014_15 net014_20) resistor r=9.89549
    rnet014_6 (net014_16 net014_17) resistor r=15.1041
    rnet014_5 (net014_18 net014_19) resistor r=12.8495
    rA1_94 (A1_22 A1_28) resistor r=58.3583
    rA1_93 (A1_22 A1_28) resistor r=4.16253
    rA1_92 (A1_22 A1_28) resistor r=58.3583
    rA1_91 (A1_22 A1_28) resistor r=4.16253
    rA1_90 (A1_25 A1_28) resistor r=58.3583
    rA1_89 (A1_25 A1_28) resistor r=4.16253
    rA1_88 (A1_25 A1_28) resistor r=58.3583
    rA1_87 (A1_25 A1_28) resistor r=4.16253
    rA1_86 (A1_28 A1_41) resistor r=24.8333
    rA1_85 (A1_28 A1_38) resistor r=24.8333
    rA1_84 (A1_28 A1_49) resistor r=24.8333
    rA1_83 (A1_28 A1_46) resistor r=24.8333
    rA1_82 (A1_28 A1_70) resistor r=58.3583
    rA1_81 (A1_28 A1_73) resistor r=58.3583
    rA1_80 (A1_28 A1_78) resistor r=14.9
    rA1_79 (A1_28 A1_41) resistor r=4.16253
    rA1_78 (A1_28 A1_49) resistor r=4.16253
    rA1_77 (A1_28 A1_38) resistor r=4.16253
    rA1_76 (A1_28 A1_70) resistor r=4.16253
    rA1_75 (A1_28 A1_78) resistor r=6.30933
    rA1_74 (A1_28 A1_73) resistor r=6.30933
    rA1_73 (A1_28 A1_46) resistor r=1.63969
    rA1_72 (A1_28 A1_41) resistor r=24.8333
    rA1_71 (A1_28 A1_38) resistor r=24.8333
    rA1_70 (A1_28 A1_49) resistor r=24.8333
    rA1_69 (A1_28 A1_46) resistor r=24.8333
    rA1_68 (A1_28 A1_70) resistor r=58.3583
    rA1_67 (A1_28 MM2_ELT_g) resistor r=22.35
    rA1_66 (A1_28 A1_78) resistor r=14.9
    rA1_65 (A1_28 A1_182) resistor r=40.975
    rA1_64 (A1_28 A1_41) resistor r=4.16253
    rA1_63 (A1_28 A1_49) resistor r=4.16253
    rA1_62 (A1_28 A1_38) resistor r=4.16253
    rA1_61 (A1_28 A1_70) resistor r=4.16253
    rA1_60 (A1_28 A1_78) resistor r=6.30933
    rA1_59 (A1_28 A1_73) resistor r=6.30933
    rA1_58 (A1_28 A1_46) resistor r=1.63969
    rA1_57 (A1_30 A1_36) resistor r=202.392
    rA1_56 (A1_30 A1_36) resistor r=4.16253
    rA1_55 (A1_30 A1_36) resistor r=202.392
    rA1_54 (A1_30 A1_36) resistor r=4.16253
    rA1_53 (A1_33 A1_36) resistor r=202.392
    rA1_52 (A1_33 A1_36) resistor r=4.16253
    rA1_51 (A1_33 A1_36) resistor r=202.392
    rA1_50 (A1_33 A1_36) resistor r=4.16253
    rA1_49 (A1_36 A1_57) resistor r=24.8333
    rA1_48 (A1_36 A1_54) resistor r=24.8333
    rA1_47 (A1_36 A1_65) resistor r=24.8333
    rA1_46 (A1_36 A1_62) resistor r=24.8333
    rA1_45 (A1_36 A1_84) resistor r=14.9
    rA1_44 (A1_36 A1_90) resistor r=202.392
    rA1_43 (A1_36 A1_93) resistor r=202.392
    rA1_42 (A1_36 A1_57) resistor r=4.16253
    rA1_41 (A1_36 A1_65) resistor r=4.16253
    rA1_40 (A1_36 A1_90) resistor r=6.30933
    rA1_39 (A1_36 A1_84) resistor r=6.30933
    rA1_38 (A1_36 A1_54) resistor r=1.63969
    rA1_37 (A1_36 A1_62) resistor r=4.16253
    rA1_36 (A1_36 A1_93) resistor r=4.16253
    rA1_35 (A1_36 A1_57) resistor r=24.8333
    rA1_34 (A1_36 A1_54) resistor r=24.8333
    rA1_33 (A1_36 A1_65) resistor r=24.8333
    rA1_32 (A1_36 A1_62) resistor r=24.8333
    rA1_31 (A1_36 A1_184) resistor r=40.975
    rA1_30 (A1_36 A1_84) resistor r=14.9
    rA1_29 (A1_36 A1_90) resistor r=202.392
    rA1_28 (A1_36 MM10_ELT_g) resistor r=7.45
    rA1_27 (A1_36 A1_57) resistor r=4.16253
    rA1_26 (A1_36 A1_65) resistor r=4.16253
    rA1_25 (A1_36 A1_90) resistor r=6.30933
    rA1_24 (A1_36 A1_84) resistor r=6.30933
    rA1_23 (A1_36 A1_54) resistor r=1.63969
    rA1_22 (A1_36 A1_62) resistor r=4.16253
    rA1_21 (A1_36 A1_93) resistor r=4.16253
    rA1_20 (A1_73 MM2_ELT_g) resistor r=36.0083
    rA1_19 (A1_93 MM10_ELT_g) resistor r=194.942
    rA1_18 (A1_132 A1_133) resistor r=10
    rA1_17 (A1_132 A1) resistor r=0.0846531
    rA1_16 (A1_133 A1_198) resistor r=41.3136
    rA1_15 (A1_182 A1_199) resistor r=10.0997
    rA1_14 (A1_184 A1_199) resistor r=10.0997
    rA1_13 (A1_198 A1_199) resistor r=0.877078
ends ND2D1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: INVD4_LVT_ELT
// View name: calibre
subckt INVD4_LVT_ELT I ZN VDD VSS
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.39187e-13 pd=1.34e-06 \
        ps=3.4075e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.39187e-13 pd=1.34e-06 \
        ps=3.4075e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.39187e-13 pd=1.34e-06 \
        ps=3.4075e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.39187e-13 pd=1.34e-06 \
        ps=3.4075e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.79887e-13 pd=3.66e-06 \
        ps=6.3075e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.79887e-13 pd=3.66e-06 \
        ps=6.3075e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.79887e-13 pd=3.66e-06 \
        ps=6.3075e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.79887e-13 pd=3.66e-06 \
        ps=6.3075e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    ciZN_32 (ZN_3 VSS) capacitor c=5.74125e-17
    ciZN_31 (ZN_4 VSS) capacitor c=1.11612e-16
    ciZN_30 (ZN_8 VSS) capacitor c=1.9029e-16
    ciZN_29 (ZN_9 VSS) capacitor c=3.2986e-16
    ciZN_28 (ZN_17 VSS) capacitor c=2.01744e-17
    ciZN_27 (ZN_18 VSS) capacitor c=1.11718e-17
    ciZN_26 (ZN_19 VSS) capacitor c=2.02011e-17
    ciZN_25 (ZN_20 VSS) capacitor c=1.11718e-17
    ciZN_24 (ZN_22 VSS) capacitor c=9.08534e-18
    ciZN_23 (ZN_24 VSS) capacitor c=9.08534e-18
    ciZN_22 (ZN_25 VSS) capacitor c=1.27079e-17
    ciZN_21 (ZN_29 VSS) capacitor c=8.2245e-17
    ciZN_20 (ZN_30 VSS) capacitor c=1.16798e-16
    ciZN_19 (ZN_34 VSS) capacitor c=2.50788e-16
    ciZN_18 (ZN_35 VSS) capacitor c=3.53332e-16
    ciZN_17 (ZN_43 VSS) capacitor c=2.7602e-17
    ciZN_16 (ZN_47 VSS) capacitor c=8.55306e-17
    ciZN_15 (ZN_48 VSS) capacitor c=1.16798e-16
    ciZN_14 (ZN_52 VSS) capacitor c=2.54263e-16
    ciZN_13 (ZN_53 VSS) capacitor c=3.53332e-16
    ciZN_12 (ZN_61 VSS) capacitor c=4.79307e-17
    ciZN_11 (ZN_65 VSS) capacitor c=4.75451e-17
    ciZN_10 (ZN_66 VSS) capacitor c=1.1105e-16
    ciZN_9 (ZN_70 VSS) capacitor c=1.73911e-16
    ciZN_8 (ZN_71 VSS) capacitor c=3.2943e-16
    ciZN_7 (ZN VSS) capacitor c=2.21817e-17
    ciZN_6 (ZN_84 VSS) capacitor c=2.62894e-17
    ciZN_5 (ZN_85 VSS) capacitor c=1.10678e-17
    ciZN_4 (ZN_86 VSS) capacitor c=1.86862e-18
    ciZN_3 (ZN_87 VSS) capacitor c=1.86862e-18
    ciZN_2 (ZN_90 VSS) capacitor c=1.85225e-17
    ciZN_1 (ZN_94 VSS) capacitor c=1.55823e-17
    ciZN_0 (ZN_96 VSS) capacitor c=4.06021e-18
    ciVDD_26 (VDD_2 VSS) capacitor c=6.33977e-17
    ciVDD_25 (VDD_11 VSS) capacitor c=2.41321e-16
    ciVDD_24 (VDD_19 VSS) capacitor c=2.02882e-17
    ciVDD_23 (VDD_20 VSS) capacitor c=2.99257e-17
    ciVDD_22 (VDD_27 VSS) capacitor c=2.35621e-16
    ciVDD_21 (VDD_35 VSS) capacitor c=1.64325e-17
    ciVDD_20 (VDD_36 VSS) capacitor c=2.99257e-17
    ciVDD_19 (VDD_43 VSS) capacitor c=2.41242e-16
    ciVDD_18 (VDD_51 VSS) capacitor c=1.64325e-17
    ciVDD_17 (VDD_54 VSS) capacitor c=7.04008e-17
    ciVDD_16 (VDD_57 VSS) capacitor c=3.58509e-18
    ciVDD_15 (VDD_58 VSS) capacitor c=3.58509e-18
    ciVDD_14 (VDD_59 VSS) capacitor c=3.58509e-18
    ciVDD_13 (VDD_65 VSS) capacitor c=1.32762e-17
    ciVDD_12 (VDD_67 VSS) capacitor c=4.65997e-18
    ciVDD_11 (VDD_70 VSS) capacitor c=1.11099e-18
    ciVDD_10 (VDD_74 VSS) capacitor c=1.11099e-18
    ciVDD_9 (VDD_76 VSS) capacitor c=5.8238e-18
    ciVDD_8 (VDD_79 VSS) capacitor c=6.16302e-18
    ciVDD_7 (VDD_82 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_86 VSS) capacitor c=1.11099e-18
    ciVDD_5 (VDD_87 VSS) capacitor c=5.8958e-18
    ciVDD_4 (VDD_88 VSS) capacitor c=3.59663e-18
    ciVDD_3 (VDD_91 VSS) capacitor c=1.62337e-17
    ciVDD_2 (VDD_93 VSS) capacitor c=3.75299e-16
    ciVDD_1 (VDD_97 VSS) capacitor c=3.75357e-16
    ciVDD_0 (VDD_99 VSS) capacitor c=3.75357e-16
    ciVSS_18 (VSS_2 VSS) capacitor c=6.14094e-17
    ciVSS_17 (VSS_11 VSS) capacitor c=6.9884e-17
    ciVSS_16 (VSS_12 VSS) capacitor c=1.20402e-16
    ciVSS_15 (VSS_14 VSS) capacitor c=3.02664e-17
    ciVSS_14 (VSS_21 VSS) capacitor c=6.54626e-17
    ciVSS_13 (VSS_22 VSS) capacitor c=1.17078e-16
    ciVSS_12 (VSS_24 VSS) capacitor c=3.02664e-17
    ciVSS_11 (VSS_31 VSS) capacitor c=6.98621e-17
    ciVSS_10 (VSS_32 VSS) capacitor c=1.17078e-16
    ciVSS_9 (VSS_36 VSS) capacitor c=6.81665e-17
    ciVSS_8 (VSS_39 VSS) capacitor c=3.58509e-18
    ciVSS_7 (VSS_40 VSS) capacitor c=3.58509e-18
    ciVSS_6 (VSS_41 VSS) capacitor c=3.58509e-18
    ciVSS_5 (VSS_50 VSS) capacitor c=3.97721e-18
    ciVSS_4 (VSS_56 VSS) capacitor c=4.75307e-18
    ciVSS_3 (VSS_62 VSS) capacitor c=5.09228e-18
    ciVSS_2 (VSS_67 VSS) capacitor c=5.8958e-18
    ciVSS_1 (VSS_68 VSS) capacitor c=2.52589e-18
    ciVSS_0 (VSS_71 VSS) capacitor c=1.96647e-18
    ciI_54 (I_82 VSS) capacitor c=2.22299e-18
    ciI_53 (I_88 VSS) capacitor c=1.79206e-16
    ciI_52 (I_93 VSS) capacitor c=2.22299e-18
    ciI_51 (I_96 VSS) capacitor c=5.64065e-16
    ciI_50 (I_98 VSS) capacitor c=2.23768e-17
    ciI_49 (I_106 VSS) capacitor c=2.07274e-17
    ciI_48 (I_114 VSS) capacitor c=1.4283e-17
    ciI_47 (I_122 VSS) capacitor c=1.51948e-17
    ciI_46 (I_130 VSS) capacitor c=4.21073e-18
    ciI_45 (I_153 VSS) capacitor c=4.28147e-18
    ciI_44 (I_158 VSS) capacitor c=3.00043e-18
    ciI_43 (I_164 VSS) capacitor c=2.39255e-16
    ciI_42 (I_175 VSS) capacitor c=7.63187e-16
    ciI_41 (I_181 VSS) capacitor c=3.00043e-18
    ciI_40 (I_186 VSS) capacitor c=2.2416e-17
    ciI_39 (I_194 VSS) capacitor c=1.94843e-17
    ciI_38 (I_202 VSS) capacitor c=1.30398e-17
    ciI_37 (I_210 VSS) capacitor c=1.51948e-17
    ciI_36 (I_218 VSS) capacitor c=3.00043e-18
    ciI_35 (I_221 VSS) capacitor c=4.29514e-19
    ciI_34 (I_226 VSS) capacitor c=4.29514e-19
    ciI_33 (I_229 VSS) capacitor c=3.00043e-18
    ciI_32 (I_234 VSS) capacitor c=3.00043e-18
    ciI_31 (I_237 VSS) capacitor c=4.29514e-19
    ciI_30 (I_240 VSS) capacitor c=2.38308e-16
    ciI_29 (I_242 VSS) capacitor c=4.29514e-19
    ciI_28 (I_245 VSS) capacitor c=3.00043e-18
    ciI_27 (I_248 VSS) capacitor c=7.62179e-16
    ciI_26 (I_250 VSS) capacitor c=2.2416e-17
    ciI_25 (I_258 VSS) capacitor c=1.954e-17
    ciI_24 (I_266 VSS) capacitor c=1.32071e-17
    ciI_23 (I_274 VSS) capacitor c=1.51948e-17
    ciI_22 (I_282 VSS) capacitor c=3.00043e-18
    ciI_21 (I_305 VSS) capacitor c=3.00043e-18
    ciI_20 (I_310 VSS) capacitor c=4.28147e-18
    ciI_19 (I_316 VSS) capacitor c=1.80006e-16
    ciI_18 (I_327 VSS) capacitor c=5.67161e-16
    ciI_17 (I_333 VSS) capacitor c=4.28147e-18
    ciI_16 (I_338 VSS) capacitor c=2.23559e-17
    ciI_15 (I_346 VSS) capacitor c=2.22432e-17
    ciI_14 (I_354 VSS) capacitor c=1.37545e-17
    ciI_13 (I_362 VSS) capacitor c=1.51948e-17
    ciI_12 (I_370 VSS) capacitor c=2.11871e-18
    ciI_11 (I_373 VSS) capacitor c=3.9912e-18
    ciI_10 (I_378 VSS) capacitor c=4.02575e-18
    ciI_9 (I_381 VSS) capacitor c=2.22299e-18
    ciI_8 (I VSS) capacitor c=4.42625e-17
    ciI_7 (I_642 VSS) capacitor c=2.64243e-17
    ciI_6 (I_662 VSS) capacitor c=7.69783e-17
    ciI_5 (I_714 VSS) capacitor c=3.25377e-17
    ciI_4 (I_756 VSS) capacitor c=2.70107e-17
    ciI_3 (I_757 VSS) capacitor c=2.80174e-18
    ciI_2 (I_762 VSS) capacitor c=4.96739e-18
    ciI_1 (I_775 VSS) capacitor c=4.96739e-18
    ciI_0 (I_780 VSS) capacitor c=1.50721e-17
    rZN_114 (ZN_1 ZN_3) resistor r=0.436874
    rZN_113 (ZN_1 ZN_18) resistor r=0.0960643
    rZN_112 (ZN_3 ZN_4) resistor r=13
    rZN_111 (ZN_4 MM3_ELT_d) resistor r=8.44
    rZN_110 (ZN_6 ZN_8) resistor r=0.522118
    rZN_109 (ZN_6 ZN_20) resistor r=0.0960643
    rZN_108 (ZN_8 ZN_9) resistor r=8.66667
    rZN_107 (ZN_8 ZN_11) resistor r=0.639328
    rZN_106 (ZN_9 MM5_ELT_d) resistor r=32.3614
    rZN_105 (ZN_11 ZN_12) resistor r=8.66667
    rZN_104 (ZN_11 ZN_14) resistor r=0.426218
    rZN_103 (ZN_12 MM5_ELT_d) resistor r=16.1807
    rZN_102 (ZN_12 ZN_15) resistor r=32.3614
    rZN_101 (ZN_14 ZN_15) resistor r=26
    rZN_100 (ZN_17 ZN_18) resistor r=0.0926881
    rZN_99 (ZN_17 ZN_21) resistor r=0.0960643
    rZN_98 (ZN_19 ZN_20) resistor r=0.0926881
    rZN_97 (ZN_19 ZN_24) resistor r=0.0960643
    rZN_96 (ZN_21 ZN_22) resistor r=0.165855
    rZN_95 (ZN_22 ZN_85) resistor r=0.0728045
    rZN_94 (ZN_23 ZN_24) resistor r=0.165855
    rZN_93 (ZN_23 ZN_85) resistor r=0.0728045
    rZN_92 (ZN_25 ZN_26) resistor r=0.239038
    rZN_91 (ZN_25 ZN_86) resistor r=0.0429835
    rZN_90 (ZN_26 ZN_85) resistor r=0.0189206
    rZN_89 (ZN_27 ZN_29) resistor r=0.73701
    rZN_88 (ZN_27 ZN_86) resistor r=0.0429835
    rZN_87 (ZN_29 ZN_30) resistor r=13
    rZN_86 (ZN_30 MM2_ELT_d) resistor r=8.44
    rZN_85 (ZN_32 ZN_34) resistor r=0.830599
    rZN_84 (ZN_32 ZN_86) resistor r=0.0429835
    rZN_83 (ZN_34 ZN_35) resistor r=8.66667
    rZN_82 (ZN_34 ZN_37) resistor r=0.701915
    rZN_81 (ZN_35 MM4_ELT_d) resistor r=32.3614
    rZN_80 (ZN_37 ZN_38) resistor r=8.66667
    rZN_79 (ZN_37 ZN_40) resistor r=0.467943
    rZN_78 (ZN_38 MM4_ELT_d) resistor r=16.1807
    rZN_77 (ZN_38 ZN_41) resistor r=32.3614
    rZN_76 (ZN_40 ZN_41) resistor r=26
    rZN_75 (ZN_43 ZN_44) resistor r=0.419535
    rZN_74 (ZN_43 ZN_87) resistor r=0.0429835
    rZN_73 (ZN_44 ZN_86) resistor r=0.0429835
    rZN_72 (ZN_45 ZN_47) resistor r=0.73701
    rZN_71 (ZN_45 ZN_87) resistor r=0.0429835
    rZN_70 (ZN_47 ZN_48) resistor r=13
    rZN_69 (ZN_48 MM0_ELT_d) resistor r=8.44
    rZN_68 (ZN_50 ZN_52) resistor r=0.830599
    rZN_67 (ZN_50 ZN_87) resistor r=0.0429835
    rZN_66 (ZN_52 ZN_53) resistor r=8.66667
    rZN_65 (ZN_52 ZN_55) resistor r=0.701915
    rZN_64 (ZN_53 MM6_ELT_d) resistor r=32.3614
    rZN_63 (ZN_55 ZN_56) resistor r=8.66667
    rZN_62 (ZN_55 ZN_58) resistor r=0.467943
    rZN_61 (ZN_56 MM6_ELT_d) resistor r=16.1807
    rZN_60 (ZN_56 ZN_59) resistor r=32.3614
    rZN_59 (ZN_58 ZN_59) resistor r=26
    rZN_58 (ZN_61 ZN_62) resistor r=0.552153
    rZN_57 (ZN_61 ZN_96) resistor r=0.0189206
    rZN_56 (ZN_62 ZN_87) resistor r=0.0429835
    rZN_55 (ZN_63 ZN_65) resistor r=0.303681
    rZN_54 (ZN_63 ZN_88) resistor r=0.0100975
    rZN_53 (ZN_65 ZN_66) resistor r=13
    rZN_52 (ZN_66 MM7_ELT_d) resistor r=8.44
    rZN_51 (ZN_68 ZN_70) resistor r=0.340975
    rZN_50 (ZN_68 ZN_92) resistor r=0.0100975
    rZN_49 (ZN_70 ZN_71) resistor r=8.66667
    rZN_48 (ZN_70 ZN_73) resistor r=0.639328
    rZN_47 (ZN_71 MM1_ELT_d) resistor r=32.3614
    rZN_46 (ZN_73 ZN_74) resistor r=8.66667
    rZN_45 (ZN_73 ZN_76) resistor r=0.426218
    rZN_44 (ZN_74 MM1_ELT_d) resistor r=16.1807
    rZN_43 (ZN_74 ZN_77) resistor r=32.3614
    rZN_42 (ZN_76 ZN_77) resistor r=26
    rZN_41 (ZN_79 ZN) resistor r=0.156106
    rZN_40 (ZN_79 ZN_90) resistor r=0.0100975
    rZN_39 (ZN_80 ZN) resistor r=0.0926881
    rZN_38 (ZN_80 ZN_96) resistor r=0.0728045
    rZN_37 (ZN_83 ZN_84) resistor r=0.292699
    rZN_36 (ZN_83 ZN_96) resistor r=0.0728045
    rZN_35 (ZN_84 ZN_94) resistor r=0.0100975
    rZN_34 (ZN_88 ZN_90) resistor r=0.128178
    rZN_33 (ZN_92 ZN_94) resistor r=0.126836
    rVDD_125 (MM4_ELT_b MM5_ELT_b) resistor r=0.01
    rVDD_124 (MM6_ELT_b MM5_ELT_b) resistor r=0.01
    rVDD_123 (MM1_ELT_b MM5_ELT_b) resistor r=0.01
    rVDD_122 (MM5_ELT_b VDD_39) resistor r=8.66667
    rVDD_121 (MM5_ELT_b VDD_54) resistor r=8.66667
    rVDD_120 (MM5_ELT_b VDD_24) resistor r=33.76
    rVDD_119 (VDD_2 VDD_7) resistor r=0.114612
    rVDD_118 (VDD_2 VDD_57) resistor r=0.0221503
    rVDD_117 (VDD VDD_7) resistor r=0.102756
    rVDD_116 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_115 (VDD_8 VDD_24) resistor r=67.52
    rVDD_114 (VDD_9 VDD_18) resistor r=0.415299
    rVDD_113 (VDD_9 VDD_57) resistor r=0.0882099
    rVDD_112 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_111 (VDD_11 VDD_15) resistor r=0.701915
    rVDD_110 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_109 (VDD_15 VDD_18) resistor r=0.701915
    rVDD_108 (VDD_18 VDD_19) resistor r=8.66667
    rVDD_107 (VDD_19 MM4_ELT_s) resistor r=0.850556
    rVDD_106 (VDD_19 MM5_ELT_s) resistor r=0.850556
    rVDD_105 (VDD_19 VDD_92) resistor r=13.0961
    rVDD_104 (VDD_20 VDD_23) resistor r=0.082995
    rVDD_103 (VDD_20 VDD_58) resistor r=0.0221503
    rVDD_102 (VDD_21 VDD_23) resistor r=0.0869472
    rVDD_101 (VDD_21 VDD_57) resistor r=0.0221503
    rVDD_100 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_99 (VDD_25 VDD_34) resistor r=0.415299
    rVDD_98 (VDD_25 VDD_58) resistor r=0.0882099
    rVDD_97 (VDD_27 VDD_35) resistor r=8.66667
    rVDD_96 (VDD_27 VDD_31) resistor r=0.701915
    rVDD_95 (VDD_31 VDD_35) resistor r=8.66667
    rVDD_94 (VDD_31 VDD_34) resistor r=0.701915
    rVDD_93 (VDD_34 VDD_35) resistor r=8.66667
    rVDD_92 (VDD_35 MM6_ELT_s) resistor r=4.04518
    rVDD_91 (VDD_35 VDD_96) resistor r=4.04518
    rVDD_90 (VDD_35 MM4_ELT_s) resistor r=4.04518
    rVDD_89 (VDD_35 VDD_94) resistor r=4.04518
    rVDD_88 (VDD_36 VDD_39) resistor r=0.0513779
    rVDD_87 (VDD_36 VDD_59) resistor r=0.0221503
    rVDD_86 (VDD_37 VDD_39) resistor r=0.118564
    rVDD_85 (VDD_37 VDD_58) resistor r=0.0221503
    rVDD_84 (VDD_41 VDD_50) resistor r=0.415299
    rVDD_83 (VDD_41 VDD_59) resistor r=0.0882099
    rVDD_82 (VDD_43 VDD_51) resistor r=8.66667
    rVDD_81 (VDD_43 VDD_47) resistor r=0.701915
    rVDD_80 (VDD_47 VDD_51) resistor r=8.66667
    rVDD_79 (VDD_47 VDD_50) resistor r=0.701915
    rVDD_78 (VDD_50 VDD_51) resistor r=8.66667
    rVDD_77 (VDD_51 MM1_ELT_s) resistor r=0.850556
    rVDD_76 (VDD_51 MM6_ELT_s) resistor r=0.850556
    rVDD_75 (VDD_51 VDD_98) resistor r=13.0961
    rVDD_74 (VDD_52 VDD_54) resistor r=0.150182
    rVDD_73 (VDD_52 VDD_59) resistor r=0.0221503
    rVDD_72 (VDD_62 VDD_65) resistor r=31.2341
    rVDD_71 (VDD_62 VDD_66) resistor r=9.04595
    rVDD_70 (VDD_63 VDD_65) resistor r=31.2341
    rVDD_69 (VDD_63 VDD_69) resistor r=9.04062
    rVDD_68 (MM5_ELT_s VDD_65) resistor r=6.12113
    rVDD_67 (MM5_ELT_s VDD_67) resistor r=12.3172
    rVDD_66 (MM5_ELT_s VDD_67) resistor r=1.62887
    rVDD_65 (MM5_ELT_s VDD_70) resistor r=2.55965
    rVDD_64 (VDD_66 VDD_67) resistor r=12.3172
    rVDD_63 (VDD_68 VDD_70) resistor r=14.4784
    rVDD_62 (VDD_68 VDD_93) resistor r=10.5593
    rVDD_61 (VDD_69 VDD_70) resistor r=14.4784
    rVDD_60 (MM4_ELT_s VDD_74) resistor r=2.55965
    rVDD_59 (MM4_ELT_s VDD_76) resistor r=12.3172
    rVDD_58 (MM4_ELT_s VDD_76) resistor r=1.62887
    rVDD_57 (VDD_72 VDD_74) resistor r=14.4784
    rVDD_56 (VDD_72 VDD_97) resistor r=10.5593
    rVDD_55 (VDD_73 VDD_74) resistor r=14.4784
    rVDD_54 (VDD_73 VDD_93) resistor r=10.5593
    rVDD_53 (VDD_75 VDD_76) resistor r=12.3172
    rVDD_52 (VDD_75 VDD_95) resistor r=10.2363
    rVDD_51 (MM6_ELT_s VDD_79) resistor r=12.3172
    rVDD_50 (MM6_ELT_s VDD_79) resistor r=1.62887
    rVDD_49 (MM6_ELT_s VDD_82) resistor r=2.55965
    rVDD_48 (VDD_78 VDD_79) resistor r=12.3172
    rVDD_47 (VDD_78 VDD_95) resistor r=10.2363
    rVDD_46 (VDD_80 VDD_82) resistor r=14.4784
    rVDD_45 (VDD_80 VDD_99) resistor r=10.5593
    rVDD_44 (VDD_81 VDD_82) resistor r=14.4784
    rVDD_43 (VDD_81 VDD_97) resistor r=10.5593
    rVDD_42 (MM1_ELT_s VDD_86) resistor r=2.55965
    rVDD_41 (MM1_ELT_s VDD_88) resistor r=12.3172
    rVDD_40 (MM1_ELT_s VDD_88) resistor r=1.62887
    rVDD_39 (MM1_ELT_s VDD_91) resistor r=6.12113
    rVDD_38 (VDD_84 VDD_86) resistor r=14.4784
    rVDD_37 (VDD_84 VDD_90) resistor r=9.04062
    rVDD_36 (VDD_85 VDD_86) resistor r=14.4784
    rVDD_35 (VDD_85 VDD_99) resistor r=10.5593
    rVDD_34 (VDD_87 VDD_88) resistor r=12.3172
    rVDD_33 (VDD_87 VDD_89) resistor r=9.04595
    rVDD_32 (VDD_89 VDD_91) resistor r=31.2341
    rVDD_31 (VDD_90 VDD_91) resistor r=31.2341
    rVDD_30 (VDD_92 VDD_93) resistor r=0.730683
    rVDD_29 (VDD_94 VDD_95) resistor r=0.549089
    rVDD_28 (VDD_96 VDD_97) resistor r=0.730683
    rVDD_27 (VDD_98 VDD_99) resistor r=0.730683
    rVSS_105 (MM2_ELT_b MM3_ELT_b) resistor r=0.01
    rVSS_104 (MM0_ELT_b MM3_ELT_b) resistor r=0.01
    rVSS_103 (MM7_ELT_b MM3_ELT_b) resistor r=0.01
    rVSS_102 (MM3_ELT_b VSS_27) resistor r=8.66667
    rVSS_101 (MM3_ELT_b VSS_36) resistor r=8.66667
    rVSS_100 (MM3_ELT_b VSS_18) resistor r=32.3614
    rVSS_99 (VSS_2 VSS_7) resistor r=0.114612
    rVSS_98 (VSS_2 VSS_39) resistor r=0.0221503
    rVSS_97 (VSS VSS_7) resistor r=0.10078
    rVSS_96 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_95 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_94 (VSS_9 VSS_11) resistor r=0.444546
    rVSS_93 (VSS_9 VSS_39) resistor r=0.0882099
    rVSS_92 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_91 (VSS_12 MM2_ELT_s) resistor r=2.27123
    rVSS_90 (VSS_12 MM3_ELT_s) resistor r=2.27123
    rVSS_89 (VSS_12 VSS_72) resistor r=8.4738
    rVSS_88 (VSS_14 VSS_17) resistor r=0.082995
    rVSS_87 (VSS_14 VSS_40) resistor r=0.0221503
    rVSS_86 (VSS_15 VSS_17) resistor r=0.0869472
    rVSS_85 (VSS_15 VSS_39) resistor r=0.0221503
    rVSS_84 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_83 (VSS_19 VSS_21) resistor r=0.444546
    rVSS_82 (VSS_19 VSS_40) resistor r=0.0882099
    rVSS_81 (VSS_21 VSS_22) resistor r=8.66667
    rVSS_80 (VSS_22 MM0_ELT_s) resistor r=4.22001
    rVSS_79 (VSS_22 VSS_76) resistor r=4.22001
    rVSS_78 (VSS_22 MM2_ELT_s) resistor r=4.22001
    rVSS_77 (VSS_22 VSS_74) resistor r=4.22001
    rVSS_76 (VSS_24 VSS_27) resistor r=0.0513779
    rVSS_75 (VSS_24 VSS_41) resistor r=0.0221503
    rVSS_74 (VSS_25 VSS_27) resistor r=0.118564
    rVSS_73 (VSS_25 VSS_40) resistor r=0.0221503
    rVSS_72 (VSS_29 VSS_31) resistor r=0.444546
    rVSS_71 (VSS_29 VSS_41) resistor r=0.0882099
    rVSS_70 (VSS_31 VSS_32) resistor r=8.66667
    rVSS_69 (VSS_32 MM7_ELT_s) resistor r=2.27123
    rVSS_68 (VSS_32 MM0_ELT_s) resistor r=2.27123
    rVSS_67 (VSS_32 VSS_78) resistor r=8.4738
    rVSS_66 (VSS_34 VSS_36) resistor r=0.150182
    rVSS_65 (VSS_34 VSS_41) resistor r=0.0221503
    rVSS_64 (VSS_42 VSS_45) resistor r=21.1301
    rVSS_63 (VSS_42 VSS_47) resistor r=9.43134
    rVSS_62 (VSS_43 VSS_45) resistor r=21.1301
    rVSS_61 (VSS_43 VSS_49) resistor r=9.4369
    rVSS_60 (MM3_ELT_s VSS_45) resistor r=4.557
    rVSS_59 (MM3_ELT_s VSS_48) resistor r=2.67027
    rVSS_58 (MM3_ELT_s VSS_50) resistor r=12.8495
    rVSS_57 (MM3_ELT_s VSS_50) resistor r=1.69926
    rVSS_56 (VSS_46 VSS_48) resistor r=15.1041
    rVSS_55 (VSS_46 VSS_73) resistor r=11.0157
    rVSS_54 (VSS_47 VSS_48) resistor r=15.1041
    rVSS_53 (VSS_49 VSS_50) resistor r=12.8495
    rVSS_52 (MM2_ELT_s VSS_54) resistor r=2.67027
    rVSS_51 (MM2_ELT_s VSS_56) resistor r=12.8495
    rVSS_50 (MM2_ELT_s VSS_56) resistor r=1.69926
    rVSS_49 (VSS_52 VSS_54) resistor r=15.1041
    rVSS_48 (VSS_52 VSS_75) resistor r=11.0157
    rVSS_47 (VSS_53 VSS_54) resistor r=15.1041
    rVSS_46 (VSS_53 VSS_73) resistor r=11.0157
    rVSS_45 (VSS_55 VSS_56) resistor r=12.8495
    rVSS_44 (VSS_55 VSS_77) resistor r=10.6787
    rVSS_43 (MM0_ELT_s VSS_60) resistor r=2.67027
    rVSS_42 (MM0_ELT_s VSS_62) resistor r=12.8495
    rVSS_41 (MM0_ELT_s VSS_62) resistor r=1.69926
    rVSS_40 (VSS_58 VSS_60) resistor r=15.1041
    rVSS_39 (VSS_58 VSS_79) resistor r=11.0157
    rVSS_38 (VSS_59 VSS_60) resistor r=15.1041
    rVSS_37 (VSS_59 VSS_75) resistor r=11.0157
    rVSS_36 (VSS_61 VSS_62) resistor r=12.8495
    rVSS_35 (VSS_61 VSS_77) resistor r=10.6787
    rVSS_34 (MM7_ELT_s VSS_66) resistor r=2.67027
    rVSS_33 (MM7_ELT_s VSS_68) resistor r=12.8495
    rVSS_32 (MM7_ELT_s VSS_68) resistor r=1.69926
    rVSS_31 (MM7_ELT_s VSS_71) resistor r=4.557
    rVSS_30 (VSS_64 VSS_66) resistor r=15.1041
    rVSS_29 (VSS_64 VSS_69) resistor r=9.43134
    rVSS_28 (VSS_65 VSS_66) resistor r=15.1041
    rVSS_27 (VSS_65 VSS_79) resistor r=11.0157
    rVSS_26 (VSS_67 VSS_68) resistor r=12.8495
    rVSS_25 (VSS_67 VSS_70) resistor r=9.4369
    rVSS_24 (VSS_69 VSS_71) resistor r=21.1301
    rVSS_23 (VSS_70 VSS_71) resistor r=21.1301
    rVSS_22 (VSS_72 VSS_73) resistor r=0.762262
    rVSS_21 (VSS_74 VSS_75) resistor r=0.762262
    rVSS_20 (VSS_76 VSS_77) resistor r=0.57282
    rVSS_19 (VSS_78 VSS_79) resistor r=0.762262
    rI_379 (I_82 I_88) resistor r=58.3583
    rI_378 (I_82 I_88) resistor r=4.16253
    rI_377 (I_82 I_88) resistor r=58.3583
    rI_376 (I_82 I_88) resistor r=4.16253
    rI_375 (I_85 I_88) resistor r=58.3583
    rI_374 (I_85 I_88) resistor r=4.16253
    rI_373 (I_85 I_88) resistor r=58.3583
    rI_372 (I_85 I_88) resistor r=4.16253
    rI_371 (I_88 I_101) resistor r=24.8333
    rI_370 (I_88 I_98) resistor r=24.8333
    rI_369 (I_88 I_109) resistor r=24.8333
    rI_368 (I_88 I_106) resistor r=24.8333
    rI_367 (I_88 I_130) resistor r=58.3583
    rI_366 (I_88 I_133) resistor r=58.3583
    rI_365 (I_88 I_138) resistor r=14.9
    rI_364 (I_88 I_101) resistor r=4.16253
    rI_363 (I_88 I_109) resistor r=4.16253
    rI_362 (I_88 I_98) resistor r=4.16253
    rI_361 (I_88 I_130) resistor r=4.16253
    rI_360 (I_88 I_138) resistor r=6.30933
    rI_359 (I_88 I_133) resistor r=6.30933
    rI_358 (I_88 I_106) resistor r=1.63969
    rI_357 (I_88 I_101) resistor r=24.8333
    rI_356 (I_88 I_98) resistor r=24.8333
    rI_355 (I_88 I_109) resistor r=24.8333
    rI_354 (I_88 I_106) resistor r=24.8333
    rI_353 (I_88 I_130) resistor r=58.3583
    rI_352 (I_88 MM3_ELT_g) resistor r=22.35
    rI_351 (I_88 I_138) resistor r=14.9
    rI_350 (I_88 I_632) resistor r=40.975
    rI_349 (I_88 I_101) resistor r=4.16253
    rI_348 (I_88 I_109) resistor r=4.16253
    rI_347 (I_88 I_98) resistor r=4.16253
    rI_346 (I_88 I_130) resistor r=4.16253
    rI_345 (I_88 I_138) resistor r=6.30933
    rI_344 (I_88 I_133) resistor r=6.30933
    rI_343 (I_88 I_106) resistor r=1.63969
    rI_342 (I_90 I_96) resistor r=202.392
    rI_341 (I_90 I_96) resistor r=4.16253
    rI_340 (I_90 I_96) resistor r=202.392
    rI_339 (I_90 I_96) resistor r=4.16253
    rI_338 (I_93 I_96) resistor r=202.392
    rI_337 (I_93 I_96) resistor r=4.16253
    rI_336 (I_93 I_96) resistor r=202.392
    rI_335 (I_93 I_96) resistor r=4.16253
    rI_334 (I_96 I_117) resistor r=24.8333
    rI_333 (I_96 I_114) resistor r=24.8333
    rI_332 (I_96 I_125) resistor r=24.8333
    rI_331 (I_96 I_122) resistor r=24.8333
    rI_330 (I_96 I_144) resistor r=14.9
    rI_329 (I_96 I_150) resistor r=202.392
    rI_328 (I_96 I_153) resistor r=202.392
    rI_327 (I_96 I_117) resistor r=4.16253
    rI_326 (I_96 I_125) resistor r=4.16253
    rI_325 (I_96 I_150) resistor r=6.30933
    rI_324 (I_96 I_144) resistor r=6.30933
    rI_323 (I_96 I_114) resistor r=1.63969
    rI_322 (I_96 I_122) resistor r=4.16253
    rI_321 (I_96 I_153) resistor r=4.16253
    rI_320 (I_96 I_117) resistor r=24.8333
    rI_319 (I_96 I_114) resistor r=24.8333
    rI_318 (I_96 I_125) resistor r=24.8333
    rI_317 (I_96 I_122) resistor r=24.8333
    rI_316 (I_96 I_634) resistor r=40.975
    rI_315 (I_96 I_144) resistor r=14.9
    rI_314 (I_96 I_150) resistor r=202.392
    rI_313 (I_96 MM5_ELT_g) resistor r=7.45
    rI_312 (I_96 I_117) resistor r=4.16253
    rI_311 (I_96 I_125) resistor r=4.16253
    rI_310 (I_96 I_150) resistor r=6.30933
    rI_309 (I_96 I_144) resistor r=6.30933
    rI_308 (I_96 I_114) resistor r=1.63969
    rI_307 (I_96 I_122) resistor r=4.16253
    rI_306 (I_96 I_153) resistor r=4.16253
    rI_305 (I_133 MM3_ELT_g) resistor r=36.0083
    rI_304 (I_153 MM5_ELT_g) resistor r=194.942
    rI_303 (I_158 I_164) resistor r=58.3583
    rI_302 (I_158 I_164) resistor r=4.16253
    rI_301 (I_158 I_164) resistor r=58.3583
    rI_300 (I_158 I_164) resistor r=4.16253
    rI_299 (I_161 I_164) resistor r=58.3583
    rI_298 (I_161 I_164) resistor r=6.30933
    rI_297 (I_161 I_164) resistor r=58.3583
    rI_296 (I_161 I_164) resistor r=6.30933
    rI_295 (I_164 I_166) resistor r=14.9
    rI_294 (I_164 I_189) resistor r=24.8333
    rI_293 (I_164 I_186) resistor r=24.8333
    rI_292 (I_164 I_197) resistor r=24.8333
    rI_291 (I_164 I_194) resistor r=24.8333
    rI_290 (I_164 I_218) resistor r=58.3583
    rI_289 (I_164 I_221) resistor r=58.3583
    rI_288 (I_164 I_189) resistor r=4.16253
    rI_287 (I_164 I_166) resistor r=6.30933
    rI_286 (I_164 I_197) resistor r=1.63969
    rI_285 (I_164 I_186) resistor r=4.16253
    rI_284 (I_164 I_218) resistor r=4.16253
    rI_283 (I_164 I_194) resistor r=4.16253
    rI_282 (I_164 I_221) resistor r=4.16253
    rI_281 (I_164 I_166) resistor r=14.9
    rI_280 (I_164 I_648) resistor r=40.975
    rI_279 (I_164 I_189) resistor r=24.8333
    rI_278 (I_164 I_186) resistor r=24.8333
    rI_277 (I_164 I_197) resistor r=24.8333
    rI_276 (I_164 I_194) resistor r=24.8333
    rI_275 (I_164 I_218) resistor r=58.3583
    rI_274 (I_164 MM2_ELT_g) resistor r=7.45
    rI_273 (I_164 I_189) resistor r=4.16253
    rI_272 (I_164 I_166) resistor r=6.30933
    rI_271 (I_164 I_197) resistor r=1.63969
    rI_270 (I_164 I_186) resistor r=4.16253
    rI_269 (I_164 I_218) resistor r=4.16253
    rI_268 (I_164 I_194) resistor r=4.16253
    rI_267 (I_164 I_221) resistor r=4.16253
    rI_266 (I_172 I_175) resistor r=14.9
    rI_265 (I_172 I_175) resistor r=6.30933
    rI_264 (I_172 I_175) resistor r=14.9
    rI_263 (I_172 I_175) resistor r=6.30933
    rI_262 (I_175 I_178) resistor r=202.392
    rI_261 (I_175 I_181) resistor r=202.392
    rI_260 (I_175 I_205) resistor r=24.8333
    rI_259 (I_175 I_202) resistor r=24.8333
    rI_258 (I_175 I_213) resistor r=24.8333
    rI_257 (I_175 I_210) resistor r=24.8333
    rI_256 (I_175 I_226) resistor r=202.392
    rI_255 (I_175 I_229) resistor r=202.392
    rI_254 (I_175 I_178) resistor r=6.30933
    rI_253 (I_175 I_205) resistor r=1.63969
    rI_252 (I_175 I_213) resistor r=4.16253
    rI_251 (I_175 I_181) resistor r=4.16253
    rI_250 (I_175 I_202) resistor r=4.16253
    rI_249 (I_175 I_226) resistor r=4.16253
    rI_248 (I_175 I_210) resistor r=4.16253
    rI_247 (I_175 I_229) resistor r=4.16253
    rI_246 (I_175 I_650) resistor r=40.975
    rI_245 (I_175 I_178) resistor r=202.392
    rI_244 (I_175 I_181) resistor r=202.392
    rI_243 (I_175 I_205) resistor r=24.8333
    rI_242 (I_175 I_202) resistor r=24.8333
    rI_241 (I_175 I_213) resistor r=24.8333
    rI_240 (I_175 I_210) resistor r=24.8333
    rI_239 (I_175 I_226) resistor r=202.392
    rI_238 (I_175 MM4_ELT_g) resistor r=7.45
    rI_237 (I_175 I_178) resistor r=6.30933
    rI_236 (I_175 I_205) resistor r=1.63969
    rI_235 (I_175 I_213) resistor r=4.16253
    rI_234 (I_175 I_181) resistor r=4.16253
    rI_233 (I_175 I_202) resistor r=4.16253
    rI_232 (I_175 I_226) resistor r=4.16253
    rI_231 (I_175 I_210) resistor r=4.16253
    rI_230 (I_175 I_229) resistor r=4.16253
    rI_229 (I_221 MM2_ELT_g) resistor r=50.9083
    rI_228 (I_229 MM4_ELT_g) resistor r=194.942
    rI_227 (I_234 I_240) resistor r=58.3583
    rI_226 (I_234 I_240) resistor r=4.16253
    rI_225 (I_234 I_240) resistor r=58.3583
    rI_224 (I_234 I_240) resistor r=4.16253
    rI_223 (I_237 I_240) resistor r=58.3583
    rI_222 (I_237 I_240) resistor r=4.16253
    rI_221 (I_237 I_240) resistor r=58.3583
    rI_220 (I_237 I_240) resistor r=4.16253
    rI_219 (I_240 I_253) resistor r=24.8333
    rI_218 (I_240 I_250) resistor r=24.8333
    rI_217 (I_240 I_261) resistor r=24.8333
    rI_216 (I_240 I_258) resistor r=24.8333
    rI_215 (I_240 I_282) resistor r=58.3583
    rI_214 (I_240 I_285) resistor r=58.3583
    rI_213 (I_240 I_290) resistor r=14.9
    rI_212 (I_240 I_253) resistor r=4.16253
    rI_211 (I_240 I_261) resistor r=4.16253
    rI_210 (I_240 I_250) resistor r=4.16253
    rI_209 (I_240 I_282) resistor r=4.16253
    rI_208 (I_240 I_290) resistor r=6.30933
    rI_207 (I_240 I_285) resistor r=6.30933
    rI_206 (I_240 I_258) resistor r=1.63969
    rI_205 (I_240 I_253) resistor r=24.8333
    rI_204 (I_240 I_250) resistor r=24.8333
    rI_203 (I_240 I_261) resistor r=24.8333
    rI_202 (I_240 I_258) resistor r=24.8333
    rI_201 (I_240 I_282) resistor r=58.3583
    rI_200 (I_240 MM0_ELT_g) resistor r=22.35
    rI_199 (I_240 I_290) resistor r=14.9
    rI_198 (I_240 I_704) resistor r=40.975
    rI_197 (I_240 I_253) resistor r=4.16253
    rI_196 (I_240 I_261) resistor r=4.16253
    rI_195 (I_240 I_250) resistor r=4.16253
    rI_194 (I_240 I_282) resistor r=4.16253
    rI_193 (I_240 I_290) resistor r=6.30933
    rI_192 (I_240 I_285) resistor r=6.30933
    rI_191 (I_240 I_258) resistor r=1.63969
    rI_190 (I_242 I_248) resistor r=202.392
    rI_189 (I_242 I_248) resistor r=4.16253
    rI_188 (I_242 I_248) resistor r=202.392
    rI_187 (I_242 I_248) resistor r=4.16253
    rI_186 (I_245 I_248) resistor r=202.392
    rI_185 (I_245 I_248) resistor r=4.16253
    rI_184 (I_245 I_248) resistor r=202.392
    rI_183 (I_245 I_248) resistor r=4.16253
    rI_182 (I_248 I_269) resistor r=24.8333
    rI_181 (I_248 I_266) resistor r=24.8333
    rI_180 (I_248 I_277) resistor r=24.8333
    rI_179 (I_248 I_274) resistor r=24.8333
    rI_178 (I_248 I_296) resistor r=14.9
    rI_177 (I_248 I_302) resistor r=202.392
    rI_176 (I_248 I_305) resistor r=202.392
    rI_175 (I_248 I_269) resistor r=4.16253
    rI_174 (I_248 I_277) resistor r=4.16253
    rI_173 (I_248 I_302) resistor r=6.30933
    rI_172 (I_248 I_296) resistor r=6.30933
    rI_171 (I_248 I_266) resistor r=1.63969
    rI_170 (I_248 I_274) resistor r=4.16253
    rI_169 (I_248 I_305) resistor r=4.16253
    rI_168 (I_248 I_269) resistor r=24.8333
    rI_167 (I_248 I_266) resistor r=24.8333
    rI_166 (I_248 I_277) resistor r=24.8333
    rI_165 (I_248 I_274) resistor r=24.8333
    rI_164 (I_248 I_706) resistor r=40.975
    rI_163 (I_248 I_296) resistor r=14.9
    rI_162 (I_248 I_302) resistor r=202.392
    rI_161 (I_248 MM6_ELT_g) resistor r=7.45
    rI_160 (I_248 I_269) resistor r=4.16253
    rI_159 (I_248 I_277) resistor r=4.16253
    rI_158 (I_248 I_302) resistor r=6.30933
    rI_157 (I_248 I_296) resistor r=6.30933
    rI_156 (I_248 I_266) resistor r=1.63969
    rI_155 (I_248 I_274) resistor r=4.16253
    rI_154 (I_248 I_305) resistor r=4.16253
    rI_153 (I_285 MM0_ELT_g) resistor r=36.0083
    rI_152 (I_305 MM6_ELT_g) resistor r=194.942
    rI_151 (I_310 I_316) resistor r=58.3583
    rI_150 (I_310 I_316) resistor r=4.16253
    rI_149 (I_310 I_316) resistor r=58.3583
    rI_148 (I_310 I_316) resistor r=4.16253
    rI_147 (I_313 I_316) resistor r=58.3583
    rI_146 (I_313 I_316) resistor r=6.30933
    rI_145 (I_313 I_316) resistor r=58.3583
    rI_144 (I_313 I_316) resistor r=6.30933
    rI_143 (I_316 I_318) resistor r=14.9
    rI_142 (I_316 I_341) resistor r=24.8333
    rI_141 (I_316 I_338) resistor r=24.8333
    rI_140 (I_316 I_349) resistor r=24.8333
    rI_139 (I_316 I_346) resistor r=24.8333
    rI_138 (I_316 I_370) resistor r=58.3583
    rI_137 (I_316 I_373) resistor r=58.3583
    rI_136 (I_316 I_341) resistor r=4.16253
    rI_135 (I_316 I_318) resistor r=6.30933
    rI_134 (I_316 I_349) resistor r=1.63969
    rI_133 (I_316 I_338) resistor r=4.16253
    rI_132 (I_316 I_370) resistor r=4.16253
    rI_131 (I_316 I_346) resistor r=4.16253
    rI_130 (I_316 I_373) resistor r=4.16253
    rI_129 (I_316 I_318) resistor r=14.9
    rI_128 (I_316 I_720) resistor r=40.975
    rI_127 (I_316 I_341) resistor r=24.8333
    rI_126 (I_316 I_338) resistor r=24.8333
    rI_125 (I_316 I_349) resistor r=24.8333
    rI_124 (I_316 I_346) resistor r=24.8333
    rI_123 (I_316 I_370) resistor r=58.3583
    rI_122 (I_316 MM7_ELT_g) resistor r=7.45
    rI_121 (I_316 I_341) resistor r=4.16253
    rI_120 (I_316 I_318) resistor r=6.30933
    rI_119 (I_316 I_349) resistor r=1.63969
    rI_118 (I_316 I_338) resistor r=4.16253
    rI_117 (I_316 I_370) resistor r=4.16253
    rI_116 (I_316 I_346) resistor r=4.16253
    rI_115 (I_316 I_373) resistor r=4.16253
    rI_114 (I_324 I_327) resistor r=14.9
    rI_113 (I_324 I_327) resistor r=6.30933
    rI_112 (I_324 I_327) resistor r=14.9
    rI_111 (I_324 I_327) resistor r=6.30933
    rI_110 (I_327 I_330) resistor r=202.392
    rI_109 (I_327 I_333) resistor r=202.392
    rI_108 (I_327 I_357) resistor r=24.8333
    rI_107 (I_327 I_354) resistor r=24.8333
    rI_106 (I_327 I_365) resistor r=24.8333
    rI_105 (I_327 I_362) resistor r=24.8333
    rI_104 (I_327 I_378) resistor r=202.392
    rI_103 (I_327 I_381) resistor r=202.392
    rI_102 (I_327 I_330) resistor r=6.30933
    rI_101 (I_327 I_357) resistor r=1.63969
    rI_100 (I_327 I_365) resistor r=4.16253
    rI_99 (I_327 I_333) resistor r=4.16253
    rI_98 (I_327 I_354) resistor r=4.16253
    rI_97 (I_327 I_378) resistor r=4.16253
    rI_96 (I_327 I_362) resistor r=4.16253
    rI_95 (I_327 I_381) resistor r=4.16253
    rI_94 (I_327 I_722) resistor r=40.975
    rI_93 (I_327 I_330) resistor r=202.392
    rI_92 (I_327 I_333) resistor r=202.392
    rI_91 (I_327 I_357) resistor r=24.8333
    rI_90 (I_327 I_354) resistor r=24.8333
    rI_89 (I_327 I_365) resistor r=24.8333
    rI_88 (I_327 I_362) resistor r=24.8333
    rI_87 (I_327 I_378) resistor r=202.392
    rI_86 (I_327 MM1_ELT_g) resistor r=7.45
    rI_85 (I_327 I_330) resistor r=6.30933
    rI_84 (I_327 I_357) resistor r=1.63969
    rI_83 (I_327 I_365) resistor r=4.16253
    rI_82 (I_327 I_333) resistor r=4.16253
    rI_81 (I_327 I_354) resistor r=4.16253
    rI_80 (I_327 I_378) resistor r=4.16253
    rI_79 (I_327 I_362) resistor r=4.16253
    rI_78 (I_327 I_381) resistor r=4.16253
    rI_77 (I_373 MM7_ELT_g) resistor r=50.9083
    rI_76 (I_381 MM1_ELT_g) resistor r=194.942
    rI_75 (I_522 I_523) resistor r=10
    rI_74 (I_522 I) resistor r=0.084634
    rI_73 (I_523 I_756) resistor r=41.3136
    rI_72 (I_632 I_757) resistor r=3.725
    rI_71 (I_634 I_757) resistor r=3.725
    rI_70 (I_642 I_643) resistor r=27.0909
    rI_69 (I_642 I_762) resistor r=3.725
    rI_68 (I_643 I_757) resistor r=3.725
    rI_67 (I_648 I_762) resistor r=3.725
    rI_66 (I_650 I_762) resistor r=3.725
    rI_65 (I_662 I_663) resistor r=97.5273
    rI_64 (I_662 I_775) resistor r=3.725
    rI_63 (I_663 I_762) resistor r=3.725
    rI_62 (I_704 I_775) resistor r=3.725
    rI_61 (I_706 I_775) resistor r=3.725
    rI_60 (I_714 I_715) resistor r=27.0909
    rI_59 (I_714 I_780) resistor r=0.877078
    rI_58 (I_715 I_775) resistor r=3.725
    rI_57 (I_720 I_780) resistor r=10.0997
    rI_56 (I_722 I_780) resistor r=10.0997
    rI_55 (I_756 I_757) resistor r=3.725
ends INVD4_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: NR2D1_LVT_ELT
// View name: calibre
subckt NR2D1_LVT_ELT A1 A2 VDD VSS ZN
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciVDD_6 (VDD_2 VSS) capacitor c=1.58634e-16
    ciVDD_5 (VDD_17 VSS) capacitor c=1.23404e-16
    ciVDD_4 (VDD_25 VSS) capacitor c=9.8201e-18
    ciVDD_3 (MM11_ELT_s VSS) capacitor c=3.51145e-17
    ciVDD_2 (VDD_30 VSS) capacitor c=1.77907e-16
    ciVDD_1 (VDD_32 VSS) capacitor c=1.11099e-18
    ciVDD_0 (VDD_34 VSS) capacitor c=1.07074e-18
    ciVSS_10 (VSS_2 VSS) capacitor c=6.19149e-17
    ciVSS_9 (VSS_11 VSS) capacitor c=6.11648e-17
    ciVSS_8 (VSS_14 VSS) capacitor c=7.70792e-17
    ciVSS_7 (VSS_24 VSS) capacitor c=3.726e-17
    ciVSS_6 (VSS_25 VSS) capacitor c=6.11746e-17
    ciVSS_5 (VSS_27 VSS) capacitor c=3.58509e-18
    ciVSS_4 (VSS_36 VSS) capacitor c=2.95832e-18
    ciVSS_3 (MM1_ELT_s VSS) capacitor c=5.29847e-18
    ciVSS_2 (VSS_42 VSS) capacitor c=5.77375e-18
    ciVSS_1 (VSS_43 VSS) capacitor c=1.54757e-18
    ciVSS_0 (VSS_44 VSS) capacitor c=7.27989e-17
    ciZN_12 (ZN_3 VSS) capacitor c=5.37921e-17
    ciZN_11 (ZN_4 VSS) capacitor c=1.11612e-16
    ciZN_10 (ZN_8 VSS) capacitor c=1.95801e-16
    ciZN_9 (ZN_9 VSS) capacitor c=3.22399e-16
    ciZN_8 (ZN_17 VSS) capacitor c=2.21817e-17
    ciZN_7 (ZN_18 VSS) capacitor c=1.11723e-17
    ciZN_6 (ZN_20 VSS) capacitor c=4.66117e-17
    ciZN_5 (ZN_21 VSS) capacitor c=7.20282e-17
    ciZN_4 (ZN_22 VSS) capacitor c=3.3514e-17
    ciZN_3 (ZN_25 VSS) capacitor c=5.08899e-17
    ciZN_2 (ZN_26 VSS) capacitor c=1.13003e-16
    ciZN_1 (ZN_28 VSS) capacitor c=3.45886e-17
    ciZN_0 (ZN_35 VSS) capacitor c=2.5441e-17
    cinet29_11 (net29_3 VSS) capacitor c=5.65262e-17
    cinet29_10 (net29_8 VSS) capacitor c=5.78512e-17
    cinet29_9 (net29_14 VSS) capacitor c=3.11728e-17
    cinet29_8 (net29_18 VSS) capacitor c=5.59901e-17
    cinet29_7 (net29_19 VSS) capacitor c=3.46591e-16
    cinet29_6 (net29_23 VSS) capacitor c=5.56143e-17
    cinet29_5 (net29_29 VSS) capacitor c=1.09621e-17
    cinet29_4 (net29_30 VSS) capacitor c=1.09621e-17
    cinet29_3 (net29_34 VSS) capacitor c=1.32762e-17
    cinet29_2 (net29_36 VSS) capacitor c=4.52916e-18
    cinet29_1 (net29_39 VSS) capacitor c=1.11099e-18
    cinet29_0 (net29_40 VSS) capacitor c=2.38919e-16
    ciA2_14 (A2_22 VSS) capacitor c=3.32033e-18
    ciA2_13 (A2_28 VSS) capacitor c=2.04582e-16
    ciA2_12 (A2_39 VSS) capacitor c=6.2713e-16
    ciA2_11 (A2_45 VSS) capacitor c=3.88523e-18
    ciA2_10 (A2_50 VSS) capacitor c=2.23697e-17
    ciA2_9 (A2_58 VSS) capacitor c=2.53588e-17
    ciA2_8 (A2_66 VSS) capacitor c=8.97212e-18
    ciA2_7 (A2_74 VSS) capacitor c=1.51948e-17
    ciA2_6 (A2_82 VSS) capacitor c=2.96645e-18
    ciA2_5 (A2_85 VSS) capacitor c=5.63284e-18
    ciA2_4 (A2_90 VSS) capacitor c=9.43883e-19
    ciA2_3 (A2_93 VSS) capacitor c=4.28147e-18
    ciA2_2 (A2 VSS) capacitor c=6.25653e-17
    ciA2_1 (A2_194 VSS) capacitor c=3.18954e-17
    ciA2_0 (A2_195 VSS) capacitor c=1.47327e-17
    ciA1_12 (A1_22 VSS) capacitor c=2.22299e-18
    ciA1_11 (A1_28 VSS) capacitor c=1.88095e-16
    ciA1_10 (A1_33 VSS) capacitor c=2.22299e-18
    ciA1_9 (A1_36 VSS) capacitor c=5.77724e-16
    ciA1_8 (A1_38 VSS) capacitor c=2.2416e-17
    ciA1_7 (A1_46 VSS) capacitor c=2.16891e-17
    ciA1_6 (A1_54 VSS) capacitor c=1.52944e-17
    ciA1_5 (A1_62 VSS) capacitor c=1.51948e-17
    ciA1_4 (A1_70 VSS) capacitor c=4.24886e-18
    ciA1_3 (A1_93 VSS) capacitor c=3.88523e-18
    ciA1_2 (A1 VSS) capacitor c=4.49662e-17
    ciA1_1 (A1_198 VSS) capacitor c=2.75557e-17
    ciA1_0 (A1_199 VSS) capacitor c=1.1684e-17
    rVDD_35 (MM11_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_34 (MM10_ELT_b VDD_10) resistor r=8.66667
    rVDD_33 (MM10_ELT_b VDD_13) resistor r=13
    rVDD_32 (MM10_ELT_b VDD_8) resistor r=56.2667
    rVDD_31 (VDD_2 VDD_13) resistor r=0.00987834
    rVDD_30 (VDD_2 VDD_15) resistor r=0.142297
    rVDD_29 (VDD VDD_7) resistor r=0.102735
    rVDD_28 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_27 (VDD_7 VDD_10) resistor r=0.23708
    rVDD_26 (VDD_10 VDD_13) resistor r=0.158054
    rVDD_25 (VDD_15 VDD_24) resistor r=0.378339
    rVDD_24 (VDD_17 VDD_25) resistor r=8.66667
    rVDD_23 (VDD_17 VDD_21) resistor r=0.639446
    rVDD_22 (VDD_21 VDD_25) resistor r=8.66667
    rVDD_21 (VDD_21 VDD_24) resistor r=0.639446
    rVDD_20 (VDD_24 VDD_25) resistor r=8.66667
    rVDD_19 (VDD_25 VDD_36) resistor r=27.2424
    rVDD_18 (VDD_25 VDD_35) resistor r=27.2424
    rVDD_17 (VDD_25 MM11_ELT_s) resistor r=5.66484
    rVDD_16 (MM11_ELT_s VDD_29) resistor r=25.7298
    rVDD_15 (MM11_ELT_s VDD_32) resistor r=2.55965
    rVDD_14 (MM11_ELT_s VDD_34) resistor r=12.3172
    rVDD_13 (MM11_ELT_s VDD_34) resistor r=1.62887
    rVDD_12 (VDD_29 VDD_31) resistor r=9.04062
    rVDD_11 (VDD_30 VDD_32) resistor r=14.4784
    rVDD_10 (VDD_30 VDD_36) resistor r=9.48555
    rVDD_9 (VDD_31 VDD_32) resistor r=14.4784
    rVDD_8 (VDD_33 VDD_34) resistor r=12.3172
    rVDD_7 (VDD_33 VDD_35) resistor r=9.39461
    rVSS_55 (MM1_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_54 (MM2_ELT_b VSS_17) resistor r=8.66667
    rVSS_53 (MM2_ELT_b VSS_20) resistor r=13
    rVSS_52 (MM2_ELT_b VSS_8) resistor r=53.9357
    rVSS_51 (VSS_2 VSS_7) resistor r=0.114589
    rVSS_50 (VSS_2 VSS_27) resistor r=0.0221458
    rVSS_49 (VSS VSS_7) resistor r=0.100759
    rVSS_48 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_47 (VSS_9 VSS_11) resistor r=0.404982
    rVSS_46 (VSS_9 VSS_27) resistor r=0.0882304
    rVSS_45 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_44 (VSS_12 MM2_ELT_s) resistor r=2.90692
    rVSS_43 (VSS_12 VSS_44) resistor r=12.1406
    rVSS_42 (VSS_14 VSS_20) resistor r=0.00987834
    rVSS_41 (VSS_14 VSS_22) resistor r=0.142297
    rVSS_40 (VSS_15 VSS_17) resistor r=0.0869294
    rVSS_39 (VSS_15 VSS_27) resistor r=0.0221458
    rVSS_38 (VSS_17 VSS_20) resistor r=0.158054
    rVSS_37 (VSS_22 VSS_24) resistor r=0.404982
    rVSS_36 (VSS_24 VSS_25) resistor r=8.66667
    rVSS_35 (VSS_25 VSS_46) resistor r=17.2126
    rVSS_34 (VSS_25 VSS_45) resistor r=17.2126
    rVSS_33 (VSS_25 MM1_ELT_s) resistor r=3.43331
    rVSS_32 (VSS_28 VSS_31) resistor r=21.1301
    rVSS_31 (VSS_28 VSS_33) resistor r=9.43134
    rVSS_30 (VSS_29 VSS_31) resistor r=21.1301
    rVSS_29 (VSS_29 VSS_35) resistor r=9.4369
    rVSS_28 (MM2_ELT_s VSS_31) resistor r=4.557
    rVSS_27 (MM2_ELT_s VSS_34) resistor r=2.67027
    rVSS_26 (MM2_ELT_s VSS_36) resistor r=12.8495
    rVSS_25 (MM2_ELT_s VSS_36) resistor r=1.69926
    rVSS_24 (VSS_32 VSS_34) resistor r=15.1041
    rVSS_23 (VSS_32 VSS_44) resistor r=9.89549
    rVSS_22 (VSS_33 VSS_34) resistor r=15.1041
    rVSS_21 (VSS_35 VSS_36) resistor r=12.8495
    rVSS_20 (MM1_ELT_s VSS_38) resistor r=18.0507
    rVSS_19 (MM1_ELT_s VSS_41) resistor r=2.67027
    rVSS_18 (MM1_ELT_s VSS_43) resistor r=12.8495
    rVSS_17 (MM1_ELT_s VSS_43) resistor r=1.69926
    rVSS_16 (VSS_38 VSS_40) resistor r=9.43134
    rVSS_15 (VSS_39 VSS_41) resistor r=15.1041
    rVSS_14 (VSS_39 VSS_45) resistor r=9.89549
    rVSS_13 (VSS_40 VSS_41) resistor r=15.1041
    rVSS_12 (VSS_42 VSS_43) resistor r=12.8495
    rVSS_11 (VSS_42 VSS_46) resistor r=9.80063
    rZN_39 (ZN_1 ZN_3) resistor r=0.399653
    rZN_38 (ZN_1 ZN_33) resistor r=0.1929
    rZN_37 (ZN_3 ZN_4) resistor r=13
    rZN_36 (ZN_4 MM2_ELT_d) resistor r=8.44
    rZN_35 (ZN_6 ZN_8) resistor r=0.522214
    rZN_34 (ZN_6 ZN_18) resistor r=0.096082
    rZN_33 (ZN_8 ZN_9) resistor r=8.66667
    rZN_32 (ZN_8 ZN_11) resistor r=0.639446
    rZN_31 (ZN_9 MM10_ELT_d) resistor r=32.3614
    rZN_30 (ZN_11 ZN_12) resistor r=8.66667
    rZN_29 (ZN_11 ZN_14) resistor r=0.426297
    rZN_28 (ZN_12 MM10_ELT_d) resistor r=16.1807
    rZN_27 (ZN_12 ZN_15) resistor r=32.3614
    rZN_26 (ZN_14 ZN_15) resistor r=26
    rZN_25 (ZN_17 ZN_18) resistor r=0.0927051
    rZN_24 (ZN_17 ZN_20) resistor r=0.096082
    rZN_23 (ZN_19 ZN_20) resistor r=0.506796
    rZN_22 (ZN_19 ZN_33) resistor r=0.0372822
    rZN_21 (ZN_21 ZN_22) resistor r=0.565457
    rZN_20 (ZN_21 ZN_23) resistor r=0.0404275
    rZN_19 (ZN_22 ZN_33) resistor r=0.0469216
    rZN_18 (ZN_23 ZN_25) resistor r=0.399653
    rZN_17 (ZN_23 ZN_35) resistor r=0.13925
    rZN_16 (ZN_25 ZN_26) resistor r=13
    rZN_15 (ZN_26 MM1_ELT_d) resistor r=8.44
    rZN_14 (ZN_28 ZN) resistor r=0.079158
    rZN_13 (ZN_28 ZN_35) resistor r=0.000181186
    rnet29_48 (MM11_ELT_d net29) resistor r=0.01
    rnet29_47 (net29_1 net29_3) resistor r=0.41564
    rnet29_46 (net29_1 net29_29) resistor r=0.135362
    rnet29_45 (net29_3 net29_12) resistor r=8.66667
    rnet29_44 (net29_6 net29_8) resistor r=0.00532871
    rnet29_43 (net29_6 net29_29) resistor r=0.135362
    rnet29_42 (net29_8 net29_12) resistor r=8.66667
    rnet29_41 (net29_8 net29_11) resistor r=0.426297
    rnet29_40 (net29_11 net29_12) resistor r=13
    rnet29_39 (net29_12 MM10_ELT_s) resistor r=1.847
    rnet29_38 (net29_12 net29_40) resistor r=20.317
    rnet29_37 (net29_14 net29_15) resistor r=0.274695
    rnet29_36 (net29_14 net29_30) resistor r=0.0200767
    rnet29_35 (net29_15 net29_29) resistor r=0.0200767
    rnet29_34 (net29_16 net29_18) resistor r=0.314394
    rnet29_33 (net29_16 net29_30) resistor r=0.135362
    rnet29_32 (net29_18 net29_19) resistor r=8.66667
    rnet29_31 (net29_19 net29) resistor r=32.3614
    rnet29_30 (net29_21 net29_23) resistor r=0.106574
    rnet29_29 (net29_21 net29_30) resistor r=0.135362
    rnet29_28 (net29_23 net29_24) resistor r=8.66667
    rnet29_27 (net29_23 net29_26) resistor r=0.426297
    rnet29_26 (net29_24 net29) resistor r=16.1807
    rnet29_25 (net29_24 net29_27) resistor r=32.3614
    rnet29_24 (net29_26 net29_27) resistor r=26
    rnet29_23 (net29_31 net29_34) resistor r=31.2341
    rnet29_22 (net29_31 net29_35) resistor r=9.04595
    rnet29_21 (net29_32 net29_34) resistor r=31.2341
    rnet29_20 (net29_32 net29_38) resistor r=9.04062
    rnet29_19 (MM10_ELT_s net29_34) resistor r=6.12113
    rnet29_18 (MM10_ELT_s net29_36) resistor r=12.3172
    rnet29_17 (MM10_ELT_s net29_36) resistor r=1.62887
    rnet29_16 (MM10_ELT_s net29_39) resistor r=2.55965
    rnet29_15 (net29_35 net29_36) resistor r=12.3172
    rnet29_14 (net29_37 net29_39) resistor r=14.4784
    rnet29_13 (net29_37 net29_40) resistor r=9.48555
    rnet29_12 (net29_38 net29_39) resistor r=14.4784
    rA2_96 (A2_22 A2_28) resistor r=58.3583
    rA2_95 (A2_22 A2_28) resistor r=4.16253
    rA2_94 (A2_22 A2_28) resistor r=58.3583
    rA2_93 (A2_22 A2_28) resistor r=4.16253
    rA2_92 (A2_25 A2_28) resistor r=58.3583
    rA2_91 (A2_25 A2_28) resistor r=6.30933
    rA2_90 (A2_25 A2_28) resistor r=58.3583
    rA2_89 (A2_25 A2_28) resistor r=6.30933
    rA2_88 (A2_28 A2_30) resistor r=14.9
    rA2_87 (A2_28 A2_53) resistor r=24.8333
    rA2_86 (A2_28 A2_50) resistor r=24.8333
    rA2_85 (A2_28 A2_61) resistor r=24.8333
    rA2_84 (A2_28 A2_58) resistor r=24.8333
    rA2_83 (A2_28 A2_82) resistor r=58.3583
    rA2_82 (A2_28 A2_85) resistor r=58.3583
    rA2_81 (A2_28 A2_53) resistor r=4.16253
    rA2_80 (A2_28 A2_30) resistor r=6.30933
    rA2_79 (A2_28 A2_61) resistor r=1.63969
    rA2_78 (A2_28 A2_50) resistor r=4.16253
    rA2_77 (A2_28 A2_82) resistor r=4.16253
    rA2_76 (A2_28 A2_58) resistor r=4.16253
    rA2_75 (A2_28 A2_85) resistor r=4.16253
    rA2_74 (A2_28 A2_30) resistor r=14.9
    rA2_73 (A2_28 A2_162) resistor r=40.975
    rA2_72 (A2_28 A2_53) resistor r=24.8333
    rA2_71 (A2_28 A2_50) resistor r=24.8333
    rA2_70 (A2_28 A2_61) resistor r=24.8333
    rA2_69 (A2_28 A2_58) resistor r=24.8333
    rA2_68 (A2_28 A2_82) resistor r=58.3583
    rA2_67 (A2_28 MM1_ELT_g) resistor r=7.45
    rA2_66 (A2_28 A2_53) resistor r=4.16253
    rA2_65 (A2_28 A2_30) resistor r=6.30933
    rA2_64 (A2_28 A2_61) resistor r=1.63969
    rA2_63 (A2_28 A2_50) resistor r=4.16253
    rA2_62 (A2_28 A2_82) resistor r=4.16253
    rA2_61 (A2_28 A2_58) resistor r=4.16253
    rA2_60 (A2_28 A2_85) resistor r=4.16253
    rA2_59 (A2_36 A2_39) resistor r=14.9
    rA2_58 (A2_36 A2_39) resistor r=6.30933
    rA2_57 (A2_36 A2_39) resistor r=14.9
    rA2_56 (A2_36 A2_39) resistor r=6.30933
    rA2_55 (A2_39 A2_42) resistor r=202.392
    rA2_54 (A2_39 A2_45) resistor r=202.392
    rA2_53 (A2_39 A2_69) resistor r=24.8333
    rA2_52 (A2_39 A2_66) resistor r=24.8333
    rA2_51 (A2_39 A2_77) resistor r=24.8333
    rA2_50 (A2_39 A2_74) resistor r=24.8333
    rA2_49 (A2_39 A2_90) resistor r=202.392
    rA2_48 (A2_39 A2_93) resistor r=202.392
    rA2_47 (A2_39 A2_42) resistor r=6.30933
    rA2_46 (A2_39 A2_69) resistor r=1.63969
    rA2_45 (A2_39 A2_77) resistor r=4.16253
    rA2_44 (A2_39 A2_45) resistor r=4.16253
    rA2_43 (A2_39 A2_66) resistor r=4.16253
    rA2_42 (A2_39 A2_90) resistor r=4.16253
    rA2_41 (A2_39 A2_74) resistor r=4.16253
    rA2_40 (A2_39 A2_93) resistor r=4.16253
    rA2_39 (A2_39 A2_164) resistor r=40.975
    rA2_38 (A2_39 A2_42) resistor r=202.392
    rA2_37 (A2_39 A2_45) resistor r=202.392
    rA2_36 (A2_39 A2_69) resistor r=24.8333
    rA2_35 (A2_39 A2_66) resistor r=24.8333
    rA2_34 (A2_39 A2_77) resistor r=24.8333
    rA2_33 (A2_39 A2_74) resistor r=24.8333
    rA2_32 (A2_39 A2_90) resistor r=202.392
    rA2_31 (A2_39 MM11_ELT_g) resistor r=7.45
