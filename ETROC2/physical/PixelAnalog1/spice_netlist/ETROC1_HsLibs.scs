    cinet024_0 (net024_11 VSS) capacitor c=1.10176e-16
    ciA3_21 (A3_32 VSS) capacitor c=1.07497e-17
    ciA3_20 (A3_35 VSS) capacitor c=4.52292e-18
    ciA3_19 (A3_38 VSS) capacitor c=1.53369e-16
    ciA3_18 (A3_40 VSS) capacitor c=3.37535e-17
    ciA3_17 (A3_48 VSS) capacitor c=2.68916e-17
    ciA3_16 (A3_56 VSS) capacitor c=7.78384e-18
    ciA3_15 (A3_70 VSS) capacitor c=5.743e-18
    ciA3_14 (A3_73 VSS) capacitor c=4.74752e-18
    ciA3_13 (A3_76 VSS) capacitor c=1.61274e-16
    ciA3_12 (A3_78 VSS) capacitor c=2.08591e-18
    ciA3_11 (A3_81 VSS) capacitor c=2.22299e-18
    ciA3_10 (A3_84 VSS) capacitor c=5.88566e-16
    ciA3_9 (A3_86 VSS) capacitor c=3.01044e-17
    ciA3_8 (A3_94 VSS) capacitor c=2.48705e-17
    ciA3_7 (A3_102 VSS) capacitor c=1.626e-17
    ciA3_6 (A3_110 VSS) capacitor c=1.51948e-17
    ciA3_5 (A3_118 VSS) capacitor c=5.53781e-18
    ciA3_4 (A3_141 VSS) capacitor c=3.931e-18
    ciA3_3 (A3 VSS) capacitor c=9.2717e-17
    ciA3_2 (A3_288 VSS) capacitor c=1.20198e-17
    ciA3_1 (A3_295 VSS) capacitor c=6.14334e-17
    ciA3_0 (A3_296 VSS) capacitor c=1.22634e-17
    cinet014_6 (net014_3 VSS) capacitor c=2.0033e-17
    cinet014_5 (net014_4 VSS) capacitor c=1.24102e-16
    cinet014_4 (net014_8 VSS) capacitor c=9.67163e-17
    cinet014_3 (net014_12 VSS) capacitor c=1.53542e-17
    cinet014_2 (net014_13 VSS) capacitor c=1.19227e-16
    cinet014_1 (net014_17 VSS) capacitor c=2.78316e-17
    cinet014_0 (net014_18 VSS) capacitor c=2.06811e-17
    ciA2_30 (A2_32 VSS) capacitor c=7.92013e-18
    ciA2_29 (A2_35 VSS) capacitor c=2.35685e-18
    ciA2_28 (A2_38 VSS) capacitor c=1.66266e-16
    ciA2_27 (A2_40 VSS) capacitor c=5.12962e-18
    ciA2_26 (A2_43 VSS) capacitor c=4.15066e-18
    ciA2_25 (A2_46 VSS) capacitor c=6.23258e-16
    ciA2_24 (A2_48 VSS) capacitor c=3.22561e-17
    ciA2_23 (A2_56 VSS) capacitor c=1.61419e-17
    ciA2_22 (A2_64 VSS) capacitor c=1.53315e-17
    ciA2_21 (A2_72 VSS) capacitor c=1.51948e-17
    ciA2_20 (A2_80 VSS) capacitor c=1.07391e-17
    ciA2_19 (A2_103 VSS) capacitor c=3.931e-18
    ciA2_18 (A2_108 VSS) capacitor c=5.81287e-18
    ciA2_17 (A2_114 VSS) capacitor c=1.81183e-16
    ciA2_16 (A2_122 VSS) capacitor c=2.23388e-17
    ciA2_15 (A2_130 VSS) capacitor c=2.26414e-17
    ciA2_14 (A2_138 VSS) capacitor c=3.98524e-18
    ciA2_13 (A2_141 VSS) capacitor c=4.99962e-18
    ciA2_12 (A2_196 VSS) capacitor c=2.19238e-17
    ciA2_11 (A2_202 VSS) capacitor c=3.63584e-17
    ciA2_10 (A2_203 VSS) capacitor c=1.72774e-16
    ciA2_9 (A2_204 VSS) capacitor c=1.60636e-17
    ciA2_8 (A2_205 VSS) capacitor c=3.46868e-18
    ciA2_7 (A2_206 VSS) capacitor c=4.62893e-17
    ciA2_6 (A2_210 VSS) capacitor c=2.05369e-17
    ciA2_5 (A2_211 VSS) capacitor c=8.25833e-17
    ciA2_4 (A2_282 VSS) capacitor c=2.91667e-17
    ciA2_3 (A2_303 VSS) capacitor c=1.31614e-17
    ciA2_2 (A2_304 VSS) capacitor c=2.52065e-17
    ciA2_1 (A2_316 VSS) capacitor c=3.80339e-17
    ciA2_0 (A2 VSS) capacitor c=6.43222e-17
    ciA1_30 (A1_32 VSS) capacitor c=1.0685e-17
    ciA1_29 (A1_38 VSS) capacitor c=2.09924e-16
    ciA1_28 (A1_49 VSS) capacitor c=6.13829e-16
    ciA1_27 (A1_55 VSS) capacitor c=3.931e-18
    ciA1_26 (A1_60 VSS) capacitor c=3.22561e-17
    ciA1_25 (A1_68 VSS) capacitor c=1.58582e-17
    ciA1_24 (A1_76 VSS) capacitor c=1.82488e-17
    ciA1_23 (A1_84 VSS) capacitor c=1.51948e-17
    ciA1_22 (A1_92 VSS) capacitor c=7.92013e-18
    ciA1_21 (A1_95 VSS) capacitor c=1.92767e-18
    ciA1_20 (A1_100 VSS) capacitor c=4.4414e-18
    ciA1_19 (A1_103 VSS) capacitor c=4.15066e-18
    ciA1_18 (A1_108 VSS) capacitor c=3.98524e-18
    ciA1_17 (A1_114 VSS) capacitor c=2.17949e-16
    ciA1_16 (A1_122 VSS) capacitor c=2.23388e-17
    ciA1_15 (A1_130 VSS) capacitor c=2.39196e-17
    ciA1_14 (A1_138 VSS) capacitor c=4.19636e-18
    ciA1_13 (A1_141 VSS) capacitor c=9.9895e-18
    ciA1_12 (A1_196 VSS) capacitor c=2.78174e-17
    ciA1_11 (A1_202 VSS) capacitor c=6.63051e-17
    ciA1_10 (A1_203 VSS) capacitor c=2.98754e-16
    ciA1_9 (A1_204 VSS) capacitor c=9.96273e-18
    ciA1_8 (A1_205 VSS) capacitor c=7.75322e-18
    ciA1_7 (A1_206 VSS) capacitor c=6.12396e-17
    ciA1_6 (A1_210 VSS) capacitor c=2.44334e-17
    ciA1_5 (A1_211 VSS) capacitor c=8.44255e-17
    ciA1_4 (A1_298 VSS) capacitor c=8.32259e-18
    ciA1_3 (A1_307 VSS) capacitor c=2.92124e-17
    ciA1_2 (A1_308 VSS) capacitor c=2.65656e-17
    ciA1_1 (A1_312 VSS) capacitor c=2.91439e-17
    ciA1_0 (A1 VSS) capacitor c=7.60067e-17
    ciA4_26 (A4_32 VSS) capacitor c=2.22299e-18
    ciA4_25 (A4_38 VSS) capacitor c=1.82017e-16
    ciA4_24 (A4_40 VSS) capacitor c=2.96531e-17
    ciA4_23 (A4_48 VSS) capacitor c=1.57537e-17
    ciA4_22 (A4_56 VSS) capacitor c=8.77994e-18
    ciA4_21 (A4_70 VSS) capacitor c=4.19636e-18
    ciA4_20 (A4_76 VSS) capacitor c=1.87459e-16
    ciA4_19 (A4_87 VSS) capacitor c=5.63434e-16
    ciA4_18 (A4_93 VSS) capacitor c=5.21204e-18
    ciA4_17 (A4_98 VSS) capacitor c=2.2403e-17
    ciA4_16 (A4_106 VSS) capacitor c=2.07984e-17
    ciA4_15 (A4_114 VSS) capacitor c=1.90486e-17
    ciA4_14 (A4_122 VSS) capacitor c=1.51948e-17
    ciA4_13 (A4_130 VSS) capacitor c=2.22299e-18
    ciA4_12 (A4_138 VSS) capacitor c=4.54778e-18
    ciA4_11 (A4_141 VSS) capacitor c=2.22299e-18
    ciA4_10 (A4_196 VSS) capacitor c=6.42381e-18
    ciA4_9 (A4_199 VSS) capacitor c=3.88905e-17
    ciA4_8 (A4_202 VSS) capacitor c=3.61468e-17
    ciA4_7 (A4_203 VSS) capacitor c=3.83059e-16
    ciA4_6 (A4_204 VSS) capacitor c=6.33236e-18
    ciA4_5 (A4_206 VSS) capacitor c=4.58857e-17
    ciA4_4 (A4_210 VSS) capacitor c=2.34121e-17
    ciA4_3 (A4_297 VSS) capacitor c=3.84874e-17
    ciA4_2 (A4_301 VSS) capacitor c=5.33106e-18
    ciA4_1 (A4_313 VSS) capacitor c=3.02202e-17
    ciA4_0 (A4 VSS) capacitor c=8.86542e-17
    rnet022_36 (net022_1 net022_4) resistor r=21.1301
    rnet022_35 (net022_1 net022_6) resistor r=9.43134
    rnet022_34 (net022_2 net022_4) resistor r=21.1301
    rnet022_33 (net022_2 net022_8) resistor r=9.4369
    rnet022_32 (MM1_ELT_s net022_4) resistor r=4.557
    rnet022_31 (MM1_ELT_s net022_7) resistor r=2.67027
    rnet022_30 (MM1_ELT_s net022_9) resistor r=12.8495
    rnet022_29 (MM1_ELT_s net022_9) resistor r=1.69926
    rnet022_28 (MM1_ELT_s net022_12) resistor r=2.27123
    rnet022_27 (net022_5 net022_7) resistor r=15.1041
    rnet022_26 (net022_5 net022) resistor r=11.0157
    rnet022_25 (net022_6 net022_7) resistor r=15.1041
    rnet022_24 (net022_8 net022_9) resistor r=12.8495
    rnet022_23 (net022_10 net022_12) resistor r=8.4738
    rnet022_22 (net022_10 net022) resistor r=0.762262
    rnet022_21 (MM21_ELT_d net022_12) resistor r=2.27123
    rnet022_20 (MM21_ELT_d net022_15) resistor r=2.67027
    rnet022_19 (MM21_ELT_d net022_17) resistor r=12.8495
    rnet022_18 (MM21_ELT_d net022_17) resistor r=1.69926
    rnet022_17 (MM21_ELT_d net022_20) resistor r=4.557
    rnet022_16 (net022_13 net022_15) resistor r=15.1041
    rnet022_15 (net022_13 net022_18) resistor r=9.43134
    rnet022_14 (net022_14 net022_15) resistor r=15.1041
    rnet022_13 (net022_14 net022) resistor r=11.0157
    rnet022_12 (net022_16 net022_17) resistor r=12.8495
    rnet022_11 (net022_16 net022_19) resistor r=9.4369
    rnet022_10 (net022_18 net022_20) resistor r=21.1301
    rnet022_9 (net022_19 net022_20) resistor r=21.1301
    rnet013_37 (net013_1 net013_4) resistor r=21.1301
    rnet013_36 (net013_1 net013_6) resistor r=9.43134
    rnet013_35 (net013_2 net013_4) resistor r=21.1301
    rnet013_34 (net013_2 net013_8) resistor r=9.4369
    rnet013_33 (MM24_ELT_s net013_4) resistor r=4.557
    rnet013_32 (MM24_ELT_s net013_7) resistor r=2.67027
    rnet013_31 (MM24_ELT_s net013_9) resistor r=12.8495
    rnet013_30 (MM24_ELT_s net013_9) resistor r=1.69926
    rnet013_29 (MM24_ELT_s net013_13) resistor r=4.22001
    rnet013_28 (MM24_ELT_s net013) resistor r=10.6787
    rnet013_27 (net013_5 net013_7) resistor r=15.1041
    rnet013_26 (net013_5 net013_20) resistor r=11.0157
    rnet013_25 (net013_6 net013_7) resistor r=15.1041
    rnet013_24 (net013_8 net013_9) resistor r=12.8495
    rnet013_23 (net013_10 net013_13) resistor r=4.22001
    rnet013_22 (net013_10 net013_20) resistor r=0.762262
    rnet013_21 (net013_11 net013_13) resistor r=4.22001
    rnet013_20 (net013_11 net013) resistor r=0.57282
    rnet013_19 (MM25_ELT_d net013_13) resistor r=4.22001
    rnet013_18 (MM25_ELT_d net013_16) resistor r=2.67027
    rnet013_17 (MM25_ELT_d net013_18) resistor r=12.8495
    rnet013_16 (MM25_ELT_d net013_18) resistor r=1.69926
    rnet013_15 (MM25_ELT_d net013_19) resistor r=18.0507
    rnet013_14 (net013_14 net013_16) resistor r=15.1041
    rnet013_13 (net013_14 net013_19) resistor r=9.43134
    rnet013_12 (net013_15 net013_16) resistor r=15.1041
    rnet013_11 (net013_15 net013_20) resistor r=11.0157
    rnet013_10 (net013_17 net013_18) resistor r=12.8495
    rnet013_9 (net013_17 net013) resistor r=10.6787
    rZN_112 (ZN_1 ZN_3) resistor r=1.10841
    rZN_111 (ZN_1 ZN_7) resistor r=0.0967378
    rZN_110 (ZN_3 ZN_4) resistor r=8.66667
    rZN_109 (ZN_4 MM23_ELT_d) resistor r=2.27123
    rZN_108 (ZN_4 MM2_ELT_d) resistor r=2.27123
    rZN_107 (ZN_4 ZN_85) resistor r=8.4738
    rZN_106 (ZN_6 ZN_7) resistor r=0.195076
    rZN_105 (ZN_6 ZN_63) resistor r=0.0610504
    rZN_104 (ZN_8 ZN_10) resistor r=0.500654
    rZN_103 (ZN_8 ZN_63) resistor r=0.0293964
    rZN_102 (ZN_10 ZN_11) resistor r=8.66667
    rZN_101 (ZN_10 ZN_13) resistor r=0.639133
    rZN_100 (ZN_11 MM10_ELT_d) resistor r=32.3614
    rZN_99 (ZN_13 ZN_14) resistor r=8.66667
    rZN_98 (ZN_13 ZN_16) resistor r=0.426089
    rZN_97 (ZN_14 MM10_ELT_d) resistor r=16.1807
    rZN_96 (ZN_14 ZN_17) resistor r=32.3614
    rZN_95 (ZN_16 ZN_17) resistor r=26
    rZN_94 (ZN_19 ZN_20) resistor r=0.677029
    rZN_93 (ZN_19 ZN_64) resistor r=0.0610504
    rZN_92 (ZN_20 ZN_63) resistor r=0.0610504
    rZN_91 (ZN_21 ZN_23) resistor r=0.500654
    rZN_90 (ZN_21 ZN_64) resistor r=0.0293964
    rZN_89 (ZN_23 ZN_24) resistor r=8.66667
    rZN_88 (ZN_23 ZN_26) resistor r=0.639133
    rZN_87 (ZN_24 MM11_ELT_d) resistor r=32.3614
    rZN_86 (ZN_26 ZN_27) resistor r=8.66667
    rZN_85 (ZN_26 ZN_29) resistor r=0.426089
    rZN_84 (ZN_27 MM11_ELT_d) resistor r=16.1807
    rZN_83 (ZN_27 ZN_30) resistor r=32.3614
    rZN_82 (ZN_29 ZN_30) resistor r=26
    rZN_81 (ZN_32 ZN_33) resistor r=1.60521
    rZN_80 (ZN_32 ZN_65) resistor r=0.0610504
    rZN_79 (ZN_33 ZN_64) resistor r=0.0610504
    rZN_78 (ZN_34 ZN_36) resistor r=0.500654
    rZN_77 (ZN_34 ZN_65) resistor r=0.0293964
    rZN_76 (ZN_36 ZN_37) resistor r=8.66667
    rZN_75 (ZN_36 ZN_39) resistor r=0.639133
    rZN_74 (ZN_37 MM15_ELT_d) resistor r=32.3614
    rZN_73 (ZN_39 ZN_40) resistor r=8.66667
    rZN_72 (ZN_39 ZN_42) resistor r=0.426089
    rZN_71 (ZN_40 MM15_ELT_d) resistor r=16.1807
    rZN_70 (ZN_40 ZN_43) resistor r=32.3614
    rZN_69 (ZN_42 ZN_43) resistor r=26
    rZN_68 (ZN_45 ZN_46) resistor r=2.3572
    rZN_67 (ZN_45 ZN_66) resistor r=0.0610504
    rZN_66 (ZN_46 ZN_65) resistor r=0.0610504
    rZN_65 (ZN_47 ZN_49) resistor r=0.500654
    rZN_64 (ZN_47 ZN_66) resistor r=0.0293964
    rZN_63 (ZN_49 ZN_50) resistor r=8.66667
    rZN_62 (ZN_49 ZN_52) resistor r=0.639133
    rZN_61 (ZN_50 MM16_ELT_d) resistor r=32.3614
    rZN_60 (ZN_52 ZN_53) resistor r=8.66667
    rZN_59 (ZN_52 ZN_55) resistor r=0.426089
    rZN_58 (ZN_53 MM16_ELT_d) resistor r=16.1807
    rZN_57 (ZN_53 ZN_56) resistor r=32.3614
    rZN_56 (ZN_55 ZN_56) resistor r=26
    rZN_55 (ZN_58 ZN_59) resistor r=0.269664
    rZN_54 (ZN_58 ZN_60) resistor r=0.09729
    rZN_53 (ZN_59 ZN_66) resistor r=0.0610504
    rZN_52 (ZN_60 ZN) resistor r=0.0973162
    rZN_51 (ZN_67 ZN_70) resistor r=21.1301
    rZN_50 (ZN_67 ZN_72) resistor r=9.43134
    rZN_49 (ZN_68 ZN_70) resistor r=21.1301
    rZN_48 (ZN_68 ZN_74) resistor r=9.4369
    rZN_47 (MM2_ELT_d ZN_70) resistor r=4.557
    rZN_46 (MM2_ELT_d ZN_73) resistor r=2.67027
    rZN_45 (MM2_ELT_d ZN_75) resistor r=12.8495
    rZN_44 (MM2_ELT_d ZN_75) resistor r=1.69926
    rZN_43 (ZN_71 ZN_73) resistor r=15.1041
    rZN_42 (ZN_71 ZN_86) resistor r=11.0157
    rZN_41 (ZN_72 ZN_73) resistor r=15.1041
    rZN_40 (ZN_74 ZN_75) resistor r=12.8495
    rZN_39 (MM23_ELT_d ZN_79) resistor r=2.67027
    rZN_38 (MM23_ELT_d ZN_81) resistor r=12.8495
    rZN_37 (MM23_ELT_d ZN_81) resistor r=1.69926
    rZN_36 (MM23_ELT_d ZN_84) resistor r=4.557
    rZN_35 (ZN_77 ZN_79) resistor r=15.1041
    rZN_34 (ZN_77 ZN_82) resistor r=9.43134
    rZN_33 (ZN_78 ZN_79) resistor r=15.1041
    rZN_32 (ZN_78 ZN_86) resistor r=11.0157
    rZN_31 (ZN_80 ZN_81) resistor r=12.8495
    rZN_30 (ZN_80 ZN_83) resistor r=9.4369
    rZN_29 (ZN_82 ZN_84) resistor r=21.1301
    rZN_28 (ZN_83 ZN_84) resistor r=21.1301
    rZN_27 (ZN_85 ZN_86) resistor r=0.762262
    rnet012_15 (MM26_ELT_d net012) resistor r=0.01
    rnet012_14 (net012_1 net012_3) resistor r=0.365763
    rnet012_13 (net012_1 net012_7) resistor r=0.0959895
    rnet012_12 (net012_3 net012_4) resistor r=13
    rnet012_11 (net012_4 MM25_ELT_s) resistor r=8.44
    rnet012_10 (net012_6 net012_7) resistor r=3.62296
    rnet012_9 (net012_6 net012_8) resistor r=0.0959895
    rnet012_8 (net012_8 net012_10) resistor r=0.399458
    rnet012_7 (net012_10 net012_11) resistor r=13
    rnet012_6 (net012_11 net012) resistor r=8.44
    rVDD_153 (MM11_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_152 (MM15_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_151 (MM16_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_150 (MM10_ELT_b VDD_45) resistor r=8.66667
    rVDD_149 (MM10_ELT_b VDD_61) resistor r=8.66667
    rVDD_148 (MM10_ELT_b VDD_64) resistor r=8.66667
    rVDD_147 (MM10_ELT_b VDD_79) resistor r=8.66667
    rVDD_146 (MM10_ELT_b VDD_82) resistor r=26
    rVDD_145 (MM10_ELT_b VDD_43) resistor r=45.0133
    rVDD_144 (VDD_2 VDD_7) resistor r=0.114509
    rVDD_143 (VDD_2 VDD_85) resistor r=0.0221303
    rVDD_142 (VDD VDD_7) resistor r=0.102663
    rVDD_141 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_140 (VDD_8 VDD_24) resistor r=67.52
    rVDD_139 (VDD_9 VDD_18) resistor r=0.591198
    rVDD_138 (VDD_9 VDD_85) resistor r=0.0881897
    rVDD_137 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_136 (VDD_11 VDD_15) resistor r=0.639133
    rVDD_135 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_134 (VDD_15 VDD_18) resistor r=0.426089
    rVDD_133 (VDD_18 VDD_19) resistor r=13
    rVDD_132 (VDD_19 MM10_ELT_s) resistor r=3.10882
    rVDD_131 (VDD_19 VDD_127) resistor r=9.14072
    rVDD_130 (VDD_20 VDD_26) resistor r=0.114509
    rVDD_129 (VDD_20 VDD_86) resistor r=0.0221303
    rVDD_128 (VDD_21 VDD_23) resistor r=0.0868686
    rVDD_127 (VDD_21 VDD_85) resistor r=0.0221303
    rVDD_126 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_125 (VDD_23 VDD_26) resistor r=0.236914
    rVDD_124 (VDD_24 VDD_27) resistor r=67.52
    rVDD_123 (VDD_26 VDD_27) resistor r=8.66667
    rVDD_122 (VDD_27 VDD_43) resistor r=67.52
    rVDD_121 (VDD_28 VDD_37) resistor r=0.591198
    rVDD_120 (VDD_28 VDD_86) resistor r=0.0881897
    rVDD_119 (VDD_30 VDD_38) resistor r=8.66667
    rVDD_118 (VDD_30 VDD_34) resistor r=0.639133
    rVDD_117 (VDD_34 VDD_38) resistor r=8.66667
    rVDD_116 (VDD_34 VDD_37) resistor r=0.426089
    rVDD_115 (VDD_37 VDD_38) resistor r=13
    rVDD_114 (VDD_38 MM11_ELT_s) resistor r=3.10152
    rVDD_113 (VDD_38 VDD_128) resistor r=9.14802
    rVDD_112 (VDD_39 VDD_45) resistor r=0.114509
    rVDD_111 (VDD_39 VDD_87) resistor r=0.0221303
    rVDD_110 (VDD_40 VDD_42) resistor r=0.0868686
    rVDD_109 (VDD_40 VDD_86) resistor r=0.0221303
    rVDD_108 (VDD_42 VDD_43) resistor r=8.66667
    rVDD_107 (VDD_42 VDD_45) resistor r=0.236914
    rVDD_106 (VDD_47 VDD_56) resistor r=0.591198
    rVDD_105 (VDD_47 VDD_87) resistor r=0.0881897
    rVDD_104 (VDD_49 VDD_57) resistor r=8.66667
    rVDD_103 (VDD_49 VDD_53) resistor r=0.639133
    rVDD_102 (VDD_53 VDD_57) resistor r=8.66667
    rVDD_101 (VDD_53 VDD_56) resistor r=0.426089
    rVDD_100 (VDD_56 VDD_57) resistor r=13
    rVDD_99 (VDD_57 MM15_ELT_s) resistor r=3.10152
    rVDD_98 (VDD_57 VDD_129) resistor r=9.14802
    rVDD_97 (VDD_58 VDD_64) resistor r=0.114509
    rVDD_96 (VDD_58 VDD_88) resistor r=0.0221303
    rVDD_95 (VDD_59 VDD_61) resistor r=0.0868686
    rVDD_94 (VDD_59 VDD_87) resistor r=0.0221303
    rVDD_93 (VDD_61 VDD_64) resistor r=0.236914
    rVDD_92 (VDD_66 VDD_75) resistor r=0.591198
    rVDD_91 (VDD_66 VDD_88) resistor r=0.0881897
    rVDD_90 (VDD_68 VDD_76) resistor r=8.66667
    rVDD_89 (VDD_68 VDD_72) resistor r=0.639133
    rVDD_88 (VDD_72 VDD_76) resistor r=8.66667
    rVDD_87 (VDD_72 VDD_75) resistor r=0.426089
    rVDD_86 (VDD_75 VDD_76) resistor r=13
    rVDD_85 (VDD_76 MM16_ELT_s) resistor r=3.10882
    rVDD_84 (VDD_76 VDD_130) resistor r=9.14072
    rVDD_83 (VDD_77 VDD_79) resistor r=0.0868686
    rVDD_82 (VDD_77 VDD_88) resistor r=0.0221303
    rVDD_81 (VDD_79 VDD_82) resistor r=0.157943
    rVDD_80 (MM10_ELT_s VDD_94) resistor r=2.55965
    rVDD_79 (MM10_ELT_s VDD_96) resistor r=12.3172
    rVDD_78 (MM10_ELT_s VDD_96) resistor r=1.62887
    rVDD_77 (MM10_ELT_s VDD_99) resistor r=6.12113
    rVDD_76 (VDD_92 VDD_94) resistor r=14.4784
    rVDD_75 (VDD_92 VDD_98) resistor r=9.04062
    rVDD_74 (VDD_93 VDD_94) resistor r=14.4784
    rVDD_73 (VDD_93 VDD_127) resistor r=16.4401
    rVDD_72 (VDD_95 VDD_96) resistor r=12.3172
    rVDD_71 (VDD_95 VDD_97) resistor r=9.04595
    rVDD_70 (VDD_97 VDD_99) resistor r=31.2341
    rVDD_69 (VDD_98 VDD_99) resistor r=31.2341
    rVDD_68 (VDD_100 VDD_103) resistor r=31.2341
    rVDD_67 (VDD_100 VDD_104) resistor r=9.04595
    rVDD_66 (VDD_101 VDD_103) resistor r=31.2341
    rVDD_65 (VDD_101 VDD_107) resistor r=9.04062
    rVDD_64 (MM11_ELT_s VDD_103) resistor r=6.12113
    rVDD_63 (MM11_ELT_s VDD_105) resistor r=12.3172
    rVDD_62 (MM11_ELT_s VDD_105) resistor r=1.62887
    rVDD_61 (MM11_ELT_s VDD_108) resistor r=2.55965
    rVDD_60 (VDD_104 VDD_105) resistor r=12.3172
    rVDD_59 (VDD_106 VDD_108) resistor r=14.4784
    rVDD_58 (VDD_106 VDD_128) resistor r=16.4401
    rVDD_57 (VDD_107 VDD_108) resistor r=14.4784
    rVDD_56 (VDD_109 VDD_112) resistor r=31.2341
    rVDD_55 (VDD_109 VDD_113) resistor r=9.04595
    rVDD_54 (VDD_110 VDD_112) resistor r=31.2341
    rVDD_53 (VDD_110 VDD_116) resistor r=9.04062
    rVDD_52 (MM15_ELT_s VDD_112) resistor r=6.12113
    rVDD_51 (MM15_ELT_s VDD_114) resistor r=12.3172
    rVDD_50 (MM15_ELT_s VDD_114) resistor r=1.62887
    rVDD_49 (MM15_ELT_s VDD_117) resistor r=2.55965
    rVDD_48 (VDD_113 VDD_114) resistor r=12.3172
    rVDD_47 (VDD_115 VDD_117) resistor r=14.4784
    rVDD_46 (VDD_115 VDD_129) resistor r=16.4401
    rVDD_45 (VDD_116 VDD_117) resistor r=14.4784
    rVDD_44 (MM16_ELT_s VDD_121) resistor r=2.55965
    rVDD_43 (MM16_ELT_s VDD_123) resistor r=12.3172
    rVDD_42 (MM16_ELT_s VDD_123) resistor r=1.62887
    rVDD_41 (MM16_ELT_s VDD_126) resistor r=6.12113
    rVDD_40 (VDD_119 VDD_121) resistor r=14.4784
    rVDD_39 (VDD_119 VDD_125) resistor r=9.04062
    rVDD_38 (VDD_120 VDD_121) resistor r=14.4784
    rVDD_37 (VDD_120 VDD_130) resistor r=16.4401
    rVDD_36 (VDD_122 VDD_123) resistor r=12.3172
    rVDD_35 (VDD_122 VDD_124) resistor r=9.04595
    rVDD_34 (VDD_124 VDD_126) resistor r=31.2341
    rVDD_33 (VDD_125 VDD_126) resistor r=31.2341
    rVSS_72 (MM23_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_71 (MM24_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_70 (MM25_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_69 (MM1_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_68 (MM21_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_67 (MM22_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_66 (MM26_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_65 (MM2_ELT_b VSS_19) resistor r=8.66667
    rVSS_64 (MM2_ELT_b VSS_22) resistor r=8.66667
    rVSS_63 (MM2_ELT_b VSS_25) resistor r=8.66667
    rVSS_62 (MM2_ELT_b VSS_34) resistor r=8.66667
    rVSS_61 (MM2_ELT_b VSS_37) resistor r=26
    rVSS_60 (MM2_ELT_b VSS_17) resistor r=43.1485
    rVSS_59 (VSS_2 VSS_25) resistor r=0.114509
    rVSS_58 (VSS_2 VSS_40) resistor r=0.0221303
    rVSS_57 (VSS VSS_7) resistor r=0.100689
    rVSS_56 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_55 (VSS_7 VSS_10) resistor r=0.237256
    rVSS_54 (VSS_8 VSS_11) resistor r=64.7228
    rVSS_53 (VSS_10 VSS_11) resistor r=8.66667
    rVSS_52 (VSS_10 VSS_13) resistor r=0.237256
    rVSS_51 (VSS_11 VSS_14) resistor r=64.7228
    rVSS_50 (VSS_13 VSS_14) resistor r=8.66667
    rVSS_49 (VSS_13 VSS_16) resistor r=0.237256
    rVSS_48 (VSS_14 VSS_17) resistor r=64.7228
    rVSS_47 (VSS_16 VSS_17) resistor r=8.66667
    rVSS_46 (VSS_16 VSS_19) resistor r=0.237256
    rVSS_45 (VSS_19 VSS_22) resistor r=0.237256
    rVSS_44 (VSS_22 VSS_25) resistor r=0.236914
    rVSS_43 (VSS_27 VSS_29) resistor r=0.444411
    rVSS_42 (VSS_27 VSS_40) resistor r=0.0881897
    rVSS_41 (VSS_29 VSS_30) resistor r=8.66667
    rVSS_40 (VSS_30 MM26_ELT_s) resistor r=4.22001
    rVSS_39 (VSS_30 VSS_59) resistor r=4.22001
    rVSS_38 (VSS_30 MM22_ELT_s) resistor r=4.22001
    rVSS_37 (VSS_30 VSS_57) resistor r=4.22001
    rVSS_36 (VSS_32 VSS_34) resistor r=0.0868686
    rVSS_35 (VSS_32 VSS_40) resistor r=0.0221303
    rVSS_34 (VSS_34 VSS_37) resistor r=0.157943
    rVSS_33 (MM22_ELT_s VSS_42) resistor r=18.0507
    rVSS_32 (MM22_ELT_s VSS_45) resistor r=2.67027
    rVSS_31 (MM22_ELT_s VSS_47) resistor r=12.8495
    rVSS_30 (MM22_ELT_s VSS_47) resistor r=1.69926
    rVSS_29 (VSS_42 VSS_44) resistor r=9.43134
    rVSS_28 (VSS_43 VSS_45) resistor r=15.1041
    rVSS_27 (VSS_43 VSS_58) resistor r=11.0157
    rVSS_26 (VSS_44 VSS_45) resistor r=15.1041
    rVSS_25 (VSS_46 VSS_47) resistor r=12.8495
    rVSS_24 (VSS_46 VSS_60) resistor r=10.6787
    rVSS_23 (MM26_ELT_s VSS_51) resistor r=2.67027
    rVSS_22 (MM26_ELT_s VSS_53) resistor r=12.8495
    rVSS_21 (MM26_ELT_s VSS_53) resistor r=1.69926
    rVSS_20 (MM26_ELT_s VSS_56) resistor r=4.557
    rVSS_19 (MM26_ELT_s VSS_60) resistor r=10.6787
    rVSS_18 (VSS_49 VSS_51) resistor r=15.1041
    rVSS_17 (VSS_49 VSS_54) resistor r=9.43134
    rVSS_16 (VSS_50 VSS_51) resistor r=15.1041
    rVSS_15 (VSS_50 VSS_58) resistor r=11.0157
    rVSS_14 (VSS_52 VSS_53) resistor r=12.8495
    rVSS_13 (VSS_52 VSS_55) resistor r=9.4369
    rVSS_12 (VSS_54 VSS_56) resistor r=21.1301
    rVSS_11 (VSS_55 VSS_56) resistor r=21.1301
    rVSS_10 (VSS_57 VSS_58) resistor r=0.762262
    rVSS_9 (VSS_59 VSS_60) resistor r=0.57282
    rnet021_18 (MM22_ELT_d net021) resistor r=0.01
    rnet021_17 (net021_1 net021_3) resistor r=0.0438915
    rnet021_16 (net021_1 net021_17) resistor r=0.0857189
    rnet021_15 (net021_3 net021_4) resistor r=13
    rnet021_14 (net021_4 MM21_ELT_s) resistor r=8.44
    rnet021_13 (net021_8 net021_9) resistor r=0.568988
    rnet021_12 (net021_8 net021_18) resistor r=0.00859578
    rnet021_11 (net021_9 net021_17) resistor r=0.00859578
    rnet021_10 (net021_10 net021_12) resistor r=0.047935
    rnet021_9 (net021_10 net021_18) resistor r=0.0857189
    rnet021_8 (net021_12 net021_13) resistor r=13
    rnet021_7 (net021_13 net021) resistor r=8.44
    rnet024_15 (MM1_ELT_d net024) resistor r=0.01
    rnet024_14 (net024_1 net024_3) resistor r=0.186414
    rnet024_13 (net024_1 net024_7) resistor r=0.0959895
    rnet024_12 (net024_3 net024_4) resistor r=13
    rnet024_11 (net024_4 MM2_ELT_s) resistor r=8.44
    rnet024_10 (net024_6 net024_7) resistor r=3.71519
    rnet024_9 (net024_6 net024_8) resistor r=0.0959895
    rnet024_8 (net024_8 net024_10) resistor r=0.170689
    rnet024_7 (net024_10 net024_11) resistor r=13
    rnet024_6 (net024_11 net024) resistor r=8.44
    rA3_143 (A3_32 A3_38) resistor r=58.3583
    rA3_142 (A3_32 A3_38) resistor r=4.16253
    rA3_141 (A3_32 A3_38) resistor r=58.3583
    rA3_140 (A3_32 A3_38) resistor r=4.16253
    rA3_139 (A3_35 A3_38) resistor r=58.3583
    rA3_138 (A3_35 A3_38) resistor r=4.16253
    rA3_137 (A3_35 A3_38) resistor r=58.3583
    rA3_136 (A3_35 A3_38) resistor r=4.16253
    rA3_135 (A3_38 A3_43) resistor r=24.8333
    rA3_134 (A3_38 A3_40) resistor r=24.8333
    rA3_133 (A3_38 A3_51) resistor r=24.8333
    rA3_132 (A3_38 A3_48) resistor r=24.8333
    rA3_131 (A3_38 A3_56) resistor r=58.3583
    rA3_130 (A3_38 A3_59) resistor r=58.3583
    rA3_129 (A3_38 A3_64) resistor r=14.9
    rA3_128 (A3_38 A3_43) resistor r=4.16253
    rA3_127 (A3_38 A3_51) resistor r=4.16253
    rA3_126 (A3_38 A3_40) resistor r=4.16253
    rA3_125 (A3_38 A3_56) resistor r=4.16253
    rA3_124 (A3_38 A3_64) resistor r=6.30933
    rA3_123 (A3_38 A3_59) resistor r=6.30933
    rA3_122 (A3_38 A3_48) resistor r=1.63969
    rA3_121 (A3_38 A3_43) resistor r=24.8333
    rA3_120 (A3_38 A3_40) resistor r=24.8333
    rA3_119 (A3_38 A3_51) resistor r=24.8333
    rA3_118 (A3_38 A3_48) resistor r=24.8333
    rA3_117 (A3_38 A3_56) resistor r=58.3583
    rA3_116 (A3_38 MM25_ELT_g) resistor r=22.35
    rA3_115 (A3_38 A3_64) resistor r=14.9
    rA3_114 (A3_38 A3_248) resistor r=40.975
    rA3_113 (A3_38 A3_43) resistor r=4.16253
    rA3_112 (A3_38 A3_51) resistor r=4.16253
    rA3_111 (A3_38 A3_40) resistor r=4.16253
    rA3_110 (A3_38 A3_56) resistor r=4.16253
    rA3_109 (A3_38 A3_64) resistor r=6.30933
    rA3_108 (A3_38 A3_59) resistor r=6.30933
    rA3_107 (A3_38 A3_48) resistor r=1.63969
    rA3_106 (A3_59 MM25_ELT_g) resistor r=36.0083
    rA3_105 (A3_70 A3_76) resistor r=58.3583
    rA3_104 (A3_70 A3_76) resistor r=4.16253
    rA3_103 (A3_70 A3_76) resistor r=58.3583
    rA3_102 (A3_70 A3_76) resistor r=4.16253
    rA3_101 (A3_73 A3_76) resistor r=58.3583
    rA3_100 (A3_73 A3_76) resistor r=4.16253
    rA3_99 (A3_73 A3_76) resistor r=58.3583
    rA3_98 (A3_73 A3_76) resistor r=4.16253
    rA3_97 (A3_76 A3_89) resistor r=24.8333
    rA3_96 (A3_76 A3_86) resistor r=24.8333
    rA3_95 (A3_76 A3_97) resistor r=24.8333
    rA3_94 (A3_76 A3_94) resistor r=24.8333
    rA3_93 (A3_76 A3_118) resistor r=58.3583
    rA3_92 (A3_76 A3_121) resistor r=58.3583
    rA3_91 (A3_76 A3_126) resistor r=14.9
    rA3_90 (A3_76 A3_89) resistor r=4.16253
    rA3_89 (A3_76 A3_97) resistor r=4.16253
    rA3_88 (A3_76 A3_86) resistor r=4.16253
    rA3_87 (A3_76 A3_118) resistor r=4.16253
    rA3_86 (A3_76 A3_126) resistor r=6.30933
    rA3_85 (A3_76 A3_121) resistor r=6.30933
    rA3_84 (A3_76 A3_94) resistor r=1.63969
    rA3_83 (A3_76 A3_89) resistor r=24.8333
    rA3_82 (A3_76 A3_86) resistor r=24.8333
    rA3_81 (A3_76 A3_97) resistor r=24.8333
    rA3_80 (A3_76 A3_94) resistor r=24.8333
    rA3_79 (A3_76 A3_118) resistor r=58.3583
    rA3_78 (A3_76 MM1_ELT_g) resistor r=22.35
    rA3_77 (A3_76 A3_126) resistor r=14.9
    rA3_76 (A3_76 A3_274) resistor r=40.975
    rA3_75 (A3_76 A3_89) resistor r=4.16253
    rA3_74 (A3_76 A3_97) resistor r=4.16253
    rA3_73 (A3_76 A3_86) resistor r=4.16253
    rA3_72 (A3_76 A3_118) resistor r=4.16253
    rA3_71 (A3_76 A3_126) resistor r=6.30933
    rA3_70 (A3_76 A3_121) resistor r=6.30933
    rA3_69 (A3_76 A3_94) resistor r=1.63969
    rA3_68 (A3_78 A3_84) resistor r=202.392
    rA3_67 (A3_78 A3_84) resistor r=4.16253
    rA3_66 (A3_78 A3_84) resistor r=202.392
    rA3_65 (A3_78 A3_84) resistor r=4.16253
    rA3_64 (A3_81 A3_84) resistor r=202.392
    rA3_63 (A3_81 A3_84) resistor r=4.16253
    rA3_62 (A3_81 A3_84) resistor r=202.392
    rA3_61 (A3_81 A3_84) resistor r=4.16253
    rA3_60 (A3_84 A3_105) resistor r=24.8333
    rA3_59 (A3_84 A3_102) resistor r=24.8333
    rA3_58 (A3_84 A3_113) resistor r=24.8333
    rA3_57 (A3_84 A3_110) resistor r=24.8333
    rA3_56 (A3_84 A3_132) resistor r=14.9
    rA3_55 (A3_84 A3_138) resistor r=202.392
    rA3_54 (A3_84 A3_141) resistor r=202.392
    rA3_53 (A3_84 A3_105) resistor r=4.16253
    rA3_52 (A3_84 A3_113) resistor r=4.16253
    rA3_51 (A3_84 A3_138) resistor r=6.30933
    rA3_50 (A3_84 A3_132) resistor r=6.30933
    rA3_49 (A3_84 A3_102) resistor r=1.63969
    rA3_48 (A3_84 A3_110) resistor r=4.16253
    rA3_47 (A3_84 A3_141) resistor r=4.16253
    rA3_46 (A3_84 A3_105) resistor r=24.8333
    rA3_45 (A3_84 A3_102) resistor r=24.8333
    rA3_44 (A3_84 A3_113) resistor r=24.8333
    rA3_43 (A3_84 A3_110) resistor r=24.8333
    rA3_42 (A3_84 A3_276) resistor r=40.975
    rA3_41 (A3_84 A3_132) resistor r=14.9
    rA3_40 (A3_84 A3_138) resistor r=202.392
    rA3_39 (A3_84 MM15_ELT_g) resistor r=7.45
    rA3_38 (A3_84 A3_105) resistor r=4.16253
    rA3_37 (A3_84 A3_113) resistor r=4.16253
    rA3_36 (A3_84 A3_138) resistor r=6.30933
    rA3_35 (A3_84 A3_132) resistor r=6.30933
    rA3_34 (A3_84 A3_102) resistor r=1.63969
    rA3_33 (A3_84 A3_110) resistor r=4.16253
    rA3_32 (A3_84 A3_141) resistor r=4.16253
    rA3_31 (A3_121 MM1_ELT_g) resistor r=36.0083
    rA3_30 (A3_141 MM15_ELT_g) resistor r=194.942
    rA3_29 (A3_197 A3_198) resistor r=10
    rA3_28 (A3_197 A3) resistor r=0.0889868
    rA3_27 (A3_198 A3_288) resistor r=25.7364
    rA3_26 (A3_198 A3_295) resistor r=58.2455
    rA3_25 (A3_248 A3_288) resistor r=9.29775
    rA3_24 (A3_274 A3_296) resistor r=10.0997
    rA3_23 (A3_276 A3_296) resistor r=10.0997
    rA3_22 (A3_295 A3_296) resistor r=0.877078
    rnet014_18 (MM24_ELT_d net014) resistor r=0.01
    rnet014_17 (net014_1 net014_3) resistor r=0.047935
    rnet014_16 (net014_1 net014_17) resistor r=0.0857189
    rnet014_15 (net014_3 net014_4) resistor r=13
    rnet014_14 (net014_4 MM23_ELT_s) resistor r=8.44
    rnet014_13 (net014_8 net014_9) resistor r=0.568988
    rnet014_12 (net014_8 net014_18) resistor r=0.00859578
    rnet014_11 (net014_9 net014_17) resistor r=0.00859578
    rnet014_10 (net014_10 net014_12) resistor r=0.0438915
    rnet014_9 (net014_10 net014_18) resistor r=0.0857189
    rnet014_8 (net014_12 net014_13) resistor r=13
    rnet014_7 (net014_13 net014) resistor r=8.44
    rA2_162 (A2_32 A2_38) resistor r=58.3583
    rA2_161 (A2_32 A2_38) resistor r=4.16253
    rA2_160 (A2_32 A2_38) resistor r=58.3583
    rA2_159 (A2_32 A2_38) resistor r=4.16253
    rA2_158 (A2_35 A2_38) resistor r=58.3583
    rA2_157 (A2_35 A2_38) resistor r=4.16253
    rA2_156 (A2_35 A2_38) resistor r=58.3583
    rA2_155 (A2_35 A2_38) resistor r=4.16253
    rA2_154 (A2_38 A2_51) resistor r=24.8333
    rA2_153 (A2_38 A2_48) resistor r=24.8333
    rA2_152 (A2_38 A2_59) resistor r=24.8333
    rA2_151 (A2_38 A2_56) resistor r=24.8333
    rA2_150 (A2_38 A2_80) resistor r=58.3583
    rA2_149 (A2_38 A2_83) resistor r=58.3583
    rA2_148 (A2_38 A2_88) resistor r=14.9
    rA2_147 (A2_38 A2_51) resistor r=4.16253
    rA2_146 (A2_38 A2_59) resistor r=4.16253
    rA2_145 (A2_38 A2_48) resistor r=4.16253
    rA2_144 (A2_38 A2_80) resistor r=4.16253
    rA2_143 (A2_38 A2_88) resistor r=6.30933
    rA2_142 (A2_38 A2_83) resistor r=6.30933
    rA2_141 (A2_38 A2_56) resistor r=1.63969
    rA2_140 (A2_38 A2_51) resistor r=24.8333
    rA2_139 (A2_38 A2_48) resistor r=24.8333
    rA2_138 (A2_38 A2_59) resistor r=24.8333
    rA2_137 (A2_38 A2_56) resistor r=24.8333
    rA2_136 (A2_38 A2_80) resistor r=58.3583
    rA2_135 (A2_38 MM24_ELT_g) resistor r=22.35
    rA2_134 (A2_38 A2_88) resistor r=14.9
    rA2_133 (A2_38 A2_266) resistor r=40.975
    rA2_132 (A2_38 A2_51) resistor r=4.16253
    rA2_131 (A2_38 A2_59) resistor r=4.16253
    rA2_130 (A2_38 A2_48) resistor r=4.16253
    rA2_129 (A2_38 A2_80) resistor r=4.16253
    rA2_128 (A2_38 A2_88) resistor r=6.30933
    rA2_127 (A2_38 A2_83) resistor r=6.30933
    rA2_126 (A2_38 A2_56) resistor r=1.63969
    rA2_125 (A2_40 A2_46) resistor r=202.392
    rA2_124 (A2_40 A2_46) resistor r=4.16253
    rA2_123 (A2_40 A2_46) resistor r=202.392
    rA2_122 (A2_40 A2_46) resistor r=4.16253
    rA2_121 (A2_43 A2_46) resistor r=202.392
    rA2_120 (A2_43 A2_46) resistor r=4.16253
    rA2_119 (A2_43 A2_46) resistor r=202.392
    rA2_118 (A2_43 A2_46) resistor r=4.16253
    rA2_117 (A2_46 A2_67) resistor r=24.8333
    rA2_116 (A2_46 A2_64) resistor r=24.8333
    rA2_115 (A2_46 A2_75) resistor r=24.8333
    rA2_114 (A2_46 A2_72) resistor r=24.8333
    rA2_113 (A2_46 A2_94) resistor r=14.9
    rA2_112 (A2_46 A2_100) resistor r=202.392
    rA2_111 (A2_46 A2_103) resistor r=202.392
    rA2_110 (A2_46 A2_67) resistor r=4.16253
    rA2_109 (A2_46 A2_75) resistor r=4.16253
    rA2_108 (A2_46 A2_100) resistor r=6.30933
    rA2_107 (A2_46 A2_94) resistor r=6.30933
    rA2_106 (A2_46 A2_64) resistor r=1.63969
    rA2_105 (A2_46 A2_72) resistor r=4.16253
    rA2_104 (A2_46 A2_103) resistor r=4.16253
    rA2_103 (A2_46 A2_67) resistor r=24.8333
    rA2_102 (A2_46 A2_64) resistor r=24.8333
    rA2_101 (A2_46 A2_75) resistor r=24.8333
    rA2_100 (A2_46 A2_72) resistor r=24.8333
    rA2_99 (A2_46 A2_268) resistor r=40.975
    rA2_98 (A2_46 A2_94) resistor r=14.9
    rA2_97 (A2_46 A2_100) resistor r=202.392
    rA2_96 (A2_46 MM11_ELT_g) resistor r=7.45
    rA2_95 (A2_46 A2_67) resistor r=4.16253
    rA2_94 (A2_46 A2_75) resistor r=4.16253
    rA2_93 (A2_46 A2_100) resistor r=6.30933
    rA2_92 (A2_46 A2_94) resistor r=6.30933
    rA2_91 (A2_46 A2_64) resistor r=1.63969
    rA2_90 (A2_46 A2_72) resistor r=4.16253
    rA2_89 (A2_46 A2_103) resistor r=4.16253
    rA2_88 (A2_83 MM24_ELT_g) resistor r=36.0083
    rA2_87 (A2_103 MM11_ELT_g) resistor r=194.942
    rA2_86 (A2_108 A2_114) resistor r=58.3583
    rA2_85 (A2_108 A2_114) resistor r=4.16253
    rA2_84 (A2_108 A2_114) resistor r=58.3583
    rA2_83 (A2_108 A2_114) resistor r=4.16253
    rA2_82 (A2_111 A2_114) resistor r=58.3583
    rA2_81 (A2_111 A2_114) resistor r=6.30933
    rA2_80 (A2_111 A2_114) resistor r=58.3583
    rA2_79 (A2_111 A2_114) resistor r=6.30933
    rA2_78 (A2_114 A2_116) resistor r=14.9
    rA2_77 (A2_114 A2_125) resistor r=24.8333
    rA2_76 (A2_114 A2_122) resistor r=24.8333
    rA2_75 (A2_114 A2_133) resistor r=24.8333
    rA2_74 (A2_114 A2_130) resistor r=24.8333
    rA2_73 (A2_114 A2_138) resistor r=58.3583
    rA2_72 (A2_114 A2_141) resistor r=58.3583
    rA2_71 (A2_114 A2_125) resistor r=4.16253
    rA2_70 (A2_114 A2_116) resistor r=6.30933
    rA2_69 (A2_114 A2_133) resistor r=1.63969
    rA2_68 (A2_114 A2_122) resistor r=4.16253
    rA2_67 (A2_114 A2_138) resistor r=4.16253
    rA2_66 (A2_114 A2_130) resistor r=4.16253
    rA2_65 (A2_114 A2_141) resistor r=4.16253
    rA2_64 (A2_114 A2_116) resistor r=14.9
    rA2_63 (A2_114 A2_282) resistor r=40.975
    rA2_62 (A2_114 A2_125) resistor r=24.8333
    rA2_61 (A2_114 A2_122) resistor r=24.8333
    rA2_60 (A2_114 A2_133) resistor r=24.8333
    rA2_59 (A2_114 A2_130) resistor r=24.8333
    rA2_58 (A2_114 A2_138) resistor r=58.3583
    rA2_57 (A2_114 MM21_ELT_g) resistor r=7.45
    rA2_56 (A2_114 A2_125) resistor r=4.16253
    rA2_55 (A2_114 A2_116) resistor r=6.30933
    rA2_54 (A2_114 A2_133) resistor r=1.63969
    rA2_53 (A2_114 A2_122) resistor r=4.16253
    rA2_52 (A2_114 A2_138) resistor r=4.16253
    rA2_51 (A2_114 A2_130) resistor r=4.16253
    rA2_50 (A2_114 A2_141) resistor r=4.16253
    rA2_49 (A2_141 MM21_ELT_g) resistor r=50.9083
    rA2_48 (A2_196 A2_198) resistor r=0.148174
    rA2_47 (A2_196 A2_201) resistor r=0.0766136
    rA2_46 (A2_198 A2_199) resistor r=0.75
    rA2_45 (A2_199 A2_312) resistor r=10
    rA2_44 (A2_199 A2) resistor r=0.0868266
    rA2_43 (A2_201 A2_202) resistor r=0.354838
    rA2_42 (A2_202 A2_204) resistor r=0.0767405
    rA2_41 (A2_203 A2_204) resistor r=1.0793
    rA2_40 (A2_203 A2_206) resistor r=0.0767405
    rA2_39 (A2_205 A2_206) resistor r=0.354838
    rA2_38 (A2_205 A2_210) resistor r=0.0383068
    rA2_37 (A2_210 A2_211) resistor r=0.75
    rA2_36 (A2_211 A2_316) resistor r=10
    rA2_35 (A2_266 A2_304) resistor r=3.725
    rA2_34 (A2_268 A2_304) resistor r=3.725
    rA2_33 (A2_282 A2_316) resistor r=5.35325
    rA2_32 (A2_303 A2_304) resistor r=3.725
    rA2_31 (A2_303 A2_312) resistor r=9.48182
    rA1_164 (A1_32 A1_38) resistor r=58.3583
    rA1_163 (A1_32 A1_38) resistor r=4.16253
    rA1_162 (A1_32 A1_38) resistor r=58.3583
    rA1_161 (A1_32 A1_38) resistor r=4.16253
    rA1_160 (A1_35 A1_38) resistor r=58.3583
    rA1_159 (A1_35 A1_38) resistor r=6.30933
    rA1_158 (A1_35 A1_38) resistor r=58.3583
    rA1_157 (A1_35 A1_38) resistor r=6.30933
    rA1_156 (A1_38 A1_40) resistor r=14.9
    rA1_155 (A1_38 A1_63) resistor r=24.8333
    rA1_154 (A1_38 A1_60) resistor r=24.8333
    rA1_153 (A1_38 A1_71) resistor r=24.8333
    rA1_152 (A1_38 A1_68) resistor r=24.8333
    rA1_151 (A1_38 A1_92) resistor r=58.3583
    rA1_150 (A1_38 A1_95) resistor r=58.3583
    rA1_149 (A1_38 A1_63) resistor r=4.16253
    rA1_148 (A1_38 A1_40) resistor r=6.30933
    rA1_147 (A1_38 A1_71) resistor r=1.63969
    rA1_146 (A1_38 A1_60) resistor r=4.16253
    rA1_145 (A1_38 A1_92) resistor r=4.16253
    rA1_144 (A1_38 A1_68) resistor r=4.16253
    rA1_143 (A1_38 A1_95) resistor r=4.16253
    rA1_142 (A1_38 A1_40) resistor r=14.9
    rA1_141 (A1_38 A1_246) resistor r=40.975
    rA1_140 (A1_38 A1_63) resistor r=24.8333
    rA1_139 (A1_38 A1_60) resistor r=24.8333
    rA1_138 (A1_38 A1_71) resistor r=24.8333
    rA1_137 (A1_38 A1_68) resistor r=24.8333
    rA1_136 (A1_38 A1_92) resistor r=58.3583
    rA1_135 (A1_38 MM23_ELT_g) resistor r=7.45
    rA1_134 (A1_38 A1_63) resistor r=4.16253
    rA1_133 (A1_38 A1_40) resistor r=6.30933
    rA1_132 (A1_38 A1_71) resistor r=1.63969
    rA1_131 (A1_38 A1_60) resistor r=4.16253
    rA1_130 (A1_38 A1_92) resistor r=4.16253
    rA1_129 (A1_38 A1_68) resistor r=4.16253
    rA1_128 (A1_38 A1_95) resistor r=4.16253
    rA1_127 (A1_46 A1_49) resistor r=14.9
    rA1_126 (A1_46 A1_49) resistor r=6.30933
    rA1_125 (A1_46 A1_49) resistor r=14.9
    rA1_124 (A1_46 A1_49) resistor r=6.30933
    rA1_123 (A1_49 A1_52) resistor r=202.392
    rA1_122 (A1_49 A1_55) resistor r=202.392
    rA1_121 (A1_49 A1_79) resistor r=24.8333
    rA1_120 (A1_49 A1_76) resistor r=24.8333
    rA1_119 (A1_49 A1_87) resistor r=24.8333
    rA1_118 (A1_49 A1_84) resistor r=24.8333
    rA1_117 (A1_49 A1_100) resistor r=202.392
    rA1_116 (A1_49 A1_103) resistor r=202.392
    rA1_115 (A1_49 A1_52) resistor r=6.30933
    rA1_114 (A1_49 A1_79) resistor r=1.63969
    rA1_113 (A1_49 A1_87) resistor r=4.16253
    rA1_112 (A1_49 A1_55) resistor r=4.16253
    rA1_111 (A1_49 A1_76) resistor r=4.16253
    rA1_110 (A1_49 A1_100) resistor r=4.16253
    rA1_109 (A1_49 A1_84) resistor r=4.16253
    rA1_108 (A1_49 A1_103) resistor r=4.16253
    rA1_107 (A1_49 A1_248) resistor r=40.975
    rA1_106 (A1_49 A1_52) resistor r=202.392
    rA1_105 (A1_49 A1_55) resistor r=202.392
    rA1_104 (A1_49 A1_79) resistor r=24.8333
    rA1_103 (A1_49 A1_76) resistor r=24.8333
    rA1_102 (A1_49 A1_87) resistor r=24.8333
    rA1_101 (A1_49 A1_84) resistor r=24.8333
    rA1_100 (A1_49 A1_100) resistor r=202.392
    rA1_99 (A1_49 MM10_ELT_g) resistor r=7.45
    rA1_98 (A1_49 A1_52) resistor r=6.30933
    rA1_97 (A1_49 A1_79) resistor r=1.63969
    rA1_96 (A1_49 A1_87) resistor r=4.16253
    rA1_95 (A1_49 A1_55) resistor r=4.16253
    rA1_94 (A1_49 A1_76) resistor r=4.16253
    rA1_93 (A1_49 A1_100) resistor r=4.16253
    rA1_92 (A1_49 A1_84) resistor r=4.16253
    rA1_91 (A1_49 A1_103) resistor r=4.16253
    rA1_90 (A1_95 MM23_ELT_g) resistor r=50.9083
    rA1_89 (A1_103 MM10_ELT_g) resistor r=194.942
    rA1_88 (A1_108 A1_114) resistor r=58.3583
    rA1_87 (A1_108 A1_114) resistor r=4.16253
    rA1_86 (A1_108 A1_114) resistor r=58.3583
    rA1_85 (A1_108 A1_114) resistor r=4.16253
    rA1_84 (A1_111 A1_114) resistor r=58.3583
    rA1_83 (A1_111 A1_114) resistor r=6.30933
    rA1_82 (A1_111 A1_114) resistor r=58.3583
    rA1_81 (A1_111 A1_114) resistor r=6.30933
    rA1_80 (A1_114 A1_116) resistor r=14.9
    rA1_79 (A1_114 A1_125) resistor r=24.8333
    rA1_78 (A1_114 A1_122) resistor r=24.8333
    rA1_77 (A1_114 A1_133) resistor r=24.8333
    rA1_76 (A1_114 A1_130) resistor r=24.8333
    rA1_75 (A1_114 A1_138) resistor r=58.3583
    rA1_74 (A1_114 A1_141) resistor r=58.3583
    rA1_73 (A1_114 A1_125) resistor r=4.16253
    rA1_72 (A1_114 A1_116) resistor r=6.30933
    rA1_71 (A1_114 A1_133) resistor r=1.63969
    rA1_70 (A1_114 A1_122) resistor r=4.16253
    rA1_69 (A1_114 A1_138) resistor r=4.16253
    rA1_68 (A1_114 A1_130) resistor r=4.16253
    rA1_67 (A1_114 A1_141) resistor r=4.16253
    rA1_66 (A1_114 A1_116) resistor r=14.9
    rA1_65 (A1_114 A1_280) resistor r=40.975
    rA1_64 (A1_114 A1_125) resistor r=24.8333
    rA1_63 (A1_114 A1_122) resistor r=24.8333
    rA1_62 (A1_114 A1_133) resistor r=24.8333
    rA1_61 (A1_114 A1_130) resistor r=24.8333
    rA1_60 (A1_114 A1_138) resistor r=58.3583
    rA1_59 (A1_114 MM22_ELT_g) resistor r=7.45
    rA1_58 (A1_114 A1_125) resistor r=4.16253
    rA1_57 (A1_114 A1_116) resistor r=6.30933
    rA1_56 (A1_114 A1_133) resistor r=1.63969
    rA1_55 (A1_114 A1_122) resistor r=4.16253
    rA1_54 (A1_114 A1_138) resistor r=4.16253
    rA1_53 (A1_114 A1_130) resistor r=4.16253
    rA1_52 (A1_114 A1_141) resistor r=4.16253
    rA1_51 (A1_141 MM22_ELT_g) resistor r=50.9083
    rA1_50 (A1_196 A1_198) resistor r=0.148174
    rA1_49 (A1_196 A1_201) resistor r=0.0766136
    rA1_48 (A1_198 A1_199) resistor r=0.75
    rA1_47 (A1_199 A1_312) resistor r=10
    rA1_46 (A1_199 A1) resistor r=0.0868266
    rA1_45 (A1_201 A1_202) resistor r=0.545905
    rA1_44 (A1_202 A1_204) resistor r=0.0767405
    rA1_43 (A1_203 A1_204) resistor r=2.24405
    rA1_42 (A1_203 A1_206) resistor r=0.0767405
    rA1_41 (A1_205 A1_206) resistor r=0.545905
    rA1_40 (A1_205 A1_210) resistor r=0.0383068
    rA1_39 (A1_210 A1_211) resistor r=0.75
    rA1_38 (A1_211 A1_316) resistor r=10
    rA1_37 (A1_246 A1_298) resistor r=10.0997
    rA1_36 (A1_248 A1_298) resistor r=10.0997
    rA1_35 (A1_280 A1_308) resistor r=4.38767
    rA1_34 (A1_297 A1_298) resistor r=0.877078
    rA1_33 (A1_297 A1_312) resistor r=10.1591
    rA1_32 (A1_307 A1_308) resistor r=3.71511
    rA1_31 (A1_307 A1_316) resistor r=9.48182
    rA4_159 (A4_32 A4_38) resistor r=58.3583
    rA4_158 (A4_32 A4_38) resistor r=4.16253
    rA4_157 (A4_32 A4_38) resistor r=58.3583
    rA4_156 (A4_32 A4_38) resistor r=4.16253
    rA4_155 (A4_35 A4_38) resistor r=58.3583
    rA4_154 (A4_35 A4_38) resistor r=4.16253
    rA4_153 (A4_35 A4_38) resistor r=58.3583
    rA4_152 (A4_35 A4_38) resistor r=4.16253
    rA4_151 (A4_38 A4_43) resistor r=24.8333
    rA4_150 (A4_38 A4_40) resistor r=24.8333
    rA4_149 (A4_38 A4_51) resistor r=24.8333
    rA4_148 (A4_38 A4_48) resistor r=24.8333
    rA4_147 (A4_38 A4_56) resistor r=58.3583
    rA4_146 (A4_38 A4_59) resistor r=58.3583
    rA4_145 (A4_38 A4_64) resistor r=14.9
    rA4_144 (A4_38 A4_43) resistor r=4.16253
    rA4_143 (A4_38 A4_51) resistor r=4.16253
    rA4_142 (A4_38 A4_40) resistor r=4.16253
    rA4_141 (A4_38 A4_56) resistor r=4.16253
    rA4_140 (A4_38 A4_64) resistor r=6.30933
    rA4_139 (A4_38 A4_59) resistor r=6.30933
    rA4_138 (A4_38 A4_48) resistor r=1.63969
    rA4_137 (A4_38 A4_43) resistor r=24.8333
    rA4_136 (A4_38 A4_40) resistor r=24.8333
    rA4_135 (A4_38 A4_51) resistor r=24.8333
    rA4_134 (A4_38 A4_48) resistor r=24.8333
    rA4_133 (A4_38 A4_56) resistor r=58.3583
    rA4_132 (A4_38 MM2_ELT_g) resistor r=22.35
    rA4_131 (A4_38 A4_64) resistor r=14.9
    rA4_130 (A4_38 A4_257) resistor r=40.975
    rA4_129 (A4_38 A4_43) resistor r=4.16253
    rA4_128 (A4_38 A4_51) resistor r=4.16253
    rA4_127 (A4_38 A4_40) resistor r=4.16253
    rA4_126 (A4_38 A4_56) resistor r=4.16253
    rA4_125 (A4_38 A4_64) resistor r=6.30933
    rA4_124 (A4_38 A4_59) resistor r=6.30933
    rA4_123 (A4_38 A4_48) resistor r=1.63969
    rA4_122 (A4_59 MM2_ELT_g) resistor r=36.0083
    rA4_121 (A4_70 A4_76) resistor r=58.3583
    rA4_120 (A4_70 A4_76) resistor r=4.16253
    rA4_119 (A4_70 A4_76) resistor r=58.3583
    rA4_118 (A4_70 A4_76) resistor r=4.16253
    rA4_117 (A4_73 A4_76) resistor r=58.3583
    rA4_116 (A4_73 A4_76) resistor r=6.30933
    rA4_115 (A4_73 A4_76) resistor r=58.3583
    rA4_114 (A4_73 A4_76) resistor r=6.30933
    rA4_113 (A4_76 A4_78) resistor r=14.9
    rA4_112 (A4_76 A4_101) resistor r=24.8333
    rA4_111 (A4_76 A4_98) resistor r=24.8333
    rA4_110 (A4_76 A4_109) resistor r=24.8333
    rA4_109 (A4_76 A4_106) resistor r=24.8333
    rA4_108 (A4_76 A4_130) resistor r=58.3583
    rA4_107 (A4_76 A4_133) resistor r=58.3583
    rA4_106 (A4_76 A4_101) resistor r=4.16253
    rA4_105 (A4_76 A4_78) resistor r=6.30933
    rA4_104 (A4_76 A4_109) resistor r=1.63969
    rA4_103 (A4_76 A4_98) resistor r=4.16253
    rA4_102 (A4_76 A4_130) resistor r=4.16253
    rA4_101 (A4_76 A4_106) resistor r=4.16253
    rA4_100 (A4_76 A4_133) resistor r=4.16253
    rA4_99 (A4_76 A4_78) resistor r=14.9
    rA4_98 (A4_76 A4_263) resistor r=40.975
    rA4_97 (A4_76 A4_101) resistor r=24.8333
    rA4_96 (A4_76 A4_98) resistor r=24.8333
    rA4_95 (A4_76 A4_109) resistor r=24.8333
    rA4_94 (A4_76 A4_106) resistor r=24.8333
    rA4_93 (A4_76 A4_130) resistor r=58.3583
    rA4_92 (A4_76 MM26_ELT_g) resistor r=7.45
    rA4_91 (A4_76 A4_101) resistor r=4.16253
    rA4_90 (A4_76 A4_78) resistor r=6.30933
    rA4_89 (A4_76 A4_109) resistor r=1.63969
    rA4_88 (A4_76 A4_98) resistor r=4.16253
    rA4_87 (A4_76 A4_130) resistor r=4.16253
    rA4_86 (A4_76 A4_106) resistor r=4.16253
    rA4_85 (A4_76 A4_133) resistor r=4.16253
    rA4_84 (A4_84 A4_87) resistor r=14.9
    rA4_83 (A4_84 A4_87) resistor r=6.30933
    rA4_82 (A4_84 A4_87) resistor r=14.9
    rA4_81 (A4_84 A4_87) resistor r=6.30933
    rA4_80 (A4_87 A4_90) resistor r=202.392
    rA4_79 (A4_87 A4_93) resistor r=202.392
    rA4_78 (A4_87 A4_117) resistor r=24.8333
    rA4_77 (A4_87 A4_114) resistor r=24.8333
    rA4_76 (A4_87 A4_125) resistor r=24.8333
    rA4_75 (A4_87 A4_122) resistor r=24.8333
    rA4_74 (A4_87 A4_138) resistor r=202.392
    rA4_73 (A4_87 A4_141) resistor r=202.392
    rA4_72 (A4_87 A4_90) resistor r=6.30933
    rA4_71 (A4_87 A4_117) resistor r=1.63969
    rA4_70 (A4_87 A4_125) resistor r=4.16253
    rA4_69 (A4_87 A4_93) resistor r=4.16253
    rA4_68 (A4_87 A4_114) resistor r=4.16253
    rA4_67 (A4_87 A4_138) resistor r=4.16253
    rA4_66 (A4_87 A4_122) resistor r=4.16253
    rA4_65 (A4_87 A4_141) resistor r=4.16253
    rA4_64 (A4_87 A4_265) resistor r=40.975
    rA4_63 (A4_87 A4_90) resistor r=202.392
    rA4_62 (A4_87 A4_93) resistor r=202.392
    rA4_61 (A4_87 A4_117) resistor r=24.8333
    rA4_60 (A4_87 A4_114) resistor r=24.8333
    rA4_59 (A4_87 A4_125) resistor r=24.8333
    rA4_58 (A4_87 A4_122) resistor r=24.8333
    rA4_57 (A4_87 A4_138) resistor r=202.392
    rA4_56 (A4_87 MM16_ELT_g) resistor r=7.45
    rA4_55 (A4_87 A4_90) resistor r=6.30933
    rA4_54 (A4_87 A4_117) resistor r=1.63969
    rA4_53 (A4_87 A4_125) resistor r=4.16253
    rA4_52 (A4_87 A4_93) resistor r=4.16253
    rA4_51 (A4_87 A4_114) resistor r=4.16253
    rA4_50 (A4_87 A4_138) resistor r=4.16253
    rA4_49 (A4_87 A4_122) resistor r=4.16253
    rA4_48 (A4_87 A4_141) resistor r=4.16253
    rA4_47 (A4_133 MM26_ELT_g) resistor r=50.9083
    rA4_46 (A4_141 MM16_ELT_g) resistor r=194.942
    rA4_45 (A4_196 A4_198) resistor r=0.148174
    rA4_44 (A4_196 A4_202) resistor r=0.0766136
    rA4_43 (A4_198 A4_199) resistor r=0.75
    rA4_42 (A4_199 A4_309) resistor r=10
    rA4_41 (A4_201 A4_202) resistor r=0.366536
    rA4_40 (A4_201 A4_204) resistor r=0.0767405
    rA4_39 (A4_203 A4_204) resistor r=2.89882
    rA4_38 (A4_203 A4_205) resistor r=0.0767405
    rA4_37 (A4_205 A4_206) resistor r=0.366536
    rA4_36 (A4_206 A4_210) resistor r=0.0383068
    rA4_35 (A4_210 A4_211) resistor r=0.75
    rA4_34 (A4_211 A4_313) resistor r=10
    rA4_33 (A4_211 A4) resistor r=0.129031
    rA4_32 (A4_257 A4_297) resistor r=9.29775
    rA4_31 (A4_263 A4_301) resistor r=10.0997
    rA4_30 (A4_265 A4_301) resistor r=10.0997
    rA4_29 (A4_297 A4_309) resistor r=35.2182
    rA4_28 (A4_300 A4_301) resistor r=0.877078
    rA4_27 (A4_300 A4_313) resistor r=6.09545
ends ND4D1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: XOR2D1_LVT_ELT
// View name: calibre
subckt XOR2D1_LVT_ELT A1 A2 Z VDD VSS
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet054_5 (net054_4 VSS) capacitor c=5.32711e-18
    cinet054_4 (net054_7 VSS) capacitor c=9.43346e-18
    cinet054_3 (net054_8 VSS) capacitor c=1.3825e-18
    cinet054_2 (net054_9 VSS) capacitor c=2.79321e-18
    cinet054_1 (MM11_ELT_s VSS) capacitor c=6.71153e-18
    cinet054_0 (net054_18 VSS) capacitor c=3.32842e-18
    cinet056_10 (MM3_ELT_s VSS) capacitor c=6.29837e-18
    cinet056_9 (net056_4 VSS) capacitor c=4.16968e-19
    cinet056_8 (net056_5 VSS) capacitor c=9.52226e-19
    cinet056_7 (net056_7 VSS) capacitor c=6.54656e-18
    cinet056_6 (MM7_ELT_d VSS) capacitor c=7.02457e-18
    cinet056_5 (net056_11 VSS) capacitor c=8.39535e-18
    cinet056_4 (net056_12 VSS) capacitor c=5.84945e-19
    cinet056_3 (net056_14 VSS) capacitor c=1.33931e-17
    cinet056_2 (net056_16 VSS) capacitor c=4.97605e-18
    cinet056_1 (net056_18 VSS) capacitor c=7.65699e-19
    cinet056_0 (net056 VSS) capacitor c=3.01246e-18
    cinet036_7 (MM6_ELT_d VSS) capacitor c=2.37323e-17
    cinet036_6 (net036_5 VSS) capacitor c=1.05449e-17
    cinet036_5 (net036_7 VSS) capacitor c=5.18795e-18
    cinet036_4 (MM0_ELT_s VSS) capacitor c=2.37137e-17
    cinet036_3 (net036_11 VSS) capacitor c=2.58685e-17
    cinet036_2 (net036_13 VSS) capacitor c=5.18999e-18
    cinet036_1 (net036_16 VSS) capacitor c=1.11099e-18
    cinet036_0 (net036_18 VSS) capacitor c=1.9761e-18
    cinet038_8 (MM13_ELT_s VSS) capacitor c=2.24335e-17
    cinet038_7 (net038_5 VSS) capacitor c=1.11099e-18
    cinet038_6 (net038_7 VSS) capacitor c=2.59676e-18
    cinet038_5 (net038_11 VSS) capacitor c=2.58685e-17
    cinet038_4 (net038_14 VSS) capacitor c=1.05449e-17
    cinet038_3 (net038_15 VSS) capacitor c=1.32861e-18
    cinet038_2 (net038_16 VSS) capacitor c=5.99607e-18
    cinet038_1 (net038_19 VSS) capacitor c=2.24659e-17
    cinet038_0 (net038_20 VSS) capacitor c=1.90274e-18
    ciZ_8 (Z_3 VSS) capacitor c=5.54423e-17
    ciZ_7 (Z_4 VSS) capacitor c=1.11642e-16
    ciZ_6 (Z_8 VSS) capacitor c=1.92778e-16
    ciZ_5 (Z_9 VSS) capacitor c=3.29129e-16
    ciZ_4 (Z_17 VSS) capacitor c=3.50952e-17
    ciZ_3 (Z_18 VSS) capacitor c=2.14501e-17
    ciZ_2 (Z_19 VSS) capacitor c=3.17668e-17
    ciZ_1 (Z_20 VSS) capacitor c=1.65525e-17
    ciZ_0 (Z VSS) capacitor c=3.20963e-17
    ciZN_24 (ZN_22 VSS) capacitor c=4.28147e-18
    ciZN_23 (ZN_28 VSS) capacitor c=1.82781e-16
    ciZN_22 (ZN_39 VSS) capacitor c=5.62301e-16
    ciZN_21 (ZN_45 VSS) capacitor c=6.02001e-18
    ciZN_20 (ZN_50 VSS) capacitor c=2.23697e-17
    ciZN_19 (ZN_58 VSS) capacitor c=2.27535e-17
    ciZN_18 (ZN_66 VSS) capacitor c=1.42966e-17
    ciZN_17 (ZN_74 VSS) capacitor c=1.51948e-17
    ciZN_16 (ZN_82 VSS) capacitor c=2.14282e-18
    ciZN_15 (ZN_85 VSS) capacitor c=4.88345e-18
    ciZN_14 (ZN_90 VSS) capacitor c=1.06765e-18
    ciZN_13 (ZN_93 VSS) capacitor c=2.22299e-18
    ciZN_12 (ZN_133 VSS) capacitor c=5.06945e-17
    ciZN_11 (ZN_134 VSS) capacitor c=1.12754e-16
    ciZN_10 (ZN_138 VSS) capacitor c=1.75248e-16
    ciZN_9 (ZN_139 VSS) capacitor c=3.32847e-16
    ciZN_8 (ZN_147 VSS) capacitor c=5.18141e-17
    ciZN_7 (ZN_148 VSS) capacitor c=2.37019e-17
    ciZN_6 (ZN_149 VSS) capacitor c=4.54713e-17
    ciZN_5 (ZN_150 VSS) capacitor c=1.83527e-17
    ciZN_4 (ZN_152 VSS) capacitor c=2.00516e-18
    ciZN_3 (ZN_154 VSS) capacitor c=2.02754e-18
    ciZN_2 (ZN_157 VSS) capacitor c=5.19492e-17
    ciZN_1 (ZN_160 VSS) capacitor c=1.42936e-17
    ciZN_0 (ZN_225 VSS) capacitor c=3.96153e-17
    ciVDD_31 (VDD_2 VSS) capacitor c=6.72889e-17
    ciVDD_30 (VDD_11 VSS) capacitor c=2.46175e-16
    ciVDD_29 (VDD_19 VSS) capacitor c=3.79127e-16
    ciVDD_28 (VDD_20 VSS) capacitor c=1.08573e-16
    ciVDD_27 (VDD_30 VSS) capacitor c=1.17816e-16
    ciVDD_26 (VDD_31 VSS) capacitor c=3.1255e-16
    ciVDD_25 (VDD_39 VSS) capacitor c=3.98118e-17
    ciVDD_24 (VDD_46 VSS) capacitor c=1.17816e-16
    ciVDD_23 (VDD_47 VSS) capacitor c=3.1255e-16
    ciVDD_22 (VDD_55 VSS) capacitor c=1.08573e-16
    ciVDD_21 (VDD_65 VSS) capacitor c=2.51519e-16
    ciVDD_20 (VDD_73 VSS) capacitor c=3.80842e-16
    ciVDD_19 (VDD_79 VSS) capacitor c=6.96233e-17
    ciVDD_18 (VDD_82 VSS) capacitor c=3.58509e-18
    ciVDD_17 (VDD_84 VSS) capacitor c=3.58509e-18
    ciVDD_16 (VDD_86 VSS) capacitor c=3.58509e-18
    ciVDD_15 (VDD_87 VSS) capacitor c=3.58509e-18
    ciVDD_14 (VDD_93 VSS) capacitor c=1.32762e-17
    ciVDD_13 (VDD_95 VSS) capacitor c=8.04828e-18
    ciVDD_12 (VDD_98 VSS) capacitor c=1.11099e-18
    ciVDD_11 (MM2_ELT_s VSS) capacitor c=2.56788e-17
    ciVDD_10 (VDD_101 VSS) capacitor c=1.07074e-18
    ciVDD_9 (VDD_104 VSS) capacitor c=1.11099e-18
    ciVDD_8 (MM15_ELT_s VSS) capacitor c=2.14457e-17
    ciVDD_7 (VDD_110 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_112 VSS) capacitor c=5.05285e-18
    ciVDD_5 (VDD_116 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_117 VSS) capacitor c=8.58639e-18
    ciVDD_3 (VDD_118 VSS) capacitor c=5.80576e-18
    ciVDD_2 (VDD_121 VSS) capacitor c=1.32762e-17
    ciVDD_1 (VDD_123 VSS) capacitor c=5.19663e-18
    ciVDD_0 (VDD_127 VSS) capacitor c=9.30831e-18
    ciVSS_33 (VSS_2 VSS) capacitor c=7.71416e-17
    ciVSS_32 (VSS_11 VSS) capacitor c=9.39638e-17
    ciVSS_31 (VSS_12 VSS) capacitor c=1.23444e-16
    ciVSS_30 (VSS_14 VSS) capacitor c=1.25431e-16
    ciVSS_29 (VSS_24 VSS) capacitor c=7.47278e-17
    ciVSS_28 (VSS_25 VSS) capacitor c=1.07664e-16
    ciVSS_27 (VSS_27 VSS) capacitor c=4.46477e-17
    ciVSS_26 (VSS_34 VSS) capacitor c=6.3498e-17
    ciVSS_25 (VSS_35 VSS) capacitor c=1.08404e-16
    ciVSS_24 (VSS_37 VSS) capacitor c=1.06936e-16
    ciVSS_23 (VSS_47 VSS) capacitor c=8.02349e-17
    ciVSS_22 (VSS_48 VSS) capacitor c=1.23945e-16
    ciVSS_21 (VSS_55 VSS) capacitor c=6.80721e-17
    ciVSS_20 (VSS_58 VSS) capacitor c=3.58509e-18
    ciVSS_19 (VSS_60 VSS) capacitor c=3.58509e-18
    ciVSS_18 (VSS_62 VSS) capacitor c=3.58509e-18
    ciVSS_17 (VSS_63 VSS) capacitor c=3.58509e-18
    ciVSS_16 (VSS_67 VSS) capacitor c=3.25741e-17
    ciVSS_15 (VSS_69 VSS) capacitor c=7.34261e-18
    ciVSS_14 (VSS_70 VSS) capacitor c=2.78136e-18
    ciVSS_13 (VSS_71 VSS) capacitor c=6.03134e-18
    ciVSS_12 (VSS_72 VSS) capacitor c=4.00514e-18
    ciVSS_11 (MM1_ELT_s VSS) capacitor c=1.03241e-17
    ciVSS_10 (VSS_74 VSS) capacitor c=4.16968e-19
    ciVSS_9 (VSS_76 VSS) capacitor c=2.03887e-18
    ciVSS_8 (VSS_78 VSS) capacitor c=2.63938e-18
    ciVSS_7 (MM14_ELT_s VSS) capacitor c=7.71667e-18
    ciVSS_6 (VSS_86 VSS) capacitor c=2.84564e-18
    ciVSS_5 (VSS_91 VSS) capacitor c=1.99626e-18
    ciVSS_4 (VSS_92 VSS) capacitor c=3.12765e-18
    ciVSS_3 (VSS_95 VSS) capacitor c=4.06506e-18
    ciVSS_2 (VSS_97 VSS) capacitor c=2.07176e-18
    ciVSS_1 (VSS_99 VSS) capacitor c=3.63416e-18
    ciVSS_0 (VSS_103 VSS) capacitor c=4.5952e-18
    ciXOR1_32 (XOR1_22 VSS) capacitor c=4.11804e-18
    ciXOR1_31 (XOR1_28 VSS) capacitor c=1.93865e-16
    ciXOR1_30 (XOR1_39 VSS) capacitor c=6.01986e-16
    ciXOR1_29 (XOR1_45 VSS) capacitor c=4.15066e-18
    ciXOR1_28 (XOR1_50 VSS) capacitor c=2.23697e-17
    ciXOR1_27 (XOR1_58 VSS) capacitor c=2.232e-17
    ciXOR1_26 (XOR1_66 VSS) capacitor c=1.35202e-17
    ciXOR1_25 (XOR1_74 VSS) capacitor c=1.51948e-17
    ciXOR1_24 (XOR1_82 VSS) capacitor c=2.96645e-18
    ciXOR1_23 (XOR1_85 VSS) capacitor c=8.43538e-18
    ciXOR1_22 (XOR1_90 VSS) capacitor c=4.53843e-18
    ciXOR1_21 (XOR1_93 VSS) capacitor c=4.73896e-18
    ciXOR1_20 (XOR1_132 VSS) capacitor c=6.99647e-17
    ciXOR1_19 (XOR1_135 VSS) capacitor c=4.325e-17
    ciXOR1_18 (XOR1_136 VSS) capacitor c=1.07958e-16
    ciXOR1_17 (XOR1_140 VSS) capacitor c=1.10166e-16
    ciXOR1_16 (XOR1_141 VSS) capacitor c=3.11739e-16
    ciXOR1_15 (XOR1_149 VSS) capacitor c=3.49087e-16
    ciXOR1_14 (XOR1_150 VSS) capacitor c=4.43175e-17
    ciXOR1_13 (XOR1_153 VSS) capacitor c=3.79746e-17
    ciXOR1_12 (XOR1_154 VSS) capacitor c=1.07958e-16
    ciXOR1_11 (XOR1_158 VSS) capacitor c=1.05422e-16
    ciXOR1_10 (XOR1_159 VSS) capacitor c=3.11739e-16
    ciXOR1_9 (XOR1_167 VSS) capacitor c=7.77113e-17
    ciXOR1_8 (XOR1_168 VSS) capacitor c=1.27858e-17
    ciXOR1_7 (XOR1_169 VSS) capacitor c=8.91039e-17
    ciXOR1_6 (XOR1_172 VSS) capacitor c=6.38832e-18
    ciXOR1_5 (XOR1_174 VSS) capacitor c=3.36865e-18
    ciXOR1_4 (XOR1_177 VSS) capacitor c=5.82097e-17
    ciXOR1_3 (XOR1_178 VSS) capacitor c=4.1613e-17
    ciXOR1_2 (XOR1_182 VSS) capacitor c=4.63808e-17
    ciXOR1_1 (XOR1_187 VSS) capacitor c=1.6115e-17
    ciXOR1_0 (XOR1_188 VSS) capacitor c=1.41759e-17
    ciA1N_28 (A1N_22 VSS) capacitor c=5.89798e-18
    ciA1N_27 (A1N_25 VSS) capacitor c=5.28047e-18
    ciA1N_26 (A1N_28 VSS) capacitor c=1.64157e-16
    ciA1N_25 (A1N_30 VSS) capacitor c=8.04681e-18
    ciA1N_24 (A1N_33 VSS) capacitor c=5.89798e-18
    ciA1N_23 (A1N_36 VSS) capacitor c=5.01681e-16
    ciA1N_22 (A1N_38 VSS) capacitor c=2.23697e-17
    ciA1N_21 (A1N_46 VSS) capacitor c=2.29104e-17
    ciA1N_20 (A1N_54 VSS) capacitor c=1.86202e-17
    ciA1N_19 (A1N_62 VSS) capacitor c=1.51948e-17
    ciA1N_18 (A1N_70 VSS) capacitor c=4.07048e-18
    ciA1N_17 (A1N_93 VSS) capacitor c=4.15066e-18
    ciA1N_16 (A1N_133 VSS) capacitor c=4.38892e-17
    ciA1N_15 (A1N_134 VSS) capacitor c=1.12745e-16
    ciA1N_14 (A1N_138 VSS) capacitor c=1.53675e-16
    ciA1N_13 (A1N_139 VSS) capacitor c=3.33276e-16
    ciA1N_12 (A1N_147 VSS) capacitor c=4.83553e-17
    ciA1N_11 (A1N_148 VSS) capacitor c=2.14872e-17
    ciA1N_10 (A1N_149 VSS) capacitor c=3.39326e-17
    ciA1N_9 (A1N_150 VSS) capacitor c=1.44707e-17
    ciA1N_8 (A1N_155 VSS) capacitor c=1.72025e-17
    ciA1N_7 (A1N_156 VSS) capacitor c=8.65027e-17
    ciA1N_6 (A1N_160 VSS) capacitor c=2.18023e-16
    ciA1N_5 (A1N_162 VSS) capacitor c=9.27078e-18
    ciA1N_4 (A1N_165 VSS) capacitor c=9.59858e-17
    ciA1N_3 (A1N_168 VSS) capacitor c=6.32013e-18
    ciA1N_2 (A1N_171 VSS) capacitor c=1.25422e-17
    ciA1N_1 (A1N_172 VSS) capacitor c=2.26729e-17
    ciA1N_0 (A1N_241 VSS) capacitor c=5.71911e-17
    ciA1_28 (A1_42 VSS) capacitor c=4.88535e-18
    ciA1_27 (A1_45 VSS) capacitor c=5.04033e-18
    ciA1_26 (A1_48 VSS) capacitor c=1.91062e-16
    ciA1_25 (A1_50 VSS) capacitor c=3.67499e-18
    ciA1_24 (A1_53 VSS) capacitor c=4.73896e-18
    ciA1_23 (A1_56 VSS) capacitor c=5.74007e-16
    ciA1_22 (A1_58 VSS) capacitor c=2.6849e-17
    ciA1_21 (A1_66 VSS) capacitor c=2.06268e-17
    ciA1_20 (A1_74 VSS) capacitor c=1.09399e-17
    ciA1_19 (A1_82 VSS) capacitor c=1.51948e-17
    ciA1_18 (A1_90 VSS) capacitor c=3.91906e-18
    ciA1_17 (A1_113 VSS) capacitor c=2.22299e-18
    ciA1_16 (A1_118 VSS) capacitor c=3.98355e-18
    ciA1_15 (A1_124 VSS) capacitor c=1.51957e-16
    ciA1_14 (A1_135 VSS) capacitor c=4.56669e-16
    ciA1_13 (A1_141 VSS) capacitor c=2.22299e-18
    ciA1_12 (A1_146 VSS) capacitor c=2.70108e-17
    ciA1_11 (A1_154 VSS) capacitor c=2.76154e-17
    ciA1_10 (A1_162 VSS) capacitor c=2.34324e-17
    ciA1_9 (A1_170 VSS) capacitor c=1.51948e-17
    ciA1_8 (A1_178 VSS) capacitor c=7.86066e-18
    ciA1_7 (A1_181 VSS) capacitor c=7.7951e-18
    ciA1_6 (A1_186 VSS) capacitor c=9.17901e-18
    ciA1_5 (A1_189 VSS) capacitor c=5.89798e-18
    ciA1_4 (A1 VSS) capacitor c=5.05802e-17
    ciA1_3 (A1_342 VSS) capacitor c=4.12993e-17
    ciA1_2 (A1_384 VSS) capacitor c=3.36792e-17
    ciA1_1 (A1_385 VSS) capacitor c=7.12206e-19
    ciA1_0 (A1_390 VSS) capacitor c=1.56332e-17
    ciA2N_30 (A2N_25 VSS) capacitor c=5.05887e-16
    ciA2N_29 (A2N_31 VSS) capacitor c=4.30419e-18
    ciA2N_28 (A2N_36 VSS) capacitor c=2.23678e-17
    ciA2N_27 (A2N_44 VSS) capacitor c=1.55503e-17
    ciA2N_26 (A2N_52 VSS) capacitor c=9.76905e-18
    ciA2N_25 (A2N_55 VSS) capacitor c=2.90427e-18
    ciA2N_24 (A2N_60 VSS) capacitor c=3.36705e-18
    ciA2N_23 (A2N_63 VSS) capacitor c=4.84099e-18
    ciA2N_22 (A2N_66 VSS) capacitor c=1.56364e-16
    ciA2N_21 (A2N_68 VSS) capacitor c=2.19947e-17
    ciA2N_20 (A2N_76 VSS) capacitor c=1.77685e-17
    ciA2N_19 (A2N_84 VSS) capacitor c=4.2906e-18
    ciA2N_18 (A2N_133 VSS) capacitor c=1.93369e-16
    ciA2N_17 (A2N_134 VSS) capacitor c=3.29558e-16
    ciA2N_16 (A2N_143 VSS) capacitor c=6.07829e-17
    ciA2N_15 (A2N_144 VSS) capacitor c=6.39827e-17
    ciA2N_14 (A2N_149 VSS) capacitor c=1.06873e-17
    ciA2N_13 (A2N_150 VSS) capacitor c=1.35452e-17
    ciA2N_12 (A2N_151 VSS) capacitor c=1.2514e-16
    ciA2N_11 (A2N_154 VSS) capacitor c=2.81221e-17
    ciA2N_10 (A2N_160 VSS) capacitor c=4.85843e-17
    ciA2N_9 (A2N_164 VSS) capacitor c=3.58044e-17
    ciA2N_8 (A2N_167 VSS) capacitor c=4.58135e-17
    ciA2N_7 (A2N_168 VSS) capacitor c=3.36812e-17
    ciA2N_6 (A2N_171 VSS) capacitor c=2.4083e-17
    ciA2N_5 (A2N_174 VSS) capacitor c=8.03359e-18
    ciA2N_4 (A2N_176 VSS) capacitor c=1.69729e-16
    ciA2N_3 (A2N_231 VSS) capacitor c=2.32106e-17
    ciA2N_2 (A2N_235 VSS) capacitor c=5.74143e-17
    ciA2N_1 (A2N_248 VSS) capacitor c=1.13794e-16
    ciA2N_0 (A2N_249 VSS) capacitor c=8.06802e-17
    ciA2_33 (A2_42 VSS) capacitor c=2.36783e-18
    ciA2_32 (A2_48 VSS) capacitor c=1.97409e-16
    ciA2_31 (A2_53 VSS) capacitor c=2.22299e-18
    ciA2_30 (A2_56 VSS) capacitor c=5.75192e-16
    ciA2_29 (A2_58 VSS) capacitor c=2.297e-17
    ciA2_28 (A2_66 VSS) capacitor c=2.24538e-17
    ciA2_27 (A2_74 VSS) capacitor c=1.48484e-17
    ciA2_26 (A2_82 VSS) capacitor c=1.51948e-17
    ciA2_25 (A2_90 VSS) capacitor c=4.52248e-18
    ciA2_24 (A2_113 VSS) capacitor c=6.02001e-18
    ciA2_23 (A2_118 VSS) capacitor c=4.39854e-18
    ciA2_22 (A2_121 VSS) capacitor c=1.08905e-17
    ciA2_21 (A2_124 VSS) capacitor c=1.66983e-16
    ciA2_20 (A2_126 VSS) capacitor c=2.28611e-17
    ciA2_19 (A2_134 VSS) capacitor c=2.96741e-17
    ciA2_18 (A2_142 VSS) capacitor c=2.97744e-18
    ciA2_17 (A2_159 VSS) capacitor c=5.03677e-16
    ciA2_16 (A2_165 VSS) capacitor c=2.90427e-18
    ciA2_15 (A2_170 VSS) capacitor c=2.52278e-17
    ciA2_14 (A2_178 VSS) capacitor c=1.55503e-17
    ciA2_13 (A2_186 VSS) capacitor c=1.14451e-17
    ciA2_12 (A2_189 VSS) capacitor c=4.30419e-18
    ciA2_11 (A2 VSS) capacitor c=4.39259e-17
    ciA2_10 (A2_272 VSS) capacitor c=2.12753e-16
    ciA2_9 (A2_274 VSS) capacitor c=1.85672e-17
    ciA2_8 (A2_277 VSS) capacitor c=8.66122e-17
    ciA2_7 (A2_280 VSS) capacitor c=8.08711e-17
    ciA2_6 (A2_284 VSS) capacitor c=2.76183e-17
    ciA2_5 (A2_285 VSS) capacitor c=1.16485e-16
    ciA2_4 (A2_286 VSS) capacitor c=2.27588e-17
    ciA2_3 (A2_401 VSS) capacitor c=2.76324e-17
    ciA2_2 (A2_402 VSS) capacitor c=1.45803e-17
    ciA2_1 (A2_409 VSS) capacitor c=1.23331e-17
    ciA2_0 (A2_410 VSS) capacitor c=6.18448e-17
    rnet054_34 (net054_1 net054_4) resistor r=21.1301
    rnet054_33 (net054_1 net054_6) resistor r=9.43134
    rnet054_32 (net054_2 net054_4) resistor r=21.1301
    rnet054_31 (net054_2 net054_8) resistor r=9.4369
    rnet054_30 (MM10_ELT_d net054_4) resistor r=4.557
    rnet054_29 (MM10_ELT_d net054_7) resistor r=2.67027
    rnet054_28 (MM10_ELT_d net054_9) resistor r=12.8495
    rnet054_27 (MM10_ELT_d net054_9) resistor r=1.69926
    rnet054_26 (MM10_ELT_d net054_13) resistor r=4.22001
    rnet054_25 (MM10_ELT_d net054) resistor r=10.6787
    rnet054_24 (net054_5 net054_7) resistor r=15.1041
    rnet054_23 (net054_5 net054_20) resistor r=11.0157
    rnet054_22 (net054_6 net054_7) resistor r=15.1041
    rnet054_21 (net054_8 net054_9) resistor r=12.8495
    rnet054_20 (net054_10 net054_13) resistor r=4.22001
    rnet054_19 (net054_10 net054_20) resistor r=0.762262
    rnet054_18 (net054_11 net054_13) resistor r=4.22001
    rnet054_17 (net054_11 net054) resistor r=0.57282
    rnet054_16 (MM11_ELT_s net054_13) resistor r=4.22001
    rnet054_15 (MM11_ELT_s net054_16) resistor r=2.67027
    rnet054_14 (MM11_ELT_s net054_18) resistor r=12.8495
    rnet054_13 (MM11_ELT_s net054_18) resistor r=1.69926
    rnet054_12 (MM11_ELT_s net054_19) resistor r=18.0507
    rnet054_11 (net054_14 net054_16) resistor r=15.1041
    rnet054_10 (net054_14 net054_19) resistor r=9.43134
    rnet054_9 (net054_15 net054_16) resistor r=15.1041
    rnet054_8 (net054_15 net054_20) resistor r=11.0157
    rnet054_7 (net054_17 net054_18) resistor r=12.8495
    rnet054_6 (net054_17 net054) resistor r=10.6787
    rnet056_36 (MM3_ELT_s net056_2) resistor r=18.0507
    rnet056_35 (MM3_ELT_s net056_5) resistor r=2.67027
    rnet056_34 (MM3_ELT_s net056_7) resistor r=12.8495
    rnet056_33 (MM3_ELT_s net056_7) resistor r=1.69926
    rnet056_32 (MM3_ELT_s net056_11) resistor r=4.22001
    rnet056_31 (net056_2 net056_4) resistor r=9.43134
    rnet056_30 (net056_3 net056_5) resistor r=15.1041
    rnet056_29 (net056_3 net056_18) resistor r=11.0157
    rnet056_28 (net056_4 net056_5) resistor r=15.1041
    rnet056_27 (net056_6 net056_7) resistor r=12.8495
    rnet056_26 (net056_6 net056) resistor r=10.6787
    rnet056_25 (net056_8 net056_11) resistor r=4.22001
    rnet056_24 (net056_8 net056_18) resistor r=0.762262
    rnet056_23 (net056_9 net056_11) resistor r=4.22001
    rnet056_22 (net056_9 net056) resistor r=0.57282
    rnet056_21 (MM7_ELT_d net056_11) resistor r=4.22001
    rnet056_20 (MM7_ELT_d net056_14) resistor r=2.67027
    rnet056_19 (MM7_ELT_d net056_16) resistor r=12.8495
    rnet056_18 (MM7_ELT_d net056_16) resistor r=1.69926
    rnet056_17 (MM7_ELT_d net056_17) resistor r=18.0507
    rnet056_16 (net056_12 net056_14) resistor r=15.1041
    rnet056_15 (net056_12 net056_17) resistor r=9.43134
    rnet056_14 (net056_13 net056_14) resistor r=15.1041
    rnet056_13 (net056_13 net056_18) resistor r=11.0157
    rnet056_12 (net056_15 net056_16) resistor r=12.8495
    rnet056_11 (net056_15 net056) resistor r=10.6787
    rnet036_33 (MM6_ELT_d net036_2) resistor r=25.7298
    rnet036_32 (MM6_ELT_d net036_5) resistor r=2.55965
    rnet036_31 (MM6_ELT_d net036_7) resistor r=12.3172
    rnet036_30 (MM6_ELT_d net036_7) resistor r=1.62887
    rnet036_29 (MM6_ELT_d net036_11) resistor r=4.04518
    rnet036_28 (net036_2 net036_4) resistor r=9.04062
    rnet036_27 (net036_3 net036_5) resistor r=14.4784
    rnet036_26 (net036_3 net036) resistor r=10.5593
    rnet036_25 (net036_4 net036_5) resistor r=14.4784
    rnet036_24 (net036_6 net036_7) resistor r=12.3172
    rnet036_23 (net036_6 net036_18) resistor r=10.2363
    rnet036_22 (net036_8 net036_11) resistor r=4.04518
    rnet036_21 (net036_8 net036_18) resistor r=0.549089
    rnet036_20 (net036_9 net036_11) resistor r=4.04518
    rnet036_19 (net036_9 net036) resistor r=0.730683
    rnet036_18 (MM0_ELT_s net036_11) resistor r=4.04518
    rnet036_17 (MM0_ELT_s net036_13) resistor r=12.3172
    rnet036_16 (MM0_ELT_s net036_13) resistor r=1.62887
    rnet036_15 (MM0_ELT_s net036_16) resistor r=2.55965
    rnet036_14 (MM0_ELT_s net036_17) resistor r=25.7298
    rnet036_13 (net036_12 net036_13) resistor r=12.3172
    rnet036_12 (net036_12 net036_18) resistor r=10.2363
    rnet036_11 (net036_14 net036_16) resistor r=14.4784
    rnet036_10 (net036_14 net036_17) resistor r=9.04062
    rnet036_9 (net036_15 net036_16) resistor r=14.4784
    rnet036_8 (net036_15 net036) resistor r=10.5593
    rnet038_37 (MM13_ELT_s net038_2) resistor r=25.7298
    rnet038_36 (MM13_ELT_s net038_5) resistor r=2.55965
    rnet038_35 (MM13_ELT_s net038_7) resistor r=12.3172
    rnet038_34 (MM13_ELT_s net038_7) resistor r=1.62887
    rnet038_33 (MM13_ELT_s net038_11) resistor r=4.04518
    rnet038_32 (net038_2 net038_4) resistor r=9.04062
    rnet038_31 (net038_3 net038_5) resistor r=14.4784
    rnet038_30 (net038_3 net038) resistor r=10.5593
    rnet038_29 (net038_4 net038_5) resistor r=14.4784
    rnet038_28 (net038_6 net038_7) resistor r=12.3172
    rnet038_27 (net038_6 net038_20) resistor r=10.2363
    rnet038_26 (net038_8 net038_11) resistor r=4.04518
    rnet038_25 (net038_8 net038_20) resistor r=0.549089
    rnet038_24 (net038_9 net038_11) resistor r=4.04518
    rnet038_23 (net038_9 net038) resistor r=0.730683
    rnet038_22 (MM12_ELT_d net038_11) resistor r=4.04518
    rnet038_21 (MM12_ELT_d net038_14) resistor r=2.55965
    rnet038_20 (MM12_ELT_d net038_16) resistor r=12.3172
    rnet038_19 (MM12_ELT_d net038_16) resistor r=1.62887
    rnet038_18 (MM12_ELT_d net038_19) resistor r=6.12113
    rnet038_17 (MM12_ELT_d net038_20) resistor r=10.2363
    rnet038_16 (net038_12 net038_14) resistor r=14.4784
    rnet038_15 (net038_12 net038_18) resistor r=9.04062
    rnet038_14 (net038_13 net038_14) resistor r=14.4784
    rnet038_13 (net038_13 net038) resistor r=10.5593
    rnet038_12 (net038_15 net038_16) resistor r=12.3172
    rnet038_11 (net038_15 net038_17) resistor r=9.04595
    rnet038_10 (net038_17 net038_19) resistor r=31.2341
    rnet038_9 (net038_18 net038_19) resistor r=31.2341
    rZ_28 (Z_1 Z_3) resistor r=0.399622
    rZ_27 (Z_1 Z_18) resistor r=0.0987376
    rZ_26 (Z_3 Z_4) resistor r=13
    rZ_25 (Z_4 MM8_ELT_d) resistor r=8.44
    rZ_24 (Z_6 Z_8) resistor r=0.522173
    rZ_23 (Z_6 Z_20) resistor r=0.0960744
    rZ_22 (Z_8 Z_9) resistor r=8.66667
    rZ_21 (Z_8 Z_11) resistor r=0.639395
    rZ_20 (Z_9 MM9_ELT_d) resistor r=32.3614
    rZ_19 (Z_11 Z_12) resistor r=8.66667
    rZ_18 (Z_11 Z_14) resistor r=0.426263
    rZ_17 (Z_12 MM9_ELT_d) resistor r=16.1807
    rZ_16 (Z_12 Z_15) resistor r=32.3614
    rZ_15 (Z_14 Z_15) resistor r=26
    rZ_14 (Z_17 Z_18) resistor r=0.197194
    rZ_13 (Z_17 Z_21) resistor r=0.0987376
    rZ_12 (Z_19 Z_20) resistor r=0.232602
    rZ_11 (Z_19 Z_22) resistor r=0.0960744
    rZ_10 (Z_21 Z) resistor r=0.204215
    rZ_9 (Z_22 Z) resistor r=0.242505
    rZN_129 (MM15_ELT_d ZN) resistor r=0.01
    rZN_128 (ZN_22 ZN_28) resistor r=58.3583
    rZN_127 (ZN_22 ZN_28) resistor r=4.16253
    rZN_126 (ZN_22 ZN_28) resistor r=58.3583
    rZN_125 (ZN_22 ZN_28) resistor r=4.16253
    rZN_124 (ZN_25 ZN_28) resistor r=58.3583
    rZN_123 (ZN_25 ZN_28) resistor r=6.30933
    rZN_122 (ZN_25 ZN_28) resistor r=58.3583
    rZN_121 (ZN_25 ZN_28) resistor r=6.30933
    rZN_120 (ZN_28 ZN_30) resistor r=14.9
    rZN_119 (ZN_28 ZN_53) resistor r=24.8333
    rZN_118 (ZN_28 ZN_50) resistor r=24.8333
    rZN_117 (ZN_28 ZN_61) resistor r=24.8333
    rZN_116 (ZN_28 ZN_58) resistor r=24.8333
    rZN_115 (ZN_28 ZN_82) resistor r=58.3583
    rZN_114 (ZN_28 ZN_85) resistor r=58.3583
    rZN_113 (ZN_28 ZN_53) resistor r=4.16253
    rZN_112 (ZN_28 ZN_30) resistor r=6.30933
    rZN_111 (ZN_28 ZN_61) resistor r=1.63969
    rZN_110 (ZN_28 ZN_50) resistor r=4.16253
    rZN_109 (ZN_28 ZN_82) resistor r=4.16253
    rZN_108 (ZN_28 ZN_58) resistor r=4.16253
    rZN_107 (ZN_28 ZN_85) resistor r=4.16253
    rZN_106 (ZN_28 ZN_30) resistor r=14.9
    rZN_105 (ZN_28 ZN_185) resistor r=40.975
    rZN_104 (ZN_28 ZN_53) resistor r=24.8333
    rZN_103 (ZN_28 ZN_50) resistor r=24.8333
    rZN_102 (ZN_28 ZN_61) resistor r=24.8333
    rZN_101 (ZN_28 ZN_58) resistor r=24.8333
    rZN_100 (ZN_28 ZN_82) resistor r=58.3583
    rZN_99 (ZN_28 MM8_ELT_g) resistor r=7.45
    rZN_98 (ZN_28 ZN_53) resistor r=4.16253
    rZN_97 (ZN_28 ZN_30) resistor r=6.30933
    rZN_96 (ZN_28 ZN_61) resistor r=1.63969
    rZN_95 (ZN_28 ZN_50) resistor r=4.16253
    rZN_94 (ZN_28 ZN_82) resistor r=4.16253
    rZN_93 (ZN_28 ZN_58) resistor r=4.16253
    rZN_92 (ZN_28 ZN_85) resistor r=4.16253
    rZN_91 (ZN_36 ZN_39) resistor r=14.9
    rZN_90 (ZN_36 ZN_39) resistor r=6.30933
    rZN_89 (ZN_36 ZN_39) resistor r=14.9
    rZN_88 (ZN_36 ZN_39) resistor r=6.30933
    rZN_87 (ZN_39 ZN_42) resistor r=202.392
    rZN_86 (ZN_39 ZN_45) resistor r=202.392
    rZN_85 (ZN_39 ZN_69) resistor r=24.8333
    rZN_84 (ZN_39 ZN_66) resistor r=24.8333
    rZN_83 (ZN_39 ZN_77) resistor r=24.8333
    rZN_82 (ZN_39 ZN_74) resistor r=24.8333
    rZN_81 (ZN_39 ZN_90) resistor r=202.392
    rZN_80 (ZN_39 ZN_93) resistor r=202.392
    rZN_79 (ZN_39 ZN_42) resistor r=6.30933
    rZN_78 (ZN_39 ZN_69) resistor r=1.63969
    rZN_77 (ZN_39 ZN_77) resistor r=4.16253
    rZN_76 (ZN_39 ZN_45) resistor r=4.16253
    rZN_75 (ZN_39 ZN_66) resistor r=4.16253
    rZN_74 (ZN_39 ZN_90) resistor r=4.16253
    rZN_73 (ZN_39 ZN_74) resistor r=4.16253
    rZN_72 (ZN_39 ZN_93) resistor r=4.16253
    rZN_71 (ZN_39 ZN_187) resistor r=40.975
    rZN_70 (ZN_39 ZN_42) resistor r=202.392
    rZN_69 (ZN_39 ZN_45) resistor r=202.392
    rZN_68 (ZN_39 ZN_69) resistor r=24.8333
    rZN_67 (ZN_39 ZN_66) resistor r=24.8333
    rZN_66 (ZN_39 ZN_77) resistor r=24.8333
    rZN_65 (ZN_39 ZN_74) resistor r=24.8333
    rZN_64 (ZN_39 ZN_90) resistor r=202.392
    rZN_63 (ZN_39 MM9_ELT_g) resistor r=7.45
    rZN_62 (ZN_39 ZN_42) resistor r=6.30933
    rZN_61 (ZN_39 ZN_69) resistor r=1.63969
    rZN_60 (ZN_39 ZN_77) resistor r=4.16253
    rZN_59 (ZN_39 ZN_45) resistor r=4.16253
    rZN_58 (ZN_39 ZN_66) resistor r=4.16253
    rZN_57 (ZN_39 ZN_90) resistor r=4.16253
    rZN_56 (ZN_39 ZN_74) resistor r=4.16253
    rZN_55 (ZN_39 ZN_93) resistor r=4.16253
    rZN_54 (ZN_85 MM8_ELT_g) resistor r=50.9083
    rZN_53 (ZN_93 MM9_ELT_g) resistor r=194.942
    rZN_52 (ZN_131 ZN_133) resistor r=0.399622
    rZN_51 (ZN_131 ZN_148) resistor r=0.0987376
    rZN_50 (ZN_133 ZN_134) resistor r=13
    rZN_49 (ZN_134 MM14_ELT_d) resistor r=8.44
    rZN_48 (ZN_136 ZN_138) resistor r=0.694668
    rZN_47 (ZN_136 ZN_150) resistor r=0.0960744
    rZN_46 (ZN_138 ZN_139) resistor r=8.66667
    rZN_45 (ZN_138 ZN_141) resistor r=0.639395
    rZN_44 (ZN_139 ZN) resistor r=32.3614
    rZN_43 (ZN_141 ZN_142) resistor r=8.66667
    rZN_42 (ZN_141 ZN_144) resistor r=0.426263
    rZN_41 (ZN_142 ZN) resistor r=16.1807
    rZN_40 (ZN_142 ZN_145) resistor r=32.3614
    rZN_39 (ZN_144 ZN_145) resistor r=26
    rZN_38 (ZN_147 ZN_148) resistor r=0.269067
    rZN_37 (ZN_147 ZN_151) resistor r=0.0987376
    rZN_36 (ZN_149 ZN_150) resistor r=0.351042
    rZN_35 (ZN_149 ZN_154) resistor r=0.0960744
    rZN_34 (ZN_151 ZN_152) resistor r=0.107334
    rZN_33 (ZN_152 ZN_160) resistor r=0.0977119
    rZN_32 (ZN_153 ZN_154) resistor r=0.107334
    rZN_31 (ZN_153 ZN_160) resistor r=0.0977119
    rZN_30 (ZN_155 ZN_157) resistor r=0.0221177
    rZN_29 (ZN_155 ZN_160) resistor r=0.000446156
    rZN_28 (ZN_157 ZN_158) resistor r=10
    rZN_27 (ZN_158 ZN_225) resistor r=1.35455
    rZN_26 (ZN_185 ZN_225) resistor r=5.23411
    rZN_25 (ZN_187 ZN_225) resistor r=5.23411
    rVDD_163 (MM2_ELT_b MM5_ELT_b) resistor r=0.01
    rVDD_162 (MM13_ELT_b MM5_ELT_b) resistor r=0.01
    rVDD_161 (MM12_ELT_b MM5_ELT_b) resistor r=0.01
    rVDD_160 (MM6_ELT_b MM5_ELT_b) resistor r=0.01
    rVDD_159 (MM0_ELT_b MM5_ELT_b) resistor r=0.01
    rVDD_158 (MM15_ELT_b MM5_ELT_b) resistor r=0.01
    rVDD_157 (MM9_ELT_b MM5_ELT_b) resistor r=0.01
    rVDD_156 (MM5_ELT_b VDD_42) resistor r=8.66667
    rVDD_155 (MM5_ELT_b VDD_58) resistor r=8.66667
    rVDD_154 (MM5_ELT_b VDD_61) resistor r=8.66667
    rVDD_153 (MM5_ELT_b VDD_76) resistor r=8.66667
    rVDD_152 (MM5_ELT_b VDD_79) resistor r=26
    rVDD_151 (MM5_ELT_b VDD_85) resistor r=45.0133
    rVDD_150 (VDD_2 VDD_7) resistor r=0.134315
    rVDD_149 (VDD_2 VDD_82) resistor r=0.0221408
    rVDD_148 (VDD VDD_7) resistor r=0.102711
    rVDD_147 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_146 (VDD_8 VDD_24) resistor r=67.52
    rVDD_145 (VDD_9 VDD_18) resistor r=0.649339
    rVDD_144 (VDD_9 VDD_82) resistor r=0.0882251
    rVDD_143 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_142 (VDD_11 VDD_15) resistor r=0.701988
    rVDD_141 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_140 (VDD_15 VDD_18) resistor r=0.467992
    rVDD_139 (VDD_18 VDD_19) resistor r=13
    rVDD_138 (VDD_19 MM2_ELT_s) resistor r=4.04518
    rVDD_137 (VDD_19 VDD_124) resistor r=4.04518
    rVDD_136 (VDD_19 MM5_ELT_s) resistor r=4.04518
    rVDD_135 (VDD_19 VDD_122) resistor r=4.04518
    rVDD_134 (VDD_20 VDD_26) resistor r=0.237026
    rVDD_133 (VDD_20 VDD_84) resistor r=0.0221408
    rVDD_132 (VDD_21 VDD_23) resistor r=0.0671574
    rVDD_131 (VDD_21 VDD_82) resistor r=0.0221408
    rVDD_130 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_129 (VDD_23 VDD_26) resistor r=0.237026
    rVDD_128 (VDD_24 VDD_27) resistor r=67.52
    rVDD_127 (VDD_26 VDD_27) resistor r=8.66667
    rVDD_126 (VDD_27 VDD_85) resistor r=67.52
    rVDD_125 (VDD_28 VDD_37) resistor r=0.448853
    rVDD_124 (VDD_28 VDD_84) resistor r=0.0882251
    rVDD_123 (VDD_30 VDD_31) resistor r=8.66667
    rVDD_122 (VDD_30 VDD_34) resistor r=0.58546
    rVDD_121 (VDD_31 MM12_ELT_s) resistor r=32.3614
    rVDD_120 (VDD_34 VDD_35) resistor r=8.66667
    rVDD_119 (VDD_34 VDD_37) resistor r=0.390307
    rVDD_118 (VDD_35 MM12_ELT_s) resistor r=16.1807
    rVDD_117 (VDD_35 VDD_38) resistor r=32.3614
    rVDD_116 (VDD_37 VDD_38) resistor r=26
    rVDD_115 (VDD_39 VDD_42) resistor r=0.0316035
    rVDD_114 (VDD_39 VDD_86) resistor r=0.0221408
    rVDD_113 (VDD_40 VDD_42) resistor r=0.201472
    rVDD_112 (VDD_40 VDD_84) resistor r=0.0221408
    rVDD_111 (VDD_44 VDD_53) resistor r=0.448853
    rVDD_110 (VDD_44 VDD_86) resistor r=0.0882251
    rVDD_109 (VDD_46 VDD_47) resistor r=8.66667
    rVDD_108 (VDD_46 VDD_50) resistor r=0.58546
    rVDD_107 (VDD_47 MM6_ELT_s) resistor r=32.3614
    rVDD_106 (VDD_50 VDD_51) resistor r=8.66667
    rVDD_105 (VDD_50 VDD_53) resistor r=0.390307
    rVDD_104 (VDD_51 MM6_ELT_s) resistor r=16.1807
    rVDD_103 (VDD_51 VDD_54) resistor r=32.3614
    rVDD_102 (VDD_53 VDD_54) resistor r=26
    rVDD_101 (VDD_55 VDD_61) resistor r=0.134315
    rVDD_100 (VDD_55 VDD_87) resistor r=0.0221408
    rVDD_99 (VDD_56 VDD_58) resistor r=0.169869
    rVDD_98 (VDD_56 VDD_86) resistor r=0.0221408
    rVDD_97 (VDD_58 VDD_61) resistor r=0.237026
    rVDD_96 (VDD_63 VDD_72) resistor r=0.649339
    rVDD_95 (VDD_63 VDD_87) resistor r=0.0882251
    rVDD_94 (VDD_65 VDD_73) resistor r=8.66667
    rVDD_93 (VDD_65 VDD_69) resistor r=0.701988
    rVDD_92 (VDD_69 VDD_73) resistor r=8.66667
    rVDD_91 (VDD_69 VDD_72) resistor r=0.467992
    rVDD_90 (VDD_72 VDD_73) resistor r=13
    rVDD_89 (VDD_73 MM9_ELT_s) resistor r=4.04518
    rVDD_88 (VDD_73 VDD_128) resistor r=4.04518
    rVDD_87 (VDD_73 MM15_ELT_s) resistor r=4.04518
    rVDD_86 (VDD_73 VDD_126) resistor r=4.04518
    rVDD_85 (VDD_74 VDD_76) resistor r=0.0671574
    rVDD_84 (VDD_74 VDD_87) resistor r=0.0221408
    rVDD_83 (VDD_76 VDD_79) resistor r=0.158017
    rVDD_82 (VDD_84 VDD_85) resistor r=8.66667
    rVDD_81 (VDD_90 VDD_93) resistor r=31.2341
    rVDD_80 (VDD_90 VDD_94) resistor r=9.04595
    rVDD_79 (VDD_91 VDD_93) resistor r=31.2341
    rVDD_78 (VDD_91 VDD_97) resistor r=9.04062
    rVDD_77 (MM5_ELT_s VDD_93) resistor r=6.12113
    rVDD_76 (MM5_ELT_s VDD_95) resistor r=12.3172
    rVDD_75 (MM5_ELT_s VDD_95) resistor r=1.62887
    rVDD_74 (MM5_ELT_s VDD_98) resistor r=2.55965
    rVDD_73 (MM5_ELT_s VDD_123) resistor r=10.2363
    rVDD_72 (VDD_94 VDD_95) resistor r=12.3172
    rVDD_71 (VDD_96 VDD_98) resistor r=14.4784
    rVDD_70 (VDD_96 VDD_125) resistor r=10.5593
    rVDD_69 (VDD_97 VDD_98) resistor r=14.4784
    rVDD_68 (MM2_ELT_s VDD_101) resistor r=12.3172
    rVDD_67 (MM2_ELT_s VDD_101) resistor r=1.62887
    rVDD_66 (MM2_ELT_s VDD_104) resistor r=2.55965
    rVDD_65 (MM2_ELT_s VDD_105) resistor r=25.7298
    rVDD_64 (VDD_100 VDD_101) resistor r=12.3172
    rVDD_63 (VDD_100 VDD_123) resistor r=10.2363
    rVDD_62 (VDD_102 VDD_104) resistor r=14.4784
    rVDD_61 (VDD_102 VDD_105) resistor r=9.04062
    rVDD_60 (VDD_103 VDD_104) resistor r=14.4784
    rVDD_59 (VDD_103 VDD_125) resistor r=10.5593
    rVDD_58 (MM15_ELT_s VDD_107) resistor r=25.7298
    rVDD_57 (MM15_ELT_s VDD_110) resistor r=2.55965
    rVDD_56 (MM15_ELT_s VDD_112) resistor r=12.3172
    rVDD_55 (MM15_ELT_s VDD_112) resistor r=1.62887
    rVDD_54 (VDD_107 VDD_109) resistor r=9.04062
    rVDD_53 (VDD_108 VDD_110) resistor r=14.4784
    rVDD_52 (VDD_108 VDD_129) resistor r=10.5593
    rVDD_51 (VDD_109 VDD_110) resistor r=14.4784
    rVDD_50 (VDD_111 VDD_112) resistor r=12.3172
    rVDD_49 (VDD_111 VDD_127) resistor r=10.2363
    rVDD_48 (MM9_ELT_s VDD_116) resistor r=2.55965
    rVDD_47 (MM9_ELT_s VDD_118) resistor r=12.3172
    rVDD_46 (MM9_ELT_s VDD_118) resistor r=1.62887
    rVDD_45 (MM9_ELT_s VDD_121) resistor r=6.12113
    rVDD_44 (MM9_ELT_s VDD_127) resistor r=10.2363
    rVDD_43 (VDD_114 VDD_116) resistor r=14.4784
    rVDD_42 (VDD_114 VDD_120) resistor r=9.04062
    rVDD_41 (VDD_115 VDD_116) resistor r=14.4784
    rVDD_40 (VDD_115 VDD_129) resistor r=10.5593
    rVDD_39 (VDD_117 VDD_118) resistor r=12.3172
    rVDD_38 (VDD_117 VDD_119) resistor r=9.04595
    rVDD_37 (VDD_119 VDD_121) resistor r=31.2341
    rVDD_36 (VDD_120 VDD_121) resistor r=31.2341
    rVDD_35 (VDD_122 VDD_123) resistor r=0.549089
    rVDD_34 (VDD_124 VDD_125) resistor r=0.730683
    rVDD_33 (VDD_126 VDD_127) resistor r=0.549089
    rVDD_32 (VDD_128 VDD_129) resistor r=0.730683
    rVSS_145 (MM1_ELT_b MM4_ELT_b) resistor r=0.01
    rVSS_144 (MM3_ELT_b MM4_ELT_b) resistor r=0.01
    rVSS_143 (MM7_ELT_b MM4_ELT_b) resistor r=0.01
    rVSS_142 (MM10_ELT_b MM4_ELT_b) resistor r=0.01
    rVSS_141 (MM11_ELT_b MM4_ELT_b) resistor r=0.01
    rVSS_140 (MM14_ELT_b MM4_ELT_b) resistor r=0.01
    rVSS_139 (MM8_ELT_b MM4_ELT_b) resistor r=0.01
    rVSS_138 (MM4_ELT_b VSS_30) resistor r=8.66667
    rVSS_137 (MM4_ELT_b VSS_40) resistor r=8.66667
    rVSS_136 (MM4_ELT_b VSS_43) resistor r=8.66667
    rVSS_135 (MM4_ELT_b VSS_52) resistor r=8.66667
    rVSS_134 (MM4_ELT_b VSS_55) resistor r=26
    rVSS_133 (MM4_ELT_b VSS_61) resistor r=43.1485
    rVSS_132 (VSS_2 VSS_7) resistor r=0.134315
    rVSS_131 (VSS_2 VSS_58) resistor r=0.0221408
    rVSS_130 (VSS VSS_7) resistor r=0.100881
    rVSS_129 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_128 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_127 (VSS_9 VSS_11) resistor r=0.456261
    rVSS_126 (VSS_9 VSS_58) resistor r=0.0882251
    rVSS_125 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_124 (VSS_12 MM1_ELT_s) resistor r=4.22001
    rVSS_123 (VSS_12 VSS_98) resistor r=4.22001
    rVSS_122 (VSS_12 MM4_ELT_s) resistor r=4.22001
    rVSS_121 (VSS_12 VSS_96) resistor r=4.22001
    rVSS_120 (VSS_14 VSS_20) resistor r=0.237026
    rVSS_119 (VSS_14 VSS_60) resistor r=0.0221408
    rVSS_118 (VSS_15 VSS_17) resistor r=0.0671574
    rVSS_117 (VSS_15 VSS_58) resistor r=0.0221408
    rVSS_116 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_115 (VSS_17 VSS_20) resistor r=0.237026
    rVSS_114 (VSS_18 VSS_21) resistor r=64.7228
    rVSS_113 (VSS_20 VSS_21) resistor r=8.66667
    rVSS_112 (VSS_21 VSS_61) resistor r=64.7228
    rVSS_111 (VSS_22 VSS_24) resistor r=0.370791
    rVSS_110 (VSS_22 VSS_60) resistor r=0.0882251
    rVSS_109 (VSS_24 VSS_25) resistor r=13
    rVSS_108 (VSS_25 MM7_ELT_s) resistor r=8.44
    rVSS_107 (VSS_27 VSS_30) resistor r=0.0316035
    rVSS_106 (VSS_27 VSS_62) resistor r=0.0221408
    rVSS_105 (VSS_28 VSS_30) resistor r=0.201472
    rVSS_104 (VSS_28 VSS_60) resistor r=0.0221408
    rVSS_103 (VSS_32 VSS_34) resistor r=0.370791
    rVSS_102 (VSS_32 VSS_62) resistor r=0.0882251
    rVSS_101 (VSS_34 VSS_35) resistor r=13
    rVSS_100 (VSS_35 MM10_ELT_s) resistor r=8.44
    rVSS_99 (VSS_37 VSS_43) resistor r=0.134315
    rVSS_98 (VSS_37 VSS_63) resistor r=0.0221408
    rVSS_97 (VSS_38 VSS_40) resistor r=0.169869
    rVSS_96 (VSS_38 VSS_62) resistor r=0.0221408
    rVSS_95 (VSS_40 VSS_43) resistor r=0.237026
    rVSS_94 (VSS_45 VSS_47) resistor r=0.444593
    rVSS_93 (VSS_45 VSS_63) resistor r=0.0882251
    rVSS_92 (VSS_47 VSS_48) resistor r=8.66667
    rVSS_91 (VSS_48 MM8_ELT_s) resistor r=4.22001
    rVSS_90 (VSS_48 VSS_102) resistor r=4.22001
    rVSS_89 (VSS_48 MM14_ELT_s) resistor r=4.22001
    rVSS_88 (VSS_48 VSS_100) resistor r=4.22001
    rVSS_87 (VSS_50 VSS_52) resistor r=0.0671574
    rVSS_86 (VSS_50 VSS_63) resistor r=0.0221408
    rVSS_85 (VSS_52 VSS_55) resistor r=0.158017
    rVSS_84 (VSS_60 VSS_61) resistor r=8.66667
    rVSS_83 (VSS_64 VSS_67) resistor r=21.1301
    rVSS_82 (VSS_64 VSS_69) resistor r=9.43134
    rVSS_81 (VSS_65 VSS_67) resistor r=21.1301
    rVSS_80 (VSS_65 VSS_71) resistor r=9.4369
    rVSS_79 (MM4_ELT_s VSS_67) resistor r=4.557
    rVSS_78 (MM4_ELT_s VSS_70) resistor r=2.67027
    rVSS_77 (MM4_ELT_s VSS_72) resistor r=12.8495
    rVSS_76 (MM4_ELT_s VSS_72) resistor r=1.69926
    rVSS_75 (MM4_ELT_s VSS_99) resistor r=10.6787
    rVSS_74 (VSS_68 VSS_70) resistor r=15.1041
    rVSS_73 (VSS_68 VSS_97) resistor r=11.0157
    rVSS_72 (VSS_69 VSS_70) resistor r=15.1041
    rVSS_71 (VSS_71 VSS_72) resistor r=12.8495
    rVSS_70 (MM1_ELT_s VSS_76) resistor r=2.67027
    rVSS_69 (MM1_ELT_s VSS_78) resistor r=12.8495
    rVSS_68 (MM1_ELT_s VSS_78) resistor r=1.69926
    rVSS_67 (MM1_ELT_s VSS_79) resistor r=18.0507
    rVSS_66 (VSS_74 VSS_76) resistor r=15.1041
    rVSS_65 (VSS_74 VSS_79) resistor r=9.43134
    rVSS_64 (VSS_75 VSS_76) resistor r=15.1041
    rVSS_63 (VSS_75 VSS_97) resistor r=11.0157
    rVSS_62 (VSS_77 VSS_78) resistor r=12.8495
    rVSS_61 (VSS_77 VSS_99) resistor r=10.6787
    rVSS_60 (MM14_ELT_s VSS_81) resistor r=18.0507
    rVSS_59 (MM14_ELT_s VSS_84) resistor r=2.67027
    rVSS_58 (MM14_ELT_s VSS_86) resistor r=12.8495
    rVSS_57 (MM14_ELT_s VSS_86) resistor r=1.69926
    rVSS_56 (VSS_81 VSS_83) resistor r=9.43134
    rVSS_55 (VSS_82 VSS_84) resistor r=15.1041
    rVSS_54 (VSS_82 VSS_101) resistor r=11.0157
    rVSS_53 (VSS_83 VSS_84) resistor r=15.1041
    rVSS_52 (VSS_85 VSS_86) resistor r=12.8495
    rVSS_51 (VSS_85 VSS_103) resistor r=10.6787
    rVSS_50 (MM8_ELT_s VSS_90) resistor r=2.67027
    rVSS_49 (MM8_ELT_s VSS_92) resistor r=12.8495
    rVSS_48 (MM8_ELT_s VSS_92) resistor r=1.69926
    rVSS_47 (MM8_ELT_s VSS_95) resistor r=4.557
    rVSS_46 (MM8_ELT_s VSS_103) resistor r=10.6787
    rVSS_45 (VSS_88 VSS_90) resistor r=15.1041
    rVSS_44 (VSS_88 VSS_93) resistor r=9.43134
    rVSS_43 (VSS_89 VSS_90) resistor r=15.1041
    rVSS_42 (VSS_89 VSS_101) resistor r=11.0157
    rVSS_41 (VSS_91 VSS_92) resistor r=12.8495
    rVSS_40 (VSS_91 VSS_94) resistor r=9.4369
    rVSS_39 (VSS_93 VSS_95) resistor r=21.1301
    rVSS_38 (VSS_94 VSS_95) resistor r=21.1301
    rVSS_37 (VSS_96 VSS_97) resistor r=0.762262
    rVSS_36 (VSS_98 VSS_99) resistor r=0.57282
    rVSS_35 (VSS_100 VSS_101) resistor r=0.762262
    rVSS_34 (VSS_102 VSS_103) resistor r=0.57282
    rXOR1_159 (MM0_ELT_d XOR1) resistor r=0.01
    rXOR1_158 (XOR1_22 XOR1_28) resistor r=58.3583
    rXOR1_157 (XOR1_22 XOR1_28) resistor r=4.16253
    rXOR1_156 (XOR1_22 XOR1_28) resistor r=58.3583
    rXOR1_155 (XOR1_22 XOR1_28) resistor r=4.16253
    rXOR1_154 (XOR1_25 XOR1_28) resistor r=58.3583
    rXOR1_153 (XOR1_25 XOR1_28) resistor r=6.30933
    rXOR1_152 (XOR1_25 XOR1_28) resistor r=58.3583
    rXOR1_151 (XOR1_25 XOR1_28) resistor r=6.30933
    rXOR1_150 (XOR1_28 XOR1_30) resistor r=14.9
    rXOR1_149 (XOR1_28 XOR1_53) resistor r=24.8333
    rXOR1_148 (XOR1_28 XOR1_50) resistor r=24.8333
    rXOR1_147 (XOR1_28 XOR1_61) resistor r=24.8333
    rXOR1_146 (XOR1_28 XOR1_58) resistor r=24.8333
    rXOR1_145 (XOR1_28 XOR1_82) resistor r=58.3583
    rXOR1_144 (XOR1_28 XOR1_85) resistor r=58.3583
    rXOR1_143 (XOR1_28 XOR1_53) resistor r=4.16253
    rXOR1_142 (XOR1_28 XOR1_30) resistor r=6.30933
    rXOR1_141 (XOR1_28 XOR1_61) resistor r=1.63969
    rXOR1_140 (XOR1_28 XOR1_50) resistor r=4.16253
    rXOR1_139 (XOR1_28 XOR1_82) resistor r=4.16253
    rXOR1_138 (XOR1_28 XOR1_58) resistor r=4.16253
    rXOR1_137 (XOR1_28 XOR1_85) resistor r=4.16253
    rXOR1_136 (XOR1_28 XOR1_30) resistor r=14.9
    rXOR1_135 (XOR1_28 XOR1_213) resistor r=40.975
    rXOR1_134 (XOR1_28 XOR1_53) resistor r=24.8333
    rXOR1_133 (XOR1_28 XOR1_50) resistor r=24.8333
    rXOR1_132 (XOR1_28 XOR1_61) resistor r=24.8333
    rXOR1_131 (XOR1_28 XOR1_58) resistor r=24.8333
    rXOR1_130 (XOR1_28 XOR1_82) resistor r=58.3583
    rXOR1_129 (XOR1_28 MM14_ELT_g) resistor r=7.45
    rXOR1_128 (XOR1_28 XOR1_53) resistor r=4.16253
    rXOR1_127 (XOR1_28 XOR1_30) resistor r=6.30933
    rXOR1_126 (XOR1_28 XOR1_61) resistor r=1.63969
    rXOR1_125 (XOR1_28 XOR1_50) resistor r=4.16253
    rXOR1_124 (XOR1_28 XOR1_82) resistor r=4.16253
    rXOR1_123 (XOR1_28 XOR1_58) resistor r=4.16253
    rXOR1_122 (XOR1_28 XOR1_85) resistor r=4.16253
    rXOR1_121 (XOR1_36 XOR1_39) resistor r=14.9
    rXOR1_120 (XOR1_36 XOR1_39) resistor r=6.30933
    rXOR1_119 (XOR1_36 XOR1_39) resistor r=14.9
    rXOR1_118 (XOR1_36 XOR1_39) resistor r=6.30933
    rXOR1_117 (XOR1_39 XOR1_42) resistor r=202.392
    rXOR1_116 (XOR1_39 XOR1_45) resistor r=202.392
    rXOR1_115 (XOR1_39 XOR1_69) resistor r=24.8333
    rXOR1_114 (XOR1_39 XOR1_66) resistor r=24.8333
    rXOR1_113 (XOR1_39 XOR1_77) resistor r=24.8333
    rXOR1_112 (XOR1_39 XOR1_74) resistor r=24.8333
    rXOR1_111 (XOR1_39 XOR1_90) resistor r=202.392
    rXOR1_110 (XOR1_39 XOR1_93) resistor r=202.392
    rXOR1_109 (XOR1_39 XOR1_42) resistor r=6.30933
    rXOR1_108 (XOR1_39 XOR1_69) resistor r=1.63969
    rXOR1_107 (XOR1_39 XOR1_77) resistor r=4.16253
    rXOR1_106 (XOR1_39 XOR1_45) resistor r=4.16253
    rXOR1_105 (XOR1_39 XOR1_66) resistor r=4.16253
    rXOR1_104 (XOR1_39 XOR1_90) resistor r=4.16253
    rXOR1_103 (XOR1_39 XOR1_74) resistor r=4.16253
    rXOR1_102 (XOR1_39 XOR1_93) resistor r=4.16253
    rXOR1_101 (XOR1_39 XOR1_215) resistor r=40.975
    rXOR1_100 (XOR1_39 XOR1_42) resistor r=202.392
    rXOR1_99 (XOR1_39 XOR1_45) resistor r=202.392
    rXOR1_98 (XOR1_39 XOR1_69) resistor r=24.8333
    rXOR1_97 (XOR1_39 XOR1_66) resistor r=24.8333
    rXOR1_96 (XOR1_39 XOR1_77) resistor r=24.8333
    rXOR1_95 (XOR1_39 XOR1_74) resistor r=24.8333
    rXOR1_94 (XOR1_39 XOR1_90) resistor r=202.392
    rXOR1_93 (XOR1_39 MM15_ELT_g) resistor r=7.45
    rXOR1_92 (XOR1_39 XOR1_42) resistor r=6.30933
    rXOR1_91 (XOR1_39 XOR1_69) resistor r=1.63969
    rXOR1_90 (XOR1_39 XOR1_77) resistor r=4.16253
    rXOR1_89 (XOR1_39 XOR1_45) resistor r=4.16253
    rXOR1_88 (XOR1_39 XOR1_66) resistor r=4.16253
    rXOR1_87 (XOR1_39 XOR1_90) resistor r=4.16253
    rXOR1_86 (XOR1_39 XOR1_74) resistor r=4.16253
    rXOR1_85 (XOR1_39 XOR1_93) resistor r=4.16253
    rXOR1_84 (XOR1_85 MM14_ELT_g) resistor r=50.9083
    rXOR1_83 (XOR1_93 MM15_ELT_g) resistor r=194.942
    rXOR1_82 (XOR1_131 XOR1_132) resistor r=0.589892
    rXOR1_81 (XOR1_131 XOR1_180) resistor r=0.0189976
    rXOR1_80 (XOR1_132 XOR1_184) resistor r=0.0404316
    rXOR1_79 (XOR1_133 XOR1_135) resistor r=0.372398
    rXOR1_78 (XOR1_133 XOR1_182) resistor r=0.0189976
    rXOR1_77 (XOR1_135 XOR1_136) resistor r=13
    rXOR1_76 (XOR1_136 MM3_ELT_d) resistor r=8.44
    rXOR1_75 (XOR1_138 XOR1_140) resistor r=0.446877
    rXOR1_74 (XOR1_138 XOR1_186) resistor r=0.0404316
    rXOR1_73 (XOR1_140 XOR1_141) resistor r=8.66667
    rXOR1_72 (XOR1_140 XOR1_143) resistor r=0.58546
    rXOR1_71 (XOR1_141 MM13_ELT_d) resistor r=32.3614
    rXOR1_70 (XOR1_143 XOR1_144) resistor r=8.66667
    rXOR1_69 (XOR1_143 XOR1_146) resistor r=0.390307
    rXOR1_68 (XOR1_144 MM13_ELT_d) resistor r=16.1807
    rXOR1_67 (XOR1_144 XOR1_147) resistor r=32.3614
    rXOR1_66 (XOR1_146 XOR1_147) resistor r=26
    rXOR1_65 (XOR1_149 XOR1_150) resistor r=1.84396
    rXOR1_64 (XOR1_149 XOR1_187) resistor r=0.052684
    rXOR1_63 (XOR1_150 XOR1_186) resistor r=0.045344
    rXOR1_62 (XOR1_151 XOR1_153) resistor r=0.365912
    rXOR1_61 (XOR1_151 XOR1_168) resistor r=0.0961927
    rXOR1_60 (XOR1_153 XOR1_154) resistor r=13
    rXOR1_59 (XOR1_154 MM11_ELT_d) resistor r=8.44
    rXOR1_58 (XOR1_156 XOR1_158) resistor r=0.439095
    rXOR1_57 (XOR1_156 XOR1_187) resistor r=0.0381804
    rXOR1_56 (XOR1_158 XOR1_159) resistor r=8.66667
    rXOR1_55 (XOR1_158 XOR1_161) resistor r=0.58546
    rXOR1_54 (XOR1_159 XOR1) resistor r=32.3614
    rXOR1_53 (XOR1_161 XOR1_162) resistor r=8.66667
    rXOR1_52 (XOR1_161 XOR1_164) resistor r=0.390307
    rXOR1_51 (XOR1_162 XOR1) resistor r=16.1807
    rXOR1_50 (XOR1_162 XOR1_165) resistor r=32.3614
    rXOR1_49 (XOR1_164 XOR1_165) resistor r=26
    rXOR1_48 (XOR1_167 XOR1_168) resistor r=0.459178
    rXOR1_47 (XOR1_167 XOR1_171) resistor r=0.0961927
    rXOR1_46 (XOR1_169 XOR1_170) resistor r=0.413134
    rXOR1_45 (XOR1_169 XOR1_174) resistor r=0.0994998
    rXOR1_44 (XOR1_170 XOR1_187) resistor r=0.052684
    rXOR1_43 (XOR1_171 XOR1_172) resistor r=0.172306
    rXOR1_42 (XOR1_172 XOR1_188) resistor r=0.0977119
    rXOR1_41 (XOR1_173 XOR1_174) resistor r=0.107334
    rXOR1_40 (XOR1_173 XOR1_188) resistor r=0.0977119
    rXOR1_39 (XOR1_175 XOR1_177) resistor r=0.0221177
    rXOR1_38 (XOR1_175 XOR1_188) resistor r=0.000446156
    rXOR1_37 (XOR1_177 XOR1_178) resistor r=10
    rXOR1_36 (XOR1_178 XOR1_215) resistor r=10.0997
    rXOR1_35 (XOR1_178 XOR1_213) resistor r=10.0997
    rXOR1_34 (XOR1_180 XOR1_182) resistor r=0.105303
    rXOR1_33 (XOR1_184 XOR1_186) resistor r=0.0973178
    rA1N_140 (MM2_ELT_d A1N) resistor r=0.01
    rA1N_139 (A1N_22 A1N_28) resistor r=58.3583
    rA1N_138 (A1N_22 A1N_28) resistor r=4.16253
    rA1N_137 (A1N_22 A1N_28) resistor r=58.3583
    rA1N_136 (A1N_22 A1N_28) resistor r=4.16253
    rA1N_135 (A1N_25 A1N_28) resistor r=58.3583
    rA1N_134 (A1N_25 A1N_28) resistor r=4.16253
    rA1N_133 (A1N_25 A1N_28) resistor r=58.3583
    rA1N_132 (A1N_25 A1N_28) resistor r=4.16253
    rA1N_131 (A1N_28 A1N_41) resistor r=24.8333
    rA1N_130 (A1N_28 A1N_38) resistor r=24.8333
    rA1N_129 (A1N_28 A1N_49) resistor r=24.8333
    rA1N_128 (A1N_28 A1N_46) resistor r=24.8333
    rA1N_127 (A1N_28 A1N_70) resistor r=58.3583
    rA1N_126 (A1N_28 A1N_73) resistor r=58.3583
    rA1N_125 (A1N_28 A1N_78) resistor r=14.9
    rA1N_124 (A1N_28 A1N_41) resistor r=4.16253
    rA1N_123 (A1N_28 A1N_49) resistor r=4.16253
    rA1N_122 (A1N_28 A1N_38) resistor r=4.16253
    rA1N_121 (A1N_28 A1N_70) resistor r=4.16253
    rA1N_120 (A1N_28 A1N_78) resistor r=6.30933
    rA1N_119 (A1N_28 A1N_73) resistor r=6.30933
    rA1N_118 (A1N_28 A1N_46) resistor r=1.63969
    rA1N_117 (A1N_28 A1N_41) resistor r=24.8333
    rA1N_116 (A1N_28 A1N_38) resistor r=24.8333
    rA1N_115 (A1N_28 A1N_49) resistor r=24.8333
    rA1N_114 (A1N_28 A1N_46) resistor r=24.8333
    rA1N_113 (A1N_28 A1N_70) resistor r=58.3583
    rA1N_112 (A1N_28 MM11_ELT_g) resistor r=22.35
    rA1N_111 (A1N_28 A1N_78) resistor r=14.9
    rA1N_110 (A1N_28 A1N_217) resistor r=40.975
    rA1N_109 (A1N_28 A1N_41) resistor r=4.16253
    rA1N_108 (A1N_28 A1N_49) resistor r=4.16253
    rA1N_107 (A1N_28 A1N_38) resistor r=4.16253
    rA1N_106 (A1N_28 A1N_70) resistor r=4.16253
    rA1N_105 (A1N_28 A1N_78) resistor r=6.30933
    rA1N_104 (A1N_28 A1N_73) resistor r=6.30933
    rA1N_103 (A1N_28 A1N_46) resistor r=1.63969
    rA1N_102 (A1N_30 A1N_36) resistor r=202.392
    rA1N_101 (A1N_30 A1N_36) resistor r=4.16253
    rA1N_100 (A1N_30 A1N_36) resistor r=202.392
    rA1N_99 (A1N_30 A1N_36) resistor r=4.16253
    rA1N_98 (A1N_33 A1N_36) resistor r=202.392
    rA1N_97 (A1N_33 A1N_36) resistor r=4.16253
    rA1N_96 (A1N_33 A1N_36) resistor r=202.392
    rA1N_95 (A1N_33 A1N_36) resistor r=4.16253
    rA1N_94 (A1N_36 A1N_57) resistor r=24.8333
    rA1N_93 (A1N_36 A1N_54) resistor r=24.8333
    rA1N_92 (A1N_36 A1N_65) resistor r=24.8333
    rA1N_91 (A1N_36 A1N_62) resistor r=24.8333
    rA1N_90 (A1N_36 A1N_84) resistor r=14.9
    rA1N_89 (A1N_36 A1N_90) resistor r=202.392
    rA1N_88 (A1N_36 A1N_93) resistor r=202.392
    rA1N_87 (A1N_36 A1N_57) resistor r=4.16253
    rA1N_86 (A1N_36 A1N_65) resistor r=4.16253
    rA1N_85 (A1N_36 A1N_90) resistor r=6.30933
    rA1N_84 (A1N_36 A1N_84) resistor r=6.30933
    rA1N_83 (A1N_36 A1N_54) resistor r=1.63969
    rA1N_82 (A1N_36 A1N_62) resistor r=4.16253
    rA1N_81 (A1N_36 A1N_93) resistor r=4.16253
    rA1N_80 (A1N_36 A1N_57) resistor r=24.8333
    rA1N_79 (A1N_36 A1N_54) resistor r=24.8333
    rA1N_78 (A1N_36 A1N_65) resistor r=24.8333
    rA1N_77 (A1N_36 A1N_62) resistor r=24.8333
    rA1N_76 (A1N_36 A1N_219) resistor r=40.975
    rA1N_75 (A1N_36 A1N_84) resistor r=14.9
    rA1N_74 (A1N_36 A1N_90) resistor r=202.392
    rA1N_73 (A1N_36 MM0_ELT_g) resistor r=7.45
    rA1N_72 (A1N_36 A1N_57) resistor r=4.16253
    rA1N_71 (A1N_36 A1N_65) resistor r=4.16253
    rA1N_70 (A1N_36 A1N_90) resistor r=6.30933
    rA1N_69 (A1N_36 A1N_84) resistor r=6.30933
    rA1N_68 (A1N_36 A1N_54) resistor r=1.63969
    rA1N_67 (A1N_36 A1N_62) resistor r=4.16253
    rA1N_66 (A1N_36 A1N_93) resistor r=4.16253
    rA1N_65 (A1N_73 MM11_ELT_g) resistor r=36.0083
    rA1N_64 (A1N_93 MM0_ELT_g) resistor r=194.942
    rA1N_63 (A1N_131 A1N_133) resistor r=0.303713
    rA1N_62 (A1N_131 A1N_148) resistor r=0.0987376
    rA1N_61 (A1N_133 A1N_134) resistor r=13
    rA1N_60 (A1N_134 MM1_ELT_d) resistor r=8.44
    rA1N_59 (A1N_136 A1N_138) resistor r=0.341011
    rA1N_58 (A1N_136 A1N_150) resistor r=0.0968695
    rA1N_57 (A1N_138 A1N_139) resistor r=8.66667
    rA1N_56 (A1N_138 A1N_141) resistor r=0.639395
    rA1N_55 (A1N_139 A1N) resistor r=32.3614
    rA1N_54 (A1N_141 A1N_142) resistor r=8.66667
    rA1N_53 (A1N_141 A1N_144) resistor r=0.426263
    rA1N_52 (A1N_142 A1N) resistor r=16.1807
    rA1N_51 (A1N_142 A1N_145) resistor r=32.3614
    rA1N_50 (A1N_144 A1N_145) resistor r=26
    rA1N_49 (A1N_147 A1N_148) resistor r=0.229306
    rA1N_48 (A1N_147 A1N_151) resistor r=0.0969519
    rA1N_47 (A1N_149 A1N_150) resistor r=0.23398
    rA1N_46 (A1N_149 A1N_152) resistor r=0.0959028
    rA1N_45 (A1N_151 A1N_156) resistor r=0.483911
    rA1N_44 (A1N_152 A1N_156) resistor r=0.20159
    rA1N_43 (A1N_153 A1N_155) resistor r=0.0389504
    rA1N_42 (A1N_153 A1N_171) resistor r=0.0579996
    rA1N_41 (A1N_155 A1N_156) resistor r=0.75
    rA1N_40 (A1N_160 A1N_161) resistor r=1.94528
    rA1N_39 (A1N_160 A1N_168) resistor r=0.0765295
    rA1N_38 (A1N_161 A1N_171) resistor r=0.0150731
    rA1N_37 (A1N_162 A1N_164) resistor r=0.045557
    rA1N_36 (A1N_162 A1N_172) resistor r=0.0579996
    rA1N_35 (A1N_164 A1N_165) resistor r=0.75
    rA1N_34 (A1N_165 A1N_238) resistor r=10
    rA1N_33 (A1N_167 A1N_168) resistor r=0.112956
    rA1N_32 (A1N_167 A1N_172) resistor r=0.0150731
    rA1N_31 (A1N_217 A1N_241) resistor r=5.23411
    rA1N_30 (A1N_219 A1N_241) resistor r=5.23411
    rA1N_29 (A1N_238 A1N_241) resistor r=6.77273
    rA1_191 (A1_42 A1_48) resistor r=58.3583
    rA1_190 (A1_42 A1_48) resistor r=4.16253
    rA1_189 (A1_42 A1_48) resistor r=58.3583
    rA1_188 (A1_42 A1_48) resistor r=4.16253
    rA1_187 (A1_45 A1_48) resistor r=58.3583
    rA1_186 (A1_45 A1_48) resistor r=4.16253
    rA1_185 (A1_45 A1_48) resistor r=58.3583
    rA1_184 (A1_45 A1_48) resistor r=4.16253
    rA1_183 (A1_48 A1_61) resistor r=24.8333
    rA1_182 (A1_48 A1_58) resistor r=24.8333
    rA1_181 (A1_48 A1_69) resistor r=24.8333
    rA1_180 (A1_48 A1_66) resistor r=24.8333
    rA1_179 (A1_48 A1_90) resistor r=58.3583
    rA1_178 (A1_48 A1_93) resistor r=58.3583
    rA1_177 (A1_48 A1_98) resistor r=14.9
    rA1_176 (A1_48 A1_61) resistor r=4.16253
    rA1_175 (A1_48 A1_69) resistor r=4.16253
    rA1_174 (A1_48 A1_58) resistor r=4.16253
    rA1_173 (A1_48 A1_90) resistor r=4.16253
    rA1_172 (A1_48 A1_98) resistor r=6.30933
    rA1_171 (A1_48 A1_93) resistor r=6.30933
    rA1_170 (A1_48 A1_66) resistor r=1.63969
    rA1_169 (A1_48 A1_61) resistor r=24.8333
    rA1_168 (A1_48 A1_58) resistor r=24.8333
    rA1_167 (A1_48 A1_69) resistor r=24.8333
    rA1_166 (A1_48 A1_66) resistor r=24.8333
    rA1_165 (A1_48 A1_90) resistor r=58.3583
    rA1_164 (A1_48 MM1_ELT_g) resistor r=22.35
    rA1_163 (A1_48 A1_98) resistor r=14.9
    rA1_162 (A1_48 A1_332) resistor r=40.975
    rA1_161 (A1_48 A1_61) resistor r=4.16253
    rA1_160 (A1_48 A1_69) resistor r=4.16253
    rA1_159 (A1_48 A1_58) resistor r=4.16253
    rA1_158 (A1_48 A1_90) resistor r=4.16253
    rA1_157 (A1_48 A1_98) resistor r=6.30933
    rA1_156 (A1_48 A1_93) resistor r=6.30933
    rA1_155 (A1_48 A1_66) resistor r=1.63969
    rA1_154 (A1_50 A1_56) resistor r=202.392
    rA1_153 (A1_50 A1_56) resistor r=4.16253
    rA1_152 (A1_50 A1_56) resistor r=202.392
    rA1_151 (A1_50 A1_56) resistor r=4.16253
    rA1_150 (A1_53 A1_56) resistor r=202.392
    rA1_149 (A1_53 A1_56) resistor r=4.16253
    rA1_148 (A1_53 A1_56) resistor r=202.392
    rA1_147 (A1_53 A1_56) resistor r=4.16253
    rA1_146 (A1_56 A1_77) resistor r=24.8333
    rA1_145 (A1_56 A1_74) resistor r=24.8333
    rA1_144 (A1_56 A1_85) resistor r=24.8333
    rA1_143 (A1_56 A1_82) resistor r=24.8333
    rA1_142 (A1_56 A1_104) resistor r=14.9
    rA1_141 (A1_56 A1_110) resistor r=202.392
    rA1_140 (A1_56 A1_113) resistor r=202.392
    rA1_139 (A1_56 A1_77) resistor r=4.16253
    rA1_138 (A1_56 A1_85) resistor r=4.16253
    rA1_137 (A1_56 A1_110) resistor r=6.30933
    rA1_136 (A1_56 A1_104) resistor r=6.30933
    rA1_135 (A1_56 A1_74) resistor r=1.63969
    rA1_134 (A1_56 A1_82) resistor r=4.16253
    rA1_133 (A1_56 A1_113) resistor r=4.16253
    rA1_132 (A1_56 A1_77) resistor r=24.8333
    rA1_131 (A1_56 A1_74) resistor r=24.8333
    rA1_130 (A1_56 A1_85) resistor r=24.8333
    rA1_129 (A1_56 A1_82) resistor r=24.8333
    rA1_128 (A1_56 A1_334) resistor r=40.975
    rA1_127 (A1_56 A1_104) resistor r=14.9
    rA1_126 (A1_56 A1_110) resistor r=202.392
    rA1_125 (A1_56 MM2_ELT_g) resistor r=7.45
    rA1_124 (A1_56 A1_77) resistor r=4.16253
    rA1_123 (A1_56 A1_85) resistor r=4.16253
    rA1_122 (A1_56 A1_110) resistor r=6.30933
    rA1_121 (A1_56 A1_104) resistor r=6.30933
    rA1_120 (A1_56 A1_74) resistor r=1.63969
    rA1_119 (A1_56 A1_82) resistor r=4.16253
    rA1_118 (A1_56 A1_113) resistor r=4.16253
    rA1_117 (A1_93 MM1_ELT_g) resistor r=36.0083
    rA1_116 (A1_113 MM2_ELT_g) resistor r=194.942
    rA1_115 (A1_118 A1_124) resistor r=58.3583
    rA1_114 (A1_118 A1_124) resistor r=4.16253
    rA1_113 (A1_118 A1_124) resistor r=58.3583
    rA1_112 (A1_118 A1_124) resistor r=4.16253
    rA1_111 (A1_121 A1_124) resistor r=58.3583
    rA1_110 (A1_121 A1_124) resistor r=6.30933
    rA1_109 (A1_121 A1_124) resistor r=58.3583
    rA1_108 (A1_121 A1_124) resistor r=6.30933
    rA1_107 (A1_124 A1_126) resistor r=14.9
    rA1_106 (A1_124 A1_149) resistor r=24.8333
    rA1_105 (A1_124 A1_146) resistor r=24.8333
    rA1_104 (A1_124 A1_157) resistor r=24.8333
    rA1_103 (A1_124 A1_154) resistor r=24.8333
    rA1_102 (A1_124 A1_178) resistor r=58.3583
    rA1_101 (A1_124 A1_181) resistor r=58.3583
    rA1_100 (A1_124 A1_149) resistor r=4.16253
    rA1_99 (A1_124 A1_126) resistor r=6.30933
    rA1_98 (A1_124 A1_157) resistor r=1.63969
    rA1_97 (A1_124 A1_146) resistor r=4.16253
    rA1_96 (A1_124 A1_178) resistor r=4.16253
    rA1_95 (A1_124 A1_154) resistor r=4.16253
    rA1_94 (A1_124 A1_181) resistor r=4.16253
    rA1_93 (A1_124 A1_126) resistor r=14.9
    rA1_92 (A1_124 A1_348) resistor r=40.975
    rA1_91 (A1_124 A1_149) resistor r=24.8333
    rA1_90 (A1_124 A1_146) resistor r=24.8333
    rA1_89 (A1_124 A1_157) resistor r=24.8333
    rA1_88 (A1_124 A1_154) resistor r=24.8333
    rA1_87 (A1_124 A1_178) resistor r=58.3583
    rA1_86 (A1_124 MM3_ELT_g) resistor r=7.45
    rA1_85 (A1_124 A1_149) resistor r=4.16253
    rA1_84 (A1_124 A1_126) resistor r=6.30933
    rA1_83 (A1_124 A1_157) resistor r=1.63969
    rA1_82 (A1_124 A1_146) resistor r=4.16253
    rA1_81 (A1_124 A1_178) resistor r=4.16253
    rA1_80 (A1_124 A1_154) resistor r=4.16253
    rA1_79 (A1_124 A1_181) resistor r=4.16253
    rA1_78 (A1_132 A1_135) resistor r=14.9
    rA1_77 (A1_132 A1_135) resistor r=6.30933
    rA1_76 (A1_132 A1_135) resistor r=14.9
    rA1_75 (A1_132 A1_135) resistor r=6.30933
    rA1_74 (A1_135 A1_138) resistor r=202.392
    rA1_73 (A1_135 A1_141) resistor r=202.392
    rA1_72 (A1_135 A1_165) resistor r=24.8333
    rA1_71 (A1_135 A1_162) resistor r=24.8333
    rA1_70 (A1_135 A1_173) resistor r=24.8333
    rA1_69 (A1_135 A1_170) resistor r=24.8333
    rA1_68 (A1_135 A1_186) resistor r=202.392
    rA1_67 (A1_135 A1_189) resistor r=202.392
    rA1_66 (A1_135 A1_138) resistor r=6.30933
    rA1_65 (A1_135 A1_165) resistor r=1.63969
    rA1_64 (A1_135 A1_173) resistor r=4.16253
    rA1_63 (A1_135 A1_141) resistor r=4.16253
    rA1_62 (A1_135 A1_162) resistor r=4.16253
    rA1_61 (A1_135 A1_186) resistor r=4.16253
    rA1_60 (A1_135 A1_170) resistor r=4.16253
    rA1_59 (A1_135 A1_189) resistor r=4.16253
    rA1_58 (A1_135 A1_350) resistor r=40.975
    rA1_57 (A1_135 A1_138) resistor r=202.392
    rA1_56 (A1_135 A1_141) resistor r=202.392
    rA1_55 (A1_135 A1_165) resistor r=24.8333
    rA1_54 (A1_135 A1_162) resistor r=24.8333
    rA1_53 (A1_135 A1_173) resistor r=24.8333
    rA1_52 (A1_135 A1_170) resistor r=24.8333
    rA1_51 (A1_135 A1_186) resistor r=202.392
    rA1_50 (A1_135 MM13_ELT_g) resistor r=7.45
    rA1_49 (A1_135 A1_138) resistor r=6.30933
    rA1_48 (A1_135 A1_165) resistor r=1.63969
    rA1_47 (A1_135 A1_173) resistor r=4.16253
    rA1_46 (A1_135 A1_141) resistor r=4.16253
    rA1_45 (A1_135 A1_162) resistor r=4.16253
    rA1_44 (A1_135 A1_186) resistor r=4.16253
    rA1_43 (A1_135 A1_170) resistor r=4.16253
    rA1_42 (A1_135 A1_189) resistor r=4.16253
    rA1_41 (A1_181 MM3_ELT_g) resistor r=50.9083
    rA1_40 (A1_189 MM13_ELT_g) resistor r=194.942
    rA1_39 (A1_262 A1_263) resistor r=10
    rA1_38 (A1_262 A1) resistor r=0.0846027
    rA1_37 (A1_263 A1_384) resistor r=33.8636
    rA1_36 (A1_332 A1_385) resistor r=3.725
    rA1_35 (A1_334 A1_385) resistor r=3.725
    rA1_34 (A1_342 A1_343) resistor r=48.7636
    rA1_33 (A1_342 A1_390) resistor r=0.877078
    rA1_32 (A1_343 A1_385) resistor r=3.725
    rA1_31 (A1_348 A1_390) resistor r=10.0997
    rA1_30 (A1_350 A1_390) resistor r=10.0997
    rA1_29 (A1_384 A1_385) resistor r=3.725
    rA2N_145 (MM5_ELT_d A2N) resistor r=0.01
    rA2N_144 (A2N_22 A2N_25) resistor r=14.9
    rA2N_143 (A2N_22 A2N_25) resistor r=6.30933
    rA2N_142 (A2N_22 A2N_25) resistor r=14.9
    rA2N_141 (A2N_22 A2N_25) resistor r=6.30933
    rA2N_140 (A2N_25 A2N_28) resistor r=202.392
    rA2N_139 (A2N_25 A2N_31) resistor r=202.392
    rA2N_138 (A2N_25 A2N_39) resistor r=24.8333
    rA2N_137 (A2N_25 A2N_36) resistor r=24.8333
    rA2N_136 (A2N_25 A2N_47) resistor r=24.8333
    rA2N_135 (A2N_25 A2N_44) resistor r=24.8333
    rA2N_134 (A2N_25 A2N_52) resistor r=202.392
    rA2N_133 (A2N_25 A2N_55) resistor r=202.392
    rA2N_132 (A2N_25 A2N_28) resistor r=6.30933
    rA2N_131 (A2N_25 A2N_39) resistor r=1.63969
    rA2N_130 (A2N_25 A2N_47) resistor r=4.16253
    rA2N_129 (A2N_25 A2N_31) resistor r=4.16253
    rA2N_128 (A2N_25 A2N_36) resistor r=4.16253
    rA2N_127 (A2N_25 A2N_52) resistor r=4.16253
    rA2N_126 (A2N_25 A2N_44) resistor r=4.16253
    rA2N_125 (A2N_25 A2N_55) resistor r=4.16253
    rA2N_124 (A2N_25 A2N_199) resistor r=40.975
    rA2N_123 (A2N_25 A2N_28) resistor r=202.392
    rA2N_122 (A2N_25 A2N_31) resistor r=202.392
    rA2N_121 (A2N_25 A2N_39) resistor r=24.8333
    rA2N_120 (A2N_25 A2N_36) resistor r=24.8333
    rA2N_119 (A2N_25 A2N_47) resistor r=24.8333
    rA2N_118 (A2N_25 A2N_44) resistor r=24.8333
    rA2N_117 (A2N_25 A2N_52) resistor r=202.392
    rA2N_116 (A2N_25 MM12_ELT_g) resistor r=7.45
    rA2N_115 (A2N_25 A2N_28) resistor r=6.30933
    rA2N_114 (A2N_25 A2N_39) resistor r=1.63969
    rA2N_113 (A2N_25 A2N_47) resistor r=4.16253
    rA2N_112 (A2N_25 A2N_31) resistor r=4.16253
    rA2N_111 (A2N_25 A2N_36) resistor r=4.16253
    rA2N_110 (A2N_25 A2N_52) resistor r=4.16253
    rA2N_109 (A2N_25 A2N_44) resistor r=4.16253
    rA2N_108 (A2N_25 A2N_55) resistor r=4.16253
    rA2N_107 (A2N_55 MM12_ELT_g) resistor r=194.942
    rA2N_106 (A2N_60 A2N_66) resistor r=58.3583
    rA2N_105 (A2N_60 A2N_66) resistor r=4.16253
    rA2N_104 (A2N_60 A2N_66) resistor r=58.3583
    rA2N_103 (A2N_60 A2N_66) resistor r=4.16253
    rA2N_102 (A2N_63 A2N_66) resistor r=58.3583
    rA2N_101 (A2N_63 A2N_66) resistor r=4.16253
    rA2N_100 (A2N_63 A2N_66) resistor r=58.3583
    rA2N_99 (A2N_63 A2N_66) resistor r=4.16253
    rA2N_98 (A2N_66 A2N_71) resistor r=24.8333
    rA2N_97 (A2N_66 A2N_68) resistor r=24.8333
    rA2N_96 (A2N_66 A2N_79) resistor r=24.8333
    rA2N_95 (A2N_66 A2N_76) resistor r=24.8333
    rA2N_94 (A2N_66 A2N_84) resistor r=58.3583
    rA2N_93 (A2N_66 A2N_87) resistor r=58.3583
    rA2N_92 (A2N_66 A2N_92) resistor r=14.9
    rA2N_91 (A2N_66 A2N_71) resistor r=4.16253
    rA2N_90 (A2N_66 A2N_79) resistor r=4.16253
    rA2N_89 (A2N_66 A2N_68) resistor r=4.16253
    rA2N_88 (A2N_66 A2N_84) resistor r=4.16253
    rA2N_87 (A2N_66 A2N_92) resistor r=6.30933
    rA2N_86 (A2N_66 A2N_87) resistor r=6.30933
    rA2N_85 (A2N_66 A2N_76) resistor r=1.63969
    rA2N_84 (A2N_66 A2N_71) resistor r=24.8333
    rA2N_83 (A2N_66 A2N_68) resistor r=24.8333
    rA2N_82 (A2N_66 A2N_79) resistor r=24.8333
    rA2N_81 (A2N_66 A2N_76) resistor r=24.8333
    rA2N_80 (A2N_66 A2N_84) resistor r=58.3583
    rA2N_79 (A2N_66 MM10_ELT_g) resistor r=22.35
    rA2N_78 (A2N_66 A2N_92) resistor r=14.9
    rA2N_77 (A2N_66 A2N_231) resistor r=40.975
    rA2N_76 (A2N_66 A2N_71) resistor r=4.16253
    rA2N_75 (A2N_66 A2N_79) resistor r=4.16253
    rA2N_74 (A2N_66 A2N_68) resistor r=4.16253
    rA2N_73 (A2N_66 A2N_84) resistor r=4.16253
    rA2N_72 (A2N_66 A2N_92) resistor r=6.30933
    rA2N_71 (A2N_66 A2N_87) resistor r=6.30933
    rA2N_70 (A2N_66 A2N_76) resistor r=1.63969
    rA2N_69 (A2N_87 MM10_ELT_g) resistor r=36.0083
    rA2N_68 (A2N_131 A2N_133) resistor r=0.522173
    rA2N_67 (A2N_131 A2N_162) resistor r=0.0100985
    rA2N_66 (A2N_133 A2N_134) resistor r=8.66667
    rA2N_65 (A2N_133 A2N_136) resistor r=0.639395
    rA2N_64 (A2N_134 A2N) resistor r=32.3614
    rA2N_63 (A2N_136 A2N_137) resistor r=8.66667
    rA2N_62 (A2N_136 A2N_139) resistor r=0.426263
    rA2N_61 (A2N_137 A2N) resistor r=16.1807
    rA2N_60 (A2N_137 A2N_140) resistor r=32.3614
    rA2N_59 (A2N_139 A2N_140) resistor r=26
    rA2N_58 (A2N_142 A2N_143) resistor r=0.594131
    rA2N_57 (A2N_142 A2N_160) resistor r=0.0372619
    rA2N_56 (A2N_143 A2N_164) resistor r=0.0100985
    rA2N_55 (A2N_144 A2N_146) resistor r=0.176338
    rA2N_54 (A2N_144 A2N_150) resistor r=0.0962061
    rA2N_53 (A2N_146 A2N_147) resistor r=10
    rA2N_52 (A2N_147 A2N_235) resistor r=33.8636
    rA2N_51 (A2N_149 A2N_150) resistor r=0.126809
    rA2N_50 (A2N_149 A2N_177) resistor r=0.045668
    rA2N_49 (A2N_151 A2N_152) resistor r=1.19992
    rA2N_48 (A2N_151 A2N_153) resistor r=0.097394
    rA2N_47 (A2N_152 A2N_177) resistor r=0.0503537
    rA2N_46 (A2N_153 A2N_154) resistor r=0.121216
    rA2N_45 (A2N_154 A2N_167) resistor r=0.0484755
    rA2N_44 (A2N_158 A2N_160) resistor r=0.177163
    rA2N_43 (A2N_158 A2N_172) resistor r=0.253373
    rA2N_42 (A2N_162 A2N_164) resistor r=0.22336
    rA2N_41 (A2N_167 A2N_168) resistor r=10
    rA2N_40 (A2N_168 A2N_231) resistor r=5.35325
    rA2N_39 (A2N_169 A2N_171) resistor r=0.148011
    rA2N_38 (A2N_169 A2N_174) resistor r=0.0765295
    rA2N_37 (A2N_171 A2N_172) resistor r=0.75
    rA2N_36 (A2N_172 A2N_249) resistor r=0.246706
    rA2N_35 (A2N_174 A2N_176) resistor r=1.18409
    rA2N_34 (A2N_176 A2N_177) resistor r=0.75
    rA2N_33 (A2N_199 A2N_235) resistor r=9.29775
    rA2N_32 (A2N_248 A2N_249) resistor r=13
    rA2N_31 (A2N_248 MM4_ELT_d) resistor r=8.44
    rA2_208 (A2_42 A2_48) resistor r=58.3583
    rA2_207 (A2_42 A2_48) resistor r=4.16253
    rA2_206 (A2_42 A2_48) resistor r=58.3583
    rA2_205 (A2_42 A2_48) resistor r=4.16253
    rA2_204 (A2_45 A2_48) resistor r=58.3583
    rA2_203 (A2_45 A2_48) resistor r=4.16253
    rA2_202 (A2_45 A2_48) resistor r=58.3583
    rA2_201 (A2_45 A2_48) resistor r=4.16253
    rA2_200 (A2_48 A2_61) resistor r=24.8333
    rA2_199 (A2_48 A2_58) resistor r=24.8333
    rA2_198 (A2_48 A2_69) resistor r=24.8333
    rA2_197 (A2_48 A2_66) resistor r=24.8333
    rA2_196 (A2_48 A2_90) resistor r=58.3583
    rA2_195 (A2_48 A2_93) resistor r=58.3583
    rA2_194 (A2_48 A2_98) resistor r=14.9
    rA2_193 (A2_48 A2_61) resistor r=4.16253
    rA2_192 (A2_48 A2_69) resistor r=4.16253
    rA2_191 (A2_48 A2_58) resistor r=4.16253
    rA2_190 (A2_48 A2_90) resistor r=4.16253
    rA2_189 (A2_48 A2_98) resistor r=6.30933
    rA2_188 (A2_48 A2_93) resistor r=6.30933
    rA2_187 (A2_48 A2_66) resistor r=1.63969
    rA2_186 (A2_48 A2_61) resistor r=24.8333
    rA2_185 (A2_48 A2_58) resistor r=24.8333
    rA2_184 (A2_48 A2_69) resistor r=24.8333
    rA2_183 (A2_48 A2_66) resistor r=24.8333
    rA2_182 (A2_48 A2_90) resistor r=58.3583
    rA2_181 (A2_48 MM4_ELT_g) resistor r=22.35
    rA2_180 (A2_48 A2_98) resistor r=14.9
    rA2_179 (A2_48 A2_351) resistor r=40.975
    rA2_178 (A2_48 A2_61) resistor r=4.16253
    rA2_177 (A2_48 A2_69) resistor r=4.16253
    rA2_176 (A2_48 A2_58) resistor r=4.16253
    rA2_175 (A2_48 A2_90) resistor r=4.16253
    rA2_174 (A2_48 A2_98) resistor r=6.30933
    rA2_173 (A2_48 A2_93) resistor r=6.30933
    rA2_172 (A2_48 A2_66) resistor r=1.63969
    rA2_171 (A2_50 A2_56) resistor r=202.392
    rA2_170 (A2_50 A2_56) resistor r=4.16253
    rA2_169 (A2_50 A2_56) resistor r=202.392
    rA2_168 (A2_50 A2_56) resistor r=4.16253
    rA2_167 (A2_53 A2_56) resistor r=202.392
    rA2_166 (A2_53 A2_56) resistor r=4.16253
    rA2_165 (A2_53 A2_56) resistor r=202.392
    rA2_164 (A2_53 A2_56) resistor r=4.16253
    rA2_163 (A2_56 A2_77) resistor r=24.8333
    rA2_162 (A2_56 A2_74) resistor r=24.8333
    rA2_161 (A2_56 A2_85) resistor r=24.8333
    rA2_160 (A2_56 A2_82) resistor r=24.8333
    rA2_159 (A2_56 A2_104) resistor r=14.9
    rA2_158 (A2_56 A2_110) resistor r=202.392
    rA2_157 (A2_56 A2_113) resistor r=202.392
    rA2_156 (A2_56 A2_77) resistor r=4.16253
    rA2_155 (A2_56 A2_85) resistor r=4.16253
    rA2_154 (A2_56 A2_110) resistor r=6.30933
    rA2_153 (A2_56 A2_104) resistor r=6.30933
    rA2_152 (A2_56 A2_74) resistor r=1.63969
    rA2_151 (A2_56 A2_82) resistor r=4.16253
    rA2_150 (A2_56 A2_113) resistor r=4.16253
    rA2_149 (A2_56 A2_77) resistor r=24.8333
    rA2_148 (A2_56 A2_74) resistor r=24.8333
    rA2_147 (A2_56 A2_85) resistor r=24.8333
    rA2_146 (A2_56 A2_82) resistor r=24.8333
    rA2_145 (A2_56 A2_353) resistor r=40.975
    rA2_144 (A2_56 A2_104) resistor r=14.9
    rA2_143 (A2_56 A2_110) resistor r=202.392
    rA2_142 (A2_56 MM5_ELT_g) resistor r=7.45
    rA2_141 (A2_56 A2_77) resistor r=4.16253
    rA2_140 (A2_56 A2_85) resistor r=4.16253
    rA2_139 (A2_56 A2_110) resistor r=6.30933
    rA2_138 (A2_56 A2_104) resistor r=6.30933
    rA2_137 (A2_56 A2_74) resistor r=1.63969
    rA2_136 (A2_56 A2_82) resistor r=4.16253
    rA2_135 (A2_56 A2_113) resistor r=4.16253
    rA2_134 (A2_93 MM4_ELT_g) resistor r=36.0083
    rA2_133 (A2_113 MM5_ELT_g) resistor r=194.942
    rA2_132 (A2_118 A2_124) resistor r=58.3583
    rA2_131 (A2_118 A2_124) resistor r=4.16253
    rA2_130 (A2_118 A2_124) resistor r=58.3583
    rA2_129 (A2_118 A2_124) resistor r=4.16253
    rA2_128 (A2_121 A2_124) resistor r=58.3583
    rA2_127 (A2_121 A2_124) resistor r=4.16253
    rA2_126 (A2_121 A2_124) resistor r=58.3583
    rA2_125 (A2_121 A2_124) resistor r=4.16253
    rA2_124 (A2_124 A2_129) resistor r=24.8333
    rA2_123 (A2_124 A2_126) resistor r=24.8333
    rA2_122 (A2_124 A2_137) resistor r=24.8333
    rA2_121 (A2_124 A2_134) resistor r=24.8333
    rA2_120 (A2_124 A2_142) resistor r=58.3583
    rA2_119 (A2_124 A2_145) resistor r=58.3583
    rA2_118 (A2_124 A2_150) resistor r=14.9
    rA2_117 (A2_124 A2_129) resistor r=4.16253
    rA2_116 (A2_124 A2_137) resistor r=4.16253
    rA2_115 (A2_124 A2_126) resistor r=4.16253
    rA2_114 (A2_124 A2_142) resistor r=4.16253
    rA2_113 (A2_124 A2_150) resistor r=6.30933
    rA2_112 (A2_124 A2_145) resistor r=6.30933
    rA2_111 (A2_124 A2_134) resistor r=1.63969
    rA2_110 (A2_124 A2_129) resistor r=24.8333
    rA2_109 (A2_124 A2_126) resistor r=24.8333
    rA2_108 (A2_124 A2_137) resistor r=24.8333
    rA2_107 (A2_124 A2_134) resistor r=24.8333
    rA2_106 (A2_124 A2_142) resistor r=58.3583
    rA2_105 (A2_124 MM7_ELT_g) resistor r=22.35
    rA2_104 (A2_124 A2_150) resistor r=14.9
    rA2_103 (A2_124 A2_376) resistor r=40.975
    rA2_102 (A2_124 A2_129) resistor r=4.16253
    rA2_101 (A2_124 A2_137) resistor r=4.16253
    rA2_100 (A2_124 A2_126) resistor r=4.16253
    rA2_99 (A2_124 A2_142) resistor r=4.16253
    rA2_98 (A2_124 A2_150) resistor r=6.30933
    rA2_97 (A2_124 A2_145) resistor r=6.30933
    rA2_96 (A2_124 A2_134) resistor r=1.63969
    rA2_95 (A2_145 MM7_ELT_g) resistor r=36.0083
    rA2_94 (A2_156 A2_159) resistor r=14.9
    rA2_93 (A2_156 A2_159) resistor r=6.30933
    rA2_92 (A2_156 A2_159) resistor r=14.9
    rA2_91 (A2_156 A2_159) resistor r=6.30933
    rA2_90 (A2_159 A2_162) resistor r=202.392
    rA2_89 (A2_159 A2_165) resistor r=202.392
    rA2_88 (A2_159 A2_173) resistor r=24.8333
    rA2_87 (A2_159 A2_170) resistor r=24.8333
    rA2_86 (A2_159 A2_181) resistor r=24.8333
    rA2_85 (A2_159 A2_178) resistor r=24.8333
    rA2_84 (A2_159 A2_186) resistor r=202.392
    rA2_83 (A2_159 A2_189) resistor r=202.392
    rA2_82 (A2_159 A2_162) resistor r=6.30933
    rA2_81 (A2_159 A2_173) resistor r=1.63969
    rA2_80 (A2_159 A2_181) resistor r=4.16253
    rA2_79 (A2_159 A2_165) resistor r=4.16253
    rA2_78 (A2_159 A2_170) resistor r=4.16253
    rA2_77 (A2_159 A2_186) resistor r=4.16253
    rA2_76 (A2_159 A2_178) resistor r=4.16253
    rA2_75 (A2_159 A2_189) resistor r=4.16253
    rA2_74 (A2_159 A2_378) resistor r=40.975
    rA2_73 (A2_159 A2_162) resistor r=202.392
    rA2_72 (A2_159 A2_165) resistor r=202.392
    rA2_71 (A2_159 A2_173) resistor r=24.8333
    rA2_70 (A2_159 A2_170) resistor r=24.8333
    rA2_69 (A2_159 A2_181) resistor r=24.8333
    rA2_68 (A2_159 A2_178) resistor r=24.8333
    rA2_67 (A2_159 A2_186) resistor r=202.392
    rA2_66 (A2_159 MM6_ELT_g) resistor r=7.45
    rA2_65 (A2_159 A2_162) resistor r=6.30933
    rA2_64 (A2_159 A2_173) resistor r=1.63969
    rA2_63 (A2_159 A2_181) resistor r=4.16253
    rA2_62 (A2_159 A2_165) resistor r=4.16253
    rA2_61 (A2_159 A2_170) resistor r=4.16253
    rA2_60 (A2_159 A2_186) resistor r=4.16253
    rA2_59 (A2_159 A2_178) resistor r=4.16253
    rA2_58 (A2_159 A2_189) resistor r=4.16253
    rA2_57 (A2_189 MM6_ELT_g) resistor r=194.942
    rA2_56 (A2_262 A2_263) resistor r=10
    rA2_55 (A2_262 A2_265) resistor r=0.00423014
    rA2_54 (A2_263 A2_401) resistor r=41.3136
    rA2_53 (A2_265 A2_266) resistor r=0.0535002
    rA2_52 (A2_265 A2) resistor r=0.0803726
    rA2_51 (A2_266 A2_285) resistor r=0.931895
    rA2_50 (A2_272 A2_273) resistor r=1.68266
    rA2_49 (A2_272 A2_279) resistor r=0.0765295
    rA2_48 (A2_273 A2_284) resistor r=0.0382647
    rA2_47 (A2_274 A2_276) resistor r=0.0501127
    rA2_46 (A2_274 A2_286) resistor r=0.0579996
    rA2_45 (A2_276 A2_277) resistor r=0.75
    rA2_44 (A2_277 A2_418) resistor r=10
    rA2_43 (A2_279 A2_280) resistor r=0.738023
    rA2_42 (A2_280 A2_286) resistor r=0.0150731
    rA2_41 (A2_284 A2_285) resistor r=0.75
    rA2_40 (A2_351 A2_402) resistor r=10.0997
    rA2_39 (A2_353 A2_402) resistor r=10.0997
    rA2_38 (A2_376 A2_409) resistor r=9.29775
    rA2_37 (A2_378 A2_410) resistor r=9.29775
    rA2_36 (A2_401 A2_402) resistor r=0.877078
    rA2_35 (A2_409 A2_418) resistor r=10.8364
    rA2_34 (A2_410 A2_418) resistor r=37.9273
ends XOR2D1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: LHENCNQD1_LVT_ELT
// View name: calibre
subckt LHENCNQD1_LVT_ELT D E CDN Q VDD VSS
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 \
        ps=4.76e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM16_ELT (MM16_ELT_d MM16_ELT_g MM16_ELT_s MM16_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM29_ELT (MM29_ELT_d MM29_ELT_g MM29_ELT_s MM29_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=5.68868e-13 pd=3.66e-06 \
        ps=8.52312e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.50082e-13 pd=1.34e-06 \
        ps=3.74688e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=3.03125e-13 as=9.4e-14 pd=4.8e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM28_ELT (MM28_ELT_d MM28_ELT_g MM28_ELT_s MM28_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cc_812 (c_1362_n c_1588_n) capacitor c=1.71175e-18
    cc_811 (c_1345_n c_1588_n) capacitor c=1.01306e-17
    cc_810 (c_1362_n c_1580_n) capacitor c=1.64973e-18
    cc_809 (c_1362_n c_1579_n) capacitor c=2.45746e-18
    cc_808 (c_1362_n MM9_ELT_d) capacitor c=3.97088e-18
    cc_807 (c_1430_p c_1497_n) capacitor c=2.39061e-18
    cc_806 (c_1420_p c_1497_n) capacitor c=3.05546e-18
    cc_805 (c_1432_p c_1497_n) capacitor c=1.41748e-18
    cc_804 (c_1420_p Q) capacitor c=1.93399e-18
    cc_803 (c_1432_p Q) capacitor c=4.43395e-18
    cc_802 (c_1421_p c_1482_n) capacitor c=6.27051e-18
    cc_801 (c_1430_p c_1482_n) capacitor c=1.32762e-17
    cc_800 (c_1420_p c_1482_n) capacitor c=1.07074e-18
    cc_799 (c_1428_p c_1482_n) capacitor c=1.11099e-18
    cc_798 (c_1374_n c_1482_n) capacitor c=2.65299e-19
    cc_797 (c_1371_n c_1482_n) capacitor c=1.5297e-17
    cc_796 (c_1368_n c_1482_n) capacitor c=9.35524e-18
    cc_795 (c_1374_n c_1480_n) capacitor c=1.93426e-18
    cc_794 (c_1371_n c_1480_n) capacitor c=9.36838e-18
    cc_793 (c_1368_n c_1480_n) capacitor c=8.98489e-17
    cc_792 (c_1421_p c_1468_n) capacitor c=6.93876e-18
    cc_791 (c_1420_p c_1468_n) capacitor c=4.5253e-19
    cc_790 (c_1371_n c_1468_n) capacitor c=1.49466e-18
    cc_789 (c_1368_n c_1468_n) capacitor c=7.22876e-18
    cc_788 (c_1368_n c_1466_n) capacitor c=7.56222e-17
    cc_787 (c_1365_n c_1461_n) capacitor c=4.90544e-19
    cc_786 (c_1365_n c_1511_n) capacitor c=6.71832e-19
    cc_785 (c_1362_n c_1547_n) capacitor c=1.19258e-17
    cc_784 (c_1345_n c_1547_n) capacitor c=1.0458e-17
    cc_783 (c_1362_n c_1455_n) capacitor c=1.19258e-17
    cc_782 (c_1345_n c_1455_n) capacitor c=1.7808e-18
    cc_781 (c_1362_n c_1447_n) capacitor c=8.11018e-17
    cc_780 (c_1345_n c_1447_n) capacitor c=1.82558e-17
    cc_779 (c_1342_n c_1446_n) capacitor c=6.71832e-19
    cc_778 (c_1297_p c_1491_n) capacitor c=2.32212e-18
    cc_777 (c_1245_n c_1491_n) capacitor c=1.94121e-18
    cc_776 (c_1297_p Q) capacitor c=3.11129e-19
    cc_775 (c_1296_p Q) capacitor c=2.33721e-18
    cc_774 (c_1295_p Q) capacitor c=5.9471e-18
    cc_773 (c_1242_n Q) capacitor c=2.98005e-18
    cc_772 (c_1248_n c_1476_n) capacitor c=2.94633e-18
    cc_771 (c_1245_n c_1476_n) capacitor c=3.47801e-19
    cc_770 (c_1242_n c_1476_n) capacitor c=2.80206e-18
    cc_769 (c_1245_n c_1474_n) capacitor c=2.31352e-18
    cc_768 (c_1242_n c_1474_n) capacitor c=2.90483e-17
    cc_767 (c_1135_n c_1622_n) capacitor c=2.14769e-18
    cc_766 (c_1133_n c_1622_n) capacitor c=2.76965e-18
    cc_765 (c_1145_n c_1622_n) capacitor c=7.8454e-19
    cc_764 (c_1135_n c_1620_n) capacitor c=5.50274e-19
    cc_763 (c_1145_n c_1620_n) capacitor c=6.50797e-19
    cc_762 (c_1145_n MM12_ELT_d) capacitor c=2.67257e-18
    cc_761 (c_1135_n Q) capacitor c=1.07097e-18
    cc_760 (c_1145_n c_1460_n) capacitor c=4.10782e-18
    cc_759 (c_1142_n c_1527_n) capacitor c=1.19258e-17
    cc_758 (c_1132_n c_1527_n) capacitor c=1.82851e-18
    cc_757 (c_1133_n c_1509_n) capacitor c=1.26206e-18
    cc_756 (c_1145_n c_1509_n) capacitor c=3.31851e-18
    cc_755 (c_1142_n c_1509_n) capacitor c=1.19258e-17
    cc_754 (c_1132_n c_1509_n) capacitor c=4.82271e-18
    cc_753 (c_1142_n c_1444_n) capacitor c=8.11018e-17
    cc_752 (c_1132_n c_1444_n) capacitor c=1.56027e-17
    cc_751 (c_1165_n c_1248_n) capacitor c=8.43153e-19
    cc_750 (c_1136_n c_1286_n) capacitor c=2.72252e-18
    cc_749 (c_1135_n c_1286_n) capacitor c=1.50777e-18
    cc_748 (c_1165_n c_1242_n) capacitor c=1.1098e-18
    cc_747 (c_1161_n c_1242_n) capacitor c=1.26919e-17
    cc_746 (c_1135_n c_1242_n) capacitor c=3.37033e-19
    cc_745 (c_1136_n c_1241_n) capacitor c=6.31931e-19
    cc_744 (c_1165_n c_1241_n) capacitor c=3.47801e-19
    cc_743 (c_1161_n c_1241_n) capacitor c=2.31352e-18
    cc_742 (c_1165_n c_1258_n) capacitor c=2.9118e-18
    cc_741 (c_1161_n c_1258_n) capacitor c=2.76923e-18
    cc_740 (c_1165_n c_1214_n) capacitor c=2.76923e-18
    cc_739 (c_1161_n c_1214_n) capacitor c=2.36781e-17
    cc_738 (c_1113_n c_1602_n) capacitor c=1.18631e-18
    cc_737 (c_1097_n c_1602_n) capacitor c=5.97299e-18
    cc_736 (c_1097_n c_1274_n) capacitor c=7.06648e-18
    cc_735 (c_1095_n c_1274_n) capacitor c=1.18631e-18
    cc_734 (c_1113_n c_1258_n) capacitor c=3.14323e-18
    cc_733 (c_1113_n c_1214_n) capacitor c=2.98932e-18
    cc_732 (c_1111_n c_1214_n) capacitor c=2.27624e-17
    cc_731 (c_1113_n c_1210_n) capacitor c=3.47801e-19
    cc_730 (c_1111_n c_1210_n) capacitor c=2.30863e-18
    cc_729 (c_1097_n c_1210_n) capacitor c=1.67481e-17
    cc_728 (c_1095_n c_1210_n) capacitor c=3.47801e-19
    cc_727 (c_1094_n c_1210_n) capacitor c=2.30863e-18
    cc_726 (c_1003_n c_1448_n) capacitor c=3.3286e-18
    cc_725 (c_1018_n Q) capacitor c=2.05383e-19
    cc_724 (c_1003_n Q) capacitor c=4.51983e-19
    cc_723 (c_1003_n c_1472_n) capacitor c=2.28937e-17
    cc_722 (c_1014_n c_1461_n) capacitor c=2.19674e-18
    cc_721 (c_1003_n c_1461_n) capacitor c=1.07964e-17
    cc_720 (c_1002_n c_1461_n) capacitor c=1.25016e-18
    cc_719 (c_1037_p c_1460_n) capacitor c=4.32154e-18
    cc_718 (c_1003_n c_1460_n) capacitor c=1.79472e-17
    cc_717 (c_1071_p c_1511_n) capacitor c=5.73637e-18
    cc_716 (c_1083_p c_1509_n) capacitor c=4.32154e-18
    cc_715 (CDN c_1509_n) capacitor c=5.80526e-19
    cc_714 (c_1003_n c_1444_n) capacitor c=3.20275e-18
    cc_713 (c_998_n c_1442_n) capacitor c=4.32154e-18
    cc_712 (CDN c_1442_n) capacitor c=1.7041e-18
    cc_711 (c_1003_n c_1447_n) capacitor c=1.00737e-17
    cc_710 (c_1002_n c_1447_n) capacitor c=5.73637e-18
    cc_709 (c_1003_n c_1371_n) capacitor c=1.61888e-17
    cc_708 (c_1075_p c_1368_n) capacitor c=1.30361e-17
    cc_707 (c_1003_n c_1368_n) capacitor c=7.89422e-18
    cc_706 (c_1071_p c_1365_n) capacitor c=7.13084e-18
    cc_705 (c_1003_n c_1345_n) capacitor c=7.82463e-19
    cc_704 (c_1071_p c_1345_n) capacitor c=3.05241e-19
    cc_703 (c_1000_n c_1248_n) capacitor c=6.917e-18
    cc_702 (c_1069_p c_1242_n) capacitor c=8.63135e-18
    cc_701 (c_1000_n c_1242_n) capacitor c=4.84278e-19
    cc_700 (c_1060_p c_1241_n) capacitor c=7.01529e-18
    cc_699 (c_1037_p c_1258_n) capacitor c=1.41656e-18
    cc_698 (CDN c_1258_n) capacitor c=5.62162e-19
    cc_697 (c_1000_n c_1258_n) capacitor c=5.12972e-17
    cc_696 (c_993_n c_1258_n) capacitor c=5.12972e-17
    cc_695 (c_1037_p c_1214_n) capacitor c=1.12549e-18
    cc_694 (CDN c_1214_n) capacitor c=3.14453e-18
    cc_693 (c_1060_p c_1214_n) capacitor c=1.00767e-17
    cc_692 (c_1059_p c_1214_n) capacitor c=1.0757e-17
    cc_691 (CDN c_1210_n) capacitor c=3.55594e-19
    cc_690 (c_1021_n c_1210_n) capacitor c=6.34085e-18
    cc_689 (c_1018_n c_1136_n) capacitor c=2.06587e-18
    cc_688 (c_1001_n c_1136_n) capacitor c=4.99092e-18
    cc_687 (c_1000_n c_1136_n) capacitor c=5.24834e-18
    cc_686 (c_993_n c_1136_n) capacitor c=5.7301e-19
    cc_685 (c_1001_n c_1165_n) capacitor c=1.19258e-17
    cc_684 (c_1048_p c_1165_n) capacitor c=1.19258e-17
    cc_683 (c_1000_n c_1165_n) capacitor c=8.11018e-17
    cc_682 (c_1001_n c_1161_n) capacitor c=5.36016e-18
    cc_681 (c_1048_p c_1161_n) capacitor c=2.25994e-18
    cc_680 (c_1000_n c_1161_n) capacitor c=1.39636e-17
    cc_679 (c_993_n c_1161_n) capacitor c=1.28034e-18
    cc_678 (c_1045_p c_1135_n) capacitor c=2.94746e-18
    cc_677 (c_1018_n c_1135_n) capacitor c=6.69275e-18
    cc_676 (c_1037_p c_1135_n) capacitor c=5.24089e-19
    cc_675 (CDN c_1135_n) capacitor c=1.60129e-17
    cc_674 (c_1000_n c_1135_n) capacitor c=4.18434e-18
    cc_673 (c_993_n c_1135_n) capacitor c=1.49423e-18
    cc_672 (c_1037_p c_1133_n) capacitor c=1.04377e-18
    cc_671 (CDN c_1133_n) capacitor c=7.77068e-18
    cc_670 (c_1037_p c_1145_n) capacitor c=2.58838e-18
    cc_669 (CDN c_1142_n) capacitor c=5.82178e-19
    cc_668 (CDN c_1117_n) capacitor c=2.24013e-18
    cc_667 (c_1031_p c_1117_n) capacitor c=2.23123e-18
    cc_666 (c_993_n c_1117_n) capacitor c=3.46689e-18
    cc_665 (CDN c_1113_n) capacitor c=5.72059e-19
    cc_664 (c_1031_p c_1113_n) capacitor c=1.19258e-17
    cc_663 (c_1028_p c_1113_n) capacitor c=1.19258e-17
    cc_662 (c_993_n c_1113_n) capacitor c=8.87293e-17
    cc_661 (c_1028_p c_1111_n) capacitor c=2.21869e-18
    cc_660 (c_993_n c_1111_n) capacitor c=8.38647e-18
    cc_659 (CDN c_1097_n) capacitor c=1.17893e-18
    cc_658 (c_993_n c_1097_n) capacitor c=1.09103e-17
    cc_657 (c_931_n c_1342_n) capacitor c=7.15333e-18
    cc_656 (c_932_n c_1316_n) capacitor c=6.04916e-17
    cc_655 (c_903_n c_1312_n) capacitor c=1.32938e-17
    cc_654 (c_906_n c_1210_n) capacitor c=7.09933e-18
    cc_653 (c_910_n c_1100_n) capacitor c=1.6909e-18
    cc_652 (c_907_n c_1100_n) capacitor c=3.46689e-18
    cc_651 (c_907_n c_1097_n) capacitor c=9.18758e-18
    cc_650 (c_910_n c_1095_n) capacitor c=1.19258e-17
    cc_649 (c_980_p c_1095_n) capacitor c=1.19258e-17
    cc_648 (c_907_n c_1095_n) capacitor c=8.87293e-17
    cc_647 (c_980_p c_1094_n) capacitor c=2.21869e-18
    cc_646 (c_907_n c_1094_n) capacitor c=8.34028e-18
    cc_645 (D CDN) capacitor c=5.40561e-19
    cc_644 (c_907_n c_993_n) capacitor c=5.50522e-18
    cc_643 (c_911_n c_991_n) capacitor c=5.50522e-18
    cc_642 (c_975_p c_1021_n) capacitor c=5.50522e-18
    cc_641 (c_830_n c_1571_n) capacitor c=1.112e-18
    cc_640 (c_830_n c_1398_n) capacitor c=1.71175e-18
    cc_639 (c_839_n c_1395_n) capacitor c=2.59637e-18
    cc_638 (c_830_n c_1395_n) capacitor c=1.64973e-18
    cc_637 (c_845_n c_1395_n) capacitor c=2.4687e-18
    cc_636 (c_830_n MM14_ELT_s) capacitor c=3.97088e-18
    cc_635 (c_826_n c_1323_n) capacitor c=4.61437e-19
    cc_634 (c_839_n c_1342_n) capacitor c=4.51344e-19
    cc_633 (c_830_n c_1342_n) capacitor c=3.47801e-19
    cc_632 (c_845_n c_1342_n) capacitor c=2.29286e-18
    cc_631 (c_830_n c_1316_n) capacitor c=9.26974e-18
    cc_630 (c_845_n c_1316_n) capacitor c=2.80206e-18
    cc_629 (c_830_n c_1312_n) capacitor c=2.80206e-18
    cc_628 (c_845_n c_1312_n) capacitor c=3.04992e-17
    cc_627 (c_836_n c_921_n) capacitor c=2.54738e-18
    cc_626 (c_823_n c_921_n) capacitor c=1.79206e-18
    cc_625 (c_831_n c_918_n) capacitor c=5.80163e-18
    cc_624 (c_830_n c_970_n) capacitor c=1.19258e-17
    cc_623 (c_845_n c_970_n) capacitor c=2.25994e-18
    cc_622 (c_839_n c_905_n) capacitor c=1.71116e-18
    cc_621 (c_836_n c_905_n) capacitor c=4.03491e-19
    cc_620 (c_830_n c_905_n) capacitor c=1.19258e-17
    cc_619 (c_845_n c_905_n) capacitor c=7.71879e-18
    cc_618 (c_839_n c_932_n) capacitor c=6.92454e-18
    cc_617 (c_831_n c_932_n) capacitor c=4.46653e-18
    cc_616 (c_830_n c_932_n) capacitor c=8.11018e-17
    cc_615 (c_845_n c_932_n) capacitor c=1.68911e-17
    cc_614 (c_822_p net29) capacitor c=4.20028e-18
    cc_613 (c_692_p net29) capacitor c=4.32714e-18
    cc_612 (c_558_n net29) capacitor c=9.39265e-19
    cc_611 (c_692_p c_1615_n) capacitor c=4.71508e-18
    cc_610 (c_692_p MM12_ELT_d) capacitor c=2.81795e-18
    cc_609 (c_558_n c_1611_n) capacitor c=4.79097e-19
    cc_608 (c_550_n c_1611_n) capacitor c=1.46167e-18
    cc_607 (c_547_n c_1611_n) capacitor c=7.01449e-19
    cc_606 (c_547_n c_1610_n) capacitor c=5.47935e-18
    cc_605 (c_570_n MM16_ELT_s) capacitor c=1.56061e-18
    cc_604 (c_563_n MM16_ELT_s) capacitor c=2.44472e-18
    cc_603 (c_549_n c_1583_n) capacitor c=1.15496e-17
    cc_602 (c_750_p c_1580_n) capacitor c=1.64962e-18
    cc_601 (c_670_p c_1580_n) capacitor c=3.82772e-18
    cc_600 (c_549_n c_1580_n) capacitor c=2.13033e-19
    cc_599 (c_596_n c_1579_n) capacitor c=2.45746e-18
    cc_598 (c_676_p MM9_ELT_d) capacitor c=1.112e-18
    cc_597 (c_670_p MM9_ELT_d) capacitor c=5.73575e-18
    cc_596 (c_596_n c_1576_n) capacitor c=1.71175e-18
    cc_595 (c_602_n c_1572_n) capacitor c=3.25596e-18
    cc_594 (c_549_n c_1572_n) capacitor c=5.18177e-19
    cc_593 (c_596_n c_1572_n) capacitor c=1.64973e-18
    cc_592 (c_593_n c_1572_n) capacitor c=7.9577e-19
    cc_591 (c_596_n c_1571_n) capacitor c=3.97088e-18
    cc_590 (c_670_p c_1448_n) capacitor c=6.09782e-18
    cc_589 (c_692_p c_1448_n) capacitor c=5.96105e-18
    cc_588 (c_607_n c_1448_n) capacitor c=1.80387e-18
    cc_587 (c_766_p c_1497_n) capacitor c=3.13372e-19
    cc_586 (c_794_p c_1497_n) capacitor c=7.40677e-18
    cc_585 (c_764_p c_1497_n) capacitor c=9.675e-18
    cc_584 (c_773_p c_1497_n) capacitor c=4.06577e-19
    cc_583 (c_766_p c_1491_n) capacitor c=6.98692e-19
    cc_582 (c_674_p c_1491_n) capacitor c=2.48482e-18
    cc_581 (c_782_p c_1491_n) capacitor c=1.54677e-18
    cc_580 (c_764_p c_1491_n) capacitor c=3.47036e-19
    cc_579 (c_773_p c_1491_n) capacitor c=6.9185e-18
    cc_578 (c_668_p c_1491_n) capacitor c=4.23268e-18
    cc_577 (c_766_p Q) capacitor c=3.43255e-18
    cc_576 (c_674_p Q) capacitor c=1.39487e-17
    cc_575 (c_673_p Q) capacitor c=1.57644e-18
    cc_574 (c_782_p Q) capacitor c=3.09474e-18
    cc_573 (c_671_p Q) capacitor c=3.67836e-18
    cc_572 (c_668_p Q) capacitor c=3.76994e-18
    cc_571 (c_764_p c_1482_n) capacitor c=5.09084e-18
    cc_570 (c_776_p c_1482_n) capacitor c=5.09084e-18
    cc_569 (c_671_p c_1482_n) capacitor c=2.66348e-16
    cc_568 (c_776_p c_1480_n) capacitor c=2.07718e-18
    cc_567 (c_671_p c_1480_n) capacitor c=8.5624e-17
    cc_566 (c_674_p c_1476_n) capacitor c=5.77003e-19
    cc_565 (c_773_p c_1476_n) capacitor c=1.19258e-17
    cc_564 (c_770_p c_1476_n) capacitor c=1.19258e-17
    cc_563 (c_668_p c_1476_n) capacitor c=8.11018e-17
    cc_562 (c_770_p c_1474_n) capacitor c=2.25994e-18
    cc_561 (c_668_p c_1474_n) capacitor c=2.05205e-17
    cc_560 (c_674_p c_1472_n) capacitor c=3.0975e-17
    cc_559 (c_673_p c_1472_n) capacitor c=3.32152e-17
    cc_558 (c_766_p c_1468_n) capacitor c=9.64875e-19
    cc_557 (c_688_p c_1468_n) capacitor c=2.77726e-18
    cc_556 (c_764_p c_1468_n) capacitor c=8.24588e-19
    cc_555 (c_671_p c_1468_n) capacitor c=8.52359e-18
    cc_554 (c_692_p c_1466_n) capacitor c=3.32152e-17
    cc_553 (c_671_p c_1466_n) capacitor c=1.0901e-18
    cc_552 (c_676_p c_1461_n) capacitor c=7.53105e-19
    cc_551 (c_674_p c_1461_n) capacitor c=9.29879e-19
    cc_550 (c_670_p c_1461_n) capacitor c=5.26678e-17
    cc_549 (c_692_p c_1461_n) capacitor c=5.47122e-17
    cc_548 (c_607_n c_1461_n) capacitor c=1.04665e-17
    cc_547 (c_673_p c_1460_n) capacitor c=6.25271e-18
    cc_546 (c_692_p c_1444_n) capacitor c=1.22367e-17
    cc_545 (c_550_n c_1444_n) capacitor c=1.20551e-18
    cc_544 (c_692_p c_1443_n) capacitor c=4.25941e-18
    cc_543 (c_550_n c_1443_n) capacitor c=3.71302e-19
    cc_542 (c_750_p c_1455_n) capacitor c=4.17581e-18
    cc_541 (c_675_p c_1447_n) capacitor c=1.17541e-18
    cc_540 (c_670_p c_1447_n) capacitor c=1.33239e-17
    cc_539 (c_607_n c_1447_n) capacitor c=1.20849e-18
    cc_538 (c_593_n c_1447_n) capacitor c=1.03518e-18
    cc_537 (c_549_n c_1445_n) capacitor c=4.17581e-18
    cc_536 (c_593_n c_1445_n) capacitor c=4.46886e-19
    cc_535 (c_676_p c_1383_n) capacitor c=1.64973e-18
    cc_534 (c_675_p c_1383_n) capacitor c=2.67171e-19
    cc_533 (c_670_p c_1383_n) capacitor c=1.46182e-18
    cc_532 (c_676_p c_1382_n) capacitor c=1.71175e-18
    cc_531 (c_676_p c_1379_n) capacitor c=1.64973e-18
    cc_530 (c_675_p c_1379_n) capacitor c=5.38975e-19
    cc_529 (c_670_p c_1379_n) capacitor c=2.20914e-18
    cc_528 (c_670_p c_1378_n) capacitor c=7.12773e-18
    cc_527 (c_676_p c_1377_n) capacitor c=3.97088e-18
    cc_526 (c_596_n MM14_ELT_s) capacitor c=1.112e-18
    cc_525 (c_573_n c_1323_n) capacitor c=4.98916e-18
    cc_524 (c_684_p c_1374_n) capacitor c=1.02385e-17
    cc_523 (c_688_p c_1371_n) capacitor c=8.33511e-19
    cc_522 (c_676_p c_1371_n) capacitor c=5.40379e-18
    cc_521 (c_671_p c_1371_n) capacitor c=1.48642e-16
    cc_520 (c_676_p c_1368_n) capacitor c=2.80206e-18
    cc_519 (c_670_p c_1368_n) capacitor c=3.81943e-17
    cc_518 (c_671_p c_1368_n) capacitor c=3.19057e-17
    cc_517 (c_676_p c_1365_n) capacitor c=3.47801e-19
    cc_516 (c_675_p c_1365_n) capacitor c=2.31352e-18
    cc_515 (c_670_p c_1365_n) capacitor c=6.23362e-18
    cc_514 (c_670_p c_1362_n) capacitor c=1.49466e-18
    cc_513 (c_596_n c_1362_n) capacitor c=1.30619e-18
    cc_512 (c_593_n c_1362_n) capacitor c=9.52584e-19
    cc_511 (c_675_p c_1345_n) capacitor c=2.66726e-18
    cc_510 (c_670_p c_1345_n) capacitor c=6.16444e-18
    cc_509 (c_596_n c_1345_n) capacitor c=9.52584e-19
    cc_508 (c_593_n c_1345_n) capacitor c=5.27996e-18
    cc_507 (c_549_n c_1342_n) capacitor c=3.14672e-18
    cc_506 (c_596_n c_1342_n) capacitor c=3.47801e-19
    cc_505 (c_593_n c_1342_n) capacitor c=2.29286e-18
    cc_504 (c_688_p c_1248_n) capacitor c=5.28343e-18
    cc_503 (c_674_p c_1248_n) capacitor c=1.30742e-18
    cc_502 (c_668_p c_1248_n) capacitor c=6.04916e-17
    cc_501 (c_578_n c_1219_n) capacitor c=1.112e-18
    cc_500 (c_674_p c_1245_n) capacitor c=1.30746e-18
    cc_499 (c_704_p c_1245_n) capacitor c=7.73354e-18
    cc_498 (c_688_p c_1242_n) capacitor c=1.80192e-18
    cc_497 (c_674_p c_1242_n) capacitor c=7.12711e-18
    cc_496 (c_704_p c_1242_n) capacitor c=1.63872e-17
    cc_495 (c_669_p c_1241_n) capacitor c=2.93012e-18
    cc_494 (c_688_p c_1135_n) capacitor c=4.29531e-19
    cc_493 (c_669_p c_1135_n) capacitor c=1.83512e-17
    cc_492 (c_668_p c_1135_n) capacitor c=1.05669e-18
    cc_491 (c_540_n c_1133_n) capacitor c=4.97396e-19
    cc_490 (c_673_p c_1145_n) capacitor c=1.83512e-17
    cc_489 (c_692_p c_1145_n) capacitor c=2.9651e-18
    cc_488 (c_673_p c_1142_n) capacitor c=1.59769e-18
    cc_487 (c_692_p c_1142_n) capacitor c=1.36297e-18
    cc_486 (c_550_n c_1142_n) capacitor c=9.41423e-19
    cc_485 (c_673_p c_1132_n) capacitor c=1.72423e-17
    cc_484 (c_692_p c_1132_n) capacitor c=5.61614e-18
    cc_483 (c_554_n c_1132_n) capacitor c=9.41423e-19
    cc_482 (c_550_n c_1132_n) capacitor c=5.20861e-18
    cc_481 (c_546_n c_1132_n) capacitor c=4.97396e-19
    cc_480 (c_688_p c_1018_n) capacitor c=6.35081e-18
    cc_479 (c_674_p c_1018_n) capacitor c=6.925e-18
    cc_478 (c_669_p c_1018_n) capacitor c=8.19309e-18
    cc_477 (c_558_n CDN) capacitor c=3.17106e-18
    cc_476 (c_684_p c_1016_n) capacitor c=1.67115e-18
    cc_475 (c_676_p c_1014_n) capacitor c=1.19258e-17
    cc_474 (c_675_p c_1014_n) capacitor c=1.3541e-18
    cc_473 (c_676_p c_1012_n) capacitor c=1.19258e-17
    cc_472 (c_675_p c_1012_n) capacitor c=2.25994e-18
    cc_471 (c_676_p c_1010_n) capacitor c=1.19258e-17
    cc_470 (c_675_p c_1010_n) capacitor c=2.48555e-18
    cc_469 (c_674_p c_1009_n) capacitor c=9.2822e-19
    cc_468 (c_676_p c_1003_n) capacitor c=9.43435e-17
    cc_467 (c_675_p c_1003_n) capacitor c=1.92715e-17
    cc_466 (c_674_p c_1003_n) capacitor c=3.60742e-18
    cc_465 (c_673_p c_1003_n) capacitor c=1.51001e-17
    cc_464 (c_670_p c_1003_n) capacitor c=6.59598e-18
    cc_463 (c_671_p c_1003_n) capacitor c=1.11442e-17
    cc_462 (c_670_p c_1002_n) capacitor c=9.8278e-19
    cc_461 (c_669_p c_1001_n) capacitor c=9.2822e-19
    cc_460 (c_668_p c_1000_n) capacitor c=1.1199e-18
    cc_459 (c_540_n c_926_n) capacitor c=1.62483e-18
    cc_458 (c_540_n c_924_n) capacitor c=3.56165e-18
    cc_457 (c_563_n c_921_n) capacitor c=1.15062e-18
    cc_456 (c_546_n c_921_n) capacitor c=1.55852e-17
    cc_455 (c_540_n c_921_n) capacitor c=7.3411e-18
    cc_454 (c_563_n D) capacitor c=2.30841e-18
    cc_453 (c_540_n D) capacitor c=2.92518e-17
    cc_452 (c_540_n c_910_n) capacitor c=4.21317e-19
    cc_451 (c_563_n c_907_n) capacitor c=6.3254e-19
    cc_450 (c_602_n c_932_n) capacitor c=7.11639e-19
    cc_449 (c_593_n c_932_n) capacitor c=9.83725e-19
    cc_448 (c_602_n c_839_n) capacitor c=8.3004e-19
    cc_447 (c_643_p c_836_n) capacitor c=5.8536e-18
    cc_446 (c_591_n c_836_n) capacitor c=2.35794e-18
    cc_445 (c_540_n c_836_n) capacitor c=8.60452e-19
    cc_444 (c_607_n c_831_n) capacitor c=3.73179e-19
    cc_443 (c_602_n c_845_n) capacitor c=4.57898e-18
    cc_442 (c_573_n c_826_n) capacitor c=8.33353e-18
    cc_441 (c_649_p c_826_n) capacitor c=3.97088e-18
    cc_440 (c_643_p c_826_n) capacitor c=1.64973e-18
    cc_439 (c_647_p c_826_n) capacitor c=1.71175e-18
    cc_438 (c_546_n c_826_n) capacitor c=1.14901e-18
    cc_437 (c_540_n c_826_n) capacitor c=1.98481e-18
    cc_436 (c_573_n c_823_n) capacitor c=4.48398e-18
    cc_435 (c_643_p c_823_n) capacitor c=8.77353e-19
    cc_434 (c_563_n c_823_n) capacitor c=4.05863e-18
    cc_433 (c_560_n c_823_n) capacitor c=1.78369e-17
    cc_432 (c_559_n c_823_n) capacitor c=1.25121e-17
    cc_431 (c_546_n c_823_n) capacitor c=1.0342e-17
    cc_430 (c_540_n c_823_n) capacitor c=8.47622e-18
    cc_429 (c_395_n c_1448_n) capacitor c=4.13106e-18
    cc_428 (c_405_p c_1447_n) capacitor c=1.45829e-17
    cc_427 (c_527_p c_1446_n) capacitor c=1.01211e-17
    cc_426 (c_405_p c_1445_n) capacitor c=1.01211e-17
    cc_425 (c_324_n c_1354_n) capacitor c=1.70056e-18
    cc_424 (c_387_n c_1323_n) capacitor c=7.87706e-19
    cc_423 (c_380_n c_1323_n) capacitor c=1.36918e-17
    cc_422 (c_376_n c_1323_n) capacitor c=2.19715e-18
    cc_421 (c_380_n c_1350_n) capacitor c=3.29477e-18
    cc_420 (c_305_n c_1349_n) capacitor c=1.07074e-18
    cc_419 (c_305_n c_1348_n) capacitor c=1.11099e-18
    cc_418 (c_305_n MM1_ELT_s) capacitor c=1.32762e-17
    cc_417 (c_527_p c_1345_n) capacitor c=5.48896e-19
    cc_416 (c_405_p c_1345_n) capacitor c=1.34582e-18
    cc_415 (c_391_n c_1342_n) capacitor c=1.45807e-18
    cc_414 (c_388_n c_1342_n) capacitor c=6.14646e-18
    cc_413 (c_470_p c_1342_n) capacitor c=8.12851e-18
    cc_412 (c_292_n c_1316_n) capacitor c=5.65894e-18
    cc_411 (c_388_n c_1312_n) capacitor c=1.3974e-18
    cc_410 (c_292_n c_1312_n) capacitor c=7.73682e-18
    cc_409 (c_387_n c_1309_n) capacitor c=7.12461e-19
    cc_408 (c_295_n c_1309_n) capacitor c=7.94374e-18
    cc_407 (c_327_n c_1302_n) capacitor c=8.59452e-19
    cc_406 (c_316_n c_1302_n) capacitor c=1.28046e-17
    cc_405 (c_305_n c_1302_n) capacitor c=2.72622e-17
    cc_404 (c_303_n c_1302_n) capacitor c=9.36838e-18
    cc_403 (c_292_n c_1302_n) capacitor c=1.48827e-16
    cc_402 (c_387_n c_1301_n) capacitor c=7.15301e-19
    cc_401 (c_316_n c_1301_n) capacitor c=8.98363e-18
    cc_400 (c_305_n c_1301_n) capacitor c=9.36838e-18
    cc_399 (c_303_n c_1301_n) capacitor c=8.97719e-17
    cc_398 (c_292_n c_1301_n) capacitor c=2.98803e-17
    cc_397 (c_305_n c_1300_n) capacitor c=2.65299e-19
    cc_396 (c_303_n c_1300_n) capacitor c=1.93426e-18
    cc_395 (c_323_n c_1239_n) capacitor c=3.10967e-19
    cc_394 (c_309_n c_1239_n) capacitor c=3.75485e-18
    cc_393 (c_312_n c_1237_n) capacitor c=1.34201e-18
    cc_392 (c_309_n c_1237_n) capacitor c=1.12855e-18
    cc_391 (c_369_n c_1210_n) capacitor c=5.24758e-19
    cc_390 (c_354_n c_1210_n) capacitor c=4.68214e-18
    cc_389 (c_340_n c_1210_n) capacitor c=3.0253e-18
    cc_388 (c_488_p c_1210_n) capacitor c=2.17431e-18
    cc_387 (c_327_n c_1204_n) capacitor c=1.37248e-18
    cc_386 (c_309_n c_1204_n) capacitor c=6.45055e-18
    cc_385 (c_299_n c_1204_n) capacitor c=2.9118e-18
    cc_384 (c_296_n c_1204_n) capacitor c=2.76923e-18
    cc_383 (c_289_n c_1204_n) capacitor c=5.12972e-17
    cc_382 (c_327_n c_1203_n) capacitor c=2.15685e-19
    cc_381 (c_309_n c_1203_n) capacitor c=8.65889e-18
    cc_380 (c_299_n c_1203_n) capacitor c=2.76923e-18
    cc_379 (c_296_n c_1203_n) capacitor c=2.32212e-17
    cc_378 (c_488_p c_1203_n) capacitor c=8.7308e-18
    cc_377 (c_309_n c_1201_n) capacitor c=1.85328e-18
    cc_376 (c_299_n c_1201_n) capacitor c=3.47801e-19
    cc_375 (c_296_n c_1201_n) capacitor c=2.31352e-18
    cc_374 (c_393_n c_924_n) capacitor c=4.37406e-18
    cc_373 (c_374_n c_924_n) capacitor c=1.03817e-18
    cc_372 (c_362_n c_924_n) capacitor c=4.00583e-19
    cc_371 (c_388_n c_918_n) capacitor c=5.07667e-19
    cc_370 (c_394_n c_944_n) capacitor c=5.10267e-18
    cc_369 (c_391_n c_944_n) capacitor c=4.94463e-19
    cc_368 (c_388_n c_944_n) capacitor c=5.78801e-18
    cc_367 (c_393_n D) capacitor c=1.07031e-18
    cc_366 (c_388_n D) capacitor c=6.56875e-19
    cc_365 (c_374_n D) capacitor c=6.58407e-18
    cc_364 (c_355_n D) capacitor c=3.59759e-19
    cc_363 (c_362_n c_907_n) capacitor c=1.0067e-17
    cc_362 (c_355_n c_907_n) capacitor c=1.39881e-17
    cc_361 (c_360_n c_906_n) capacitor c=1.0067e-17
    cc_360 (c_470_p c_936_n) capacitor c=5.73637e-18
    cc_359 (c_391_n c_932_n) capacitor c=2.29994e-19
    cc_358 (c_405_p c_932_n) capacitor c=8.28069e-18
    cc_357 (c_452_p c_932_n) capacitor c=5.73637e-18
    cc_356 (c_292_n c_932_n) capacitor c=2.41518e-18
    cc_355 (c_465_p c_931_n) capacitor c=1.32952e-18
    cc_354 (c_292_n c_903_n) capacitor c=1.32952e-18
    cc_353 (c_388_n c_839_n) capacitor c=3.02805e-18
    cc_352 (c_405_p c_839_n) capacitor c=2.53946e-19
    cc_351 (c_292_n c_839_n) capacitor c=8.08579e-19
    cc_350 (c_388_n c_836_n) capacitor c=2.49474e-18
    cc_349 (c_394_n c_831_n) capacitor c=5.22852e-19
    cc_348 (c_391_n c_831_n) capacitor c=3.51048e-18
    cc_347 (c_388_n c_831_n) capacitor c=9.90745e-18
    cc_346 (c_376_n c_831_n) capacitor c=2.00966e-18
    cc_345 (c_405_p c_831_n) capacitor c=4.96477e-19
    cc_344 (c_292_n c_831_n) capacitor c=4.67744e-19
    cc_343 (c_405_p c_845_n) capacitor c=7.06078e-19
    cc_342 (c_452_p c_845_n) capacitor c=2.76111e-19
    cc_341 (c_380_n c_823_n) capacitor c=2.35375e-18
    cc_340 (c_376_n c_823_n) capacitor c=1.91722e-18
    cc_339 (c_393_n c_579_n) capacitor c=2.64735e-19
    cc_338 (c_374_n c_579_n) capacitor c=9.96988e-19
    cc_337 (c_359_n c_579_n) capacitor c=1.53726e-18
    cc_336 (c_358_n c_579_n) capacitor c=1.51545e-18
    cc_335 (c_355_n c_579_n) capacitor c=2.65791e-17
    cc_334 (c_289_n c_579_n) capacitor c=1.74348e-18
    cc_333 (c_359_n c_578_n) capacitor c=1.19258e-17
    cc_332 (c_358_n c_578_n) capacitor c=1.19258e-17
    cc_331 (c_355_n c_578_n) capacitor c=8.11018e-17
    cc_330 (c_393_n c_573_n) capacitor c=2.76577e-18
    cc_329 (c_380_n c_573_n) capacitor c=6.3942e-18
    cc_328 (c_353_n c_573_n) capacitor c=3.6443e-18
    cc_327 (c_292_n c_573_n) capacitor c=8.58236e-18
    cc_326 (c_388_n c_570_n) capacitor c=5.38566e-19
    cc_325 (c_374_n c_570_n) capacitor c=7.48309e-19
    cc_324 (c_355_n c_570_n) capacitor c=1.3882e-18
    cc_323 (c_289_n c_570_n) capacitor c=5.52105e-19
    cc_322 (c_388_n c_563_n) capacitor c=1.55342e-18
    cc_321 (c_380_n c_563_n) capacitor c=8.29564e-18
    cc_320 (c_374_n c_563_n) capacitor c=1.65263e-17
    cc_319 (c_355_n c_563_n) capacitor c=4.32615e-18
    cc_318 (c_428_p c_563_n) capacitor c=5.52105e-19
    cc_317 (c_395_n c_615_n) capacitor c=1.7306e-18
    cc_316 (c_388_n c_560_n) capacitor c=6.6857e-19
    cc_315 (c_380_n c_560_n) capacitor c=2.13415e-18
    cc_314 (c_376_n c_560_n) capacitor c=5.92453e-18
    cc_313 (c_374_n c_560_n) capacitor c=4.50661e-19
    cc_312 (c_395_n c_607_n) capacitor c=1.16011e-18
    cc_311 (c_391_n c_607_n) capacitor c=1.16488e-17
    cc_310 (c_388_n c_607_n) capacitor c=2.04572e-18
    cc_309 (c_405_p c_607_n) capacitor c=8.29696e-19
    cc_308 (c_395_n c_558_n) capacitor c=1.7306e-18
    cc_307 (c_391_n c_554_n) capacitor c=5.67481e-19
    cc_306 (c_394_n c_602_n) capacitor c=1.46345e-18
    cc_305 (c_391_n c_602_n) capacitor c=2.44246e-17
    cc_304 (c_388_n c_602_n) capacitor c=7.29129e-18
    cc_303 (c_395_n c_549_n) capacitor c=2.3208e-18
    cc_302 (c_405_p c_549_n) capacitor c=8.71553e-18
    cc_301 (c_391_n c_596_n) capacitor c=5.48298e-19
    cc_300 (c_407_p c_596_n) capacitor c=1.19258e-17
    cc_299 (c_406_p c_596_n) capacitor c=1.19258e-17
    cc_298 (c_405_p c_596_n) capacitor c=8.11018e-17
    cc_297 (c_407_p c_593_n) capacitor c=2.25994e-18
    cc_296 (c_406_p c_593_n) capacitor c=8.12681e-18
    cc_295 (c_405_p c_593_n) capacitor c=1.88228e-17
    cc_294 (c_391_n c_591_n) capacitor c=4.14878e-17
    cc_293 (c_388_n c_591_n) capacitor c=1.33523e-17
    cc_292 (c_394_n c_547_n) capacitor c=1.7306e-18
    cc_291 (c_391_n c_547_n) capacitor c=1.13962e-18
    cc_290 (c_393_n c_586_n) capacitor c=2.9966e-18
    cc_289 (c_380_n c_586_n) capacitor c=5.49679e-17
    cc_288 (c_374_n c_586_n) capacitor c=1.35543e-17
    cc_287 (c_388_n c_540_n) capacitor c=3.45441e-18
    cc_286 (c_359_n c_540_n) capacitor c=1.3791e-18
    cc_285 (c_80_p net17) capacitor c=2.96644e-18
    cc_284 (c_126_p net17) capacitor c=4.92938e-19
    cc_283 (c_65_p c_1603_n) capacitor c=5.18809e-18
    cc_282 (c_126_p c_1602_n) capacitor c=1.32944e-18
    cc_281 (c_129_p c_1600_n) capacitor c=5.19307e-19
    cc_280 (c_126_p c_1600_n) capacitor c=5.43947e-18
    cc_279 (c_129_p c_1598_n) capacitor c=1.66675e-18
    cc_278 (c_126_p c_1598_n) capacitor c=2.02389e-18
    cc_277 (c_80_p c_1594_n) capacitor c=3.64187e-19
    cc_276 (c_126_p c_1594_n) capacitor c=1.79683e-18
    cc_275 (c_86_p c_1594_n) capacitor c=1.64971e-17
    cc_274 (c_65_p c_1594_n) capacitor c=4.54599e-19
    cc_273 (c_65_p c_1593_n) capacitor c=3.54909e-18
    cc_272 (c_65_p c_1592_n) capacitor c=1.41862e-18
    cc_271 (c_55_p MM16_ELT_s) capacitor c=1.112e-18
    cc_270 (c_65_p MM16_ELT_s) capacitor c=4.23579e-18
    cc_269 (c_124_p c_1444_n) capacitor c=1.00251e-17
    cc_268 (c_139_p c_1443_n) capacitor c=1.00251e-17
    cc_267 (c_212_p c_1442_n) capacitor c=1.00251e-17
    cc_266 (c_64_p c_1323_n) capacitor c=1.40391e-17
    cc_265 (c_60_p c_1323_n) capacitor c=7.31348e-18
    cc_264 (c_64_p c_1321_n) capacitor c=1.07074e-18
    cc_263 (c_51_n c_1321_n) capacitor c=1.30831e-18
    cc_262 (c_64_p c_1320_n) capacitor c=1.11099e-18
    cc_261 (c_64_p c_1316_n) capacitor c=1.63537e-18
    cc_260 (c_63_p c_1316_n) capacitor c=2.35616e-18
    cc_259 (c_60_p c_1316_n) capacitor c=7.8953e-19
    cc_258 (c_59_p c_1316_n) capacitor c=1.16181e-18
    cc_257 (c_64_p c_1312_n) capacitor c=1.16181e-18
    cc_256 (c_63_p c_1312_n) capacitor c=1.60381e-18
    cc_255 (c_60_p c_1312_n) capacitor c=2.64832e-18
    cc_254 (c_59_p c_1312_n) capacitor c=9.09731e-18
    cc_253 (c_64_p c_1309_n) capacitor c=2.65299e-19
    cc_252 (c_60_p c_1309_n) capacitor c=1.91721e-18
    cc_251 (c_59_p c_1309_n) capacitor c=1.93426e-18
    cc_250 (c_64_p c_1302_n) capacitor c=2.83004e-17
    cc_249 (c_64_p c_1301_n) capacitor c=8.59931e-18
    cc_248 (c_62_p c_1301_n) capacitor c=2.11589e-17
    cc_247 (c_51_n c_1301_n) capacitor c=6.83728e-18
    cc_246 (c_58_p c_1301_n) capacitor c=6.67601e-17
    cc_245 (c_106_p c_1301_n) capacitor c=1.27393e-18
    cc_244 (c_65_p c_1219_n) capacitor c=4.23606e-18
    cc_243 (c_51_n c_1218_n) capacitor c=1.87542e-18
    cc_242 (c_66_p c_1216_n) capacitor c=2.2962e-18
    cc_241 (c_65_p c_1216_n) capacitor c=1.25434e-18
    cc_240 (c_65_p c_1215_n) capacitor c=1.41862e-18
    cc_239 (c_65_p c_1214_n) capacitor c=7.12918e-19
    cc_238 (c_55_p c_1210_n) capacitor c=3.47801e-19
    cc_237 (c_51_n c_1210_n) capacitor c=1.06307e-18
    cc_236 (c_126_p c_1210_n) capacitor c=1.77698e-18
    cc_235 (c_66_p c_1210_n) capacitor c=9.2187e-17
    cc_234 (c_56_p c_1204_n) capacitor c=3.56679e-18
    cc_233 (c_55_p c_1204_n) capacitor c=2.9118e-18
    cc_232 (c_56_p c_1203_n) capacitor c=1.31028e-18
    cc_231 (c_51_n c_1203_n) capacitor c=7.25166e-18
    cc_230 (c_66_p c_1203_n) capacitor c=3.48146e-17
    cc_229 (c_126_p c_1136_n) capacitor c=5.81949e-19
    cc_228 (c_129_p c_1135_n) capacitor c=5.81949e-19
    cc_227 (c_212_p c_1133_n) capacitor c=3.6746e-19
    cc_226 (c_124_p c_1133_n) capacitor c=6.74581e-19
    cc_225 (c_212_p c_1132_n) capacitor c=9.42341e-19
    cc_224 (c_126_p c_1100_n) capacitor c=8.46739e-18
    cc_223 (c_194_p c_1097_n) capacitor c=3.69684e-18
    cc_222 (c_134_p c_1097_n) capacitor c=6.1362e-18
    cc_221 (c_126_p c_1097_n) capacitor c=8.53997e-18
    cc_220 (c_126_p c_1095_n) capacitor c=1.98481e-18
    cc_219 (c_86_p c_1095_n) capacitor c=2.97542e-18
    cc_218 (c_86_p c_1094_n) capacitor c=2.24521e-17
    cc_217 (c_211_p c_998_n) capacitor c=8.89676e-18
    cc_216 (c_134_p c_998_n) capacitor c=1.10592e-18
    cc_215 (c_211_p CDN) capacitor c=1.37527e-18
    cc_214 (c_134_p CDN) capacitor c=8.23154e-18
    cc_213 (c_129_p CDN) capacitor c=1.36512e-18
    cc_212 (c_129_p c_993_n) capacitor c=5.44862e-19
    cc_211 (c_126_p c_993_n) capacitor c=1.05811e-18
    cc_210 (c_126_p c_991_n) capacitor c=2.56999e-19
    cc_209 (c_212_p c_991_n) capacitor c=9.01167e-19
    cc_208 (c_211_p c_926_n) capacitor c=3.70405e-19
    cc_207 (c_194_p c_926_n) capacitor c=8.573e-18
    cc_206 (c_129_p c_926_n) capacitor c=1.22177e-18
    cc_205 (c_126_p c_926_n) capacitor c=1.22752e-18
    cc_204 (c_80_p c_924_n) capacitor c=2.71726e-18
    cc_203 (c_87_p c_924_n) capacitor c=2.37887e-18
    cc_202 (c_124_p c_921_n) capacitor c=1.99666e-17
    cc_201 (c_123_p c_921_n) capacitor c=3.39234e-17
    cc_200 (c_57_p c_921_n) capacitor c=2.63219e-18
    cc_199 (c_63_p c_918_n) capacitor c=9.00996e-18
    cc_198 (c_60_p c_918_n) capacitor c=7.97624e-19
    cc_197 (c_200_p c_918_n) capacitor c=2.83209e-18
    cc_196 (c_194_p D) capacitor c=1.21238e-18
    cc_195 (c_129_p D) capacitor c=9.11721e-18
    cc_194 (c_80_p D) capacitor c=2.47461e-17
    cc_193 (c_124_p D) capacitor c=4.47226e-19
    cc_192 (c_87_p D) capacitor c=4.05891e-19
    cc_191 (c_194_p c_911_n) capacitor c=1.51747e-18
    cc_190 (c_126_p c_911_n) capacitor c=3.52879e-18
    cc_189 (c_126_p c_910_n) capacitor c=7.88641e-18
    cc_188 (c_129_p c_907_n) capacitor c=4.41491e-18
    cc_187 (c_126_p c_907_n) capacitor c=9.67725e-18
    cc_186 (c_86_p c_907_n) capacitor c=4.39889e-18
    cc_185 (c_65_p c_906_n) capacitor c=4.39889e-18
    cc_184 (c_113_p c_905_n) capacitor c=1.70815e-18
    cc_183 (c_63_p c_903_n) capacitor c=6.03125e-18
    cc_182 (c_60_p c_903_n) capacitor c=1.08204e-18
    cc_181 (c_63_p c_839_n) capacitor c=3.7e-19
    cc_180 (c_60_p c_839_n) capacitor c=3.8191e-19
    cc_179 (c_59_p c_839_n) capacitor c=1.35761e-18
    cc_178 (c_113_p c_839_n) capacitor c=4.35474e-19
    cc_177 (c_63_p c_836_n) capacitor c=2.61348e-19
    cc_176 (c_60_p c_836_n) capacitor c=3.51271e-19
    cc_175 (c_113_p c_836_n) capacitor c=2.64115e-18
    cc_174 (c_63_p c_831_n) capacitor c=1.14781e-18
    cc_173 (c_60_p c_831_n) capacitor c=7.92516e-18
    cc_172 (c_59_p c_831_n) capacitor c=9.87021e-19
    cc_171 (c_58_p c_831_n) capacitor c=3.41269e-19
    cc_170 (c_57_p c_831_n) capacitor c=2.57072e-18
    cc_169 (c_60_p c_830_n) capacitor c=5.52757e-19
    cc_168 (c_60_p c_826_n) capacitor c=6.02329e-19
    cc_167 (c_113_p c_826_n) capacitor c=1.19258e-17
    cc_166 (c_87_p c_826_n) capacitor c=1.19258e-17
    cc_165 (c_57_p c_826_n) capacitor c=8.11018e-17
    cc_164 (c_113_p c_823_n) capacitor c=7.1717e-18
    cc_163 (c_87_p c_823_n) capacitor c=1.70787e-18
    cc_162 (c_57_p c_823_n) capacitor c=1.56899e-17
    cc_161 (c_56_p c_579_n) capacitor c=3.05186e-18
    cc_160 (c_51_n c_579_n) capacitor c=2.08251e-18
    cc_159 (c_86_p c_579_n) capacitor c=2.9945e-17
    cc_158 (c_65_p c_579_n) capacitor c=1.77851e-17
    cc_157 (c_78_p c_579_n) capacitor c=4.46254e-19
    cc_156 (c_65_p c_578_n) capacitor c=1.96161e-18
    cc_155 (c_64_p c_573_n) capacitor c=2.53575e-18
    cc_154 (c_63_p c_573_n) capacitor c=2.76577e-18
    cc_153 (c_60_p c_573_n) capacitor c=8.6898e-19
    cc_152 (c_57_p c_573_n) capacitor c=9.17313e-17
    cc_151 (c_78_p c_573_n) capacitor c=2.36833e-17
    cc_150 (c_56_p c_570_n) capacitor c=8.28278e-19
    cc_149 (c_51_n c_570_n) capacitor c=2.83021e-17
    cc_148 (c_65_p c_570_n) capacitor c=3.69951e-18
    cc_147 (c_56_p c_566_n) capacitor c=1.50327e-18
    cc_146 (c_51_n c_566_n) capacitor c=3.63276e-18
    cc_145 (c_86_p c_566_n) capacitor c=6.99428e-18
    cc_144 (c_65_p c_566_n) capacitor c=1.85437e-18
    cc_143 (c_129_p c_563_n) capacitor c=1.75334e-18
    cc_142 (c_86_p c_563_n) capacitor c=3.89935e-18
    cc_141 (c_60_p c_563_n) capacitor c=5.40352e-19
    cc_140 (c_63_p c_560_n) capacitor c=1.79541e-18
    cc_139 (c_60_p c_560_n) capacitor c=3.08498e-18
    cc_138 (c_57_p c_560_n) capacitor c=5.95597e-18
    cc_137 (c_78_p c_559_n) capacitor c=1.81268e-18
    cc_136 (c_139_p c_558_n) capacitor c=1.24438e-18
    cc_135 (c_134_p c_554_n) capacitor c=6.02329e-19
    cc_134 (c_117_p c_554_n) capacitor c=1.19258e-17
    cc_133 (c_132_p c_554_n) capacitor c=1.19258e-17
    cc_132 (c_124_p c_554_n) capacitor c=8.11018e-17
    cc_131 (c_134_p c_550_n) capacitor c=1.8669e-18
    cc_130 (c_117_p c_550_n) capacitor c=7.42107e-18
    cc_129 (c_132_p c_550_n) capacitor c=2.3745e-18
    cc_128 (c_124_p c_550_n) capacitor c=1.59153e-17
    cc_127 (c_117_p c_549_n) capacitor c=3.95088e-19
    cc_126 (c_129_p c_547_n) capacitor c=1.07712e-18
    cc_125 (c_116_p c_547_n) capacitor c=6.14699e-19
    cc_124 (c_124_p c_546_n) capacitor c=3.37548e-18
    cc_123 (c_126_p c_540_n) capacitor c=1.33414e-18
    cc_122 (c_60_p c_540_n) capacitor c=2.75923e-19
    cc_121 (c_124_p c_540_n) capacitor c=3.37548e-18
    cc_120 (c_123_p c_540_n) capacitor c=4.45122e-18
    cc_119 (c_87_p c_540_n) capacitor c=8.66663e-18
    cc_118 (c_78_p c_540_n) capacitor c=2.32378e-18
    cc_117 (c_117_p c_395_n) capacitor c=5.57437e-18
    cc_116 (c_116_p c_394_n) capacitor c=5.23477e-18
    cc_115 (c_78_p c_393_n) capacitor c=1.82075e-18
    cc_114 (c_117_p c_391_n) capacitor c=7.67457e-19
    cc_113 (c_116_p c_391_n) capacitor c=5.56352e-19
    cc_112 (c_63_p c_388_n) capacitor c=3.69583e-18
    cc_111 (c_60_p c_388_n) capacitor c=1.10879e-17
    cc_110 (c_113_p c_388_n) capacitor c=5.69761e-19
    cc_109 (c_60_p c_387_n) capacitor c=4.08306e-18
    cc_108 (c_64_p c_380_n) capacitor c=1.39506e-18
    cc_107 (c_62_p c_380_n) capacitor c=2.29998e-17
    cc_106 (c_51_n c_380_n) capacitor c=8.61811e-18
    cc_105 (c_60_p c_380_n) capacitor c=8.74484e-18
    cc_104 (c_58_p c_380_n) capacitor c=9.99437e-18
    cc_103 (c_106_p c_380_n) capacitor c=1.0045e-18
    cc_102 (c_57_p c_380_n) capacitor c=1.60613e-18
    cc_101 (c_62_p c_376_n) capacitor c=1.95409e-18
    cc_100 (c_51_n c_376_n) capacitor c=1.26544e-17
    cc_99 (c_58_p c_376_n) capacitor c=6.97572e-18
    cc_98 (c_57_p c_376_n) capacitor c=1.28278e-18
    cc_97 (c_60_p c_374_n) capacitor c=5.51797e-19
    cc_96 (c_78_p c_374_n) capacitor c=2.82896e-19
    cc_95 (c_56_p c_369_n) capacitor c=2.96741e-18
    cc_94 (c_62_p c_369_n) capacitor c=2.06291e-18
    cc_93 (c_51_n c_369_n) capacitor c=1.68414e-17
    cc_92 (c_65_p c_369_n) capacitor c=5.73046e-18
    cc_91 (c_60_p c_369_n) capacitor c=4.56106e-19
    cc_90 (c_51_n c_324_n) capacitor c=7.74788e-18
    cc_89 (c_51_n c_309_n) capacitor c=8.2055e-18
    cc_88 (c_62_p c_303_n) capacitor c=4.84352e-19
    cc_87 (c_51_n c_303_n) capacitor c=2.01116e-18
    cc_86 (c_56_p c_296_n) capacitor c=4.8961e-19
    cc_85 (c_51_n c_296_n) capacitor c=2.46399e-18
    cc_84 (c_87_p c_362_n) capacitor c=1.60098e-18
    cc_83 (c_86_p c_360_n) capacitor c=3.85832e-18
    cc_82 (c_65_p c_360_n) capacitor c=3.40885e-18
    cc_81 (c_78_p c_359_n) capacitor c=1.60098e-18
    cc_80 (c_65_p c_358_n) capacitor c=6.9226e-18
    cc_79 (c_56_p c_355_n) capacitor c=9.31123e-19
    cc_78 (c_51_n c_355_n) capacitor c=1.10368e-18
    cc_77 (c_80_p c_355_n) capacitor c=4.88462e-18
    cc_76 (c_65_p c_354_n) capacitor c=5.65541e-18
    cc_75 (c_78_p c_353_n) capacitor c=5.25465e-18
    cc_74 (c_65_p c_352_n) capacitor c=3.61829e-18
    cc_73 (c_64_p c_350_n) capacitor c=5.09084e-18
    cc_72 (c_59_p c_350_n) capacitor c=2.07718e-18
    cc_71 (c_64_p c_347_n) capacitor c=5.09084e-18
    cc_70 (c_62_p c_347_n) capacitor c=1.87476e-18
    cc_69 (c_51_n c_347_n) capacitor c=3.21353e-18
    cc_68 (c_56_p c_344_n) capacitor c=1.8646e-18
    cc_67 (c_55_p c_344_n) capacitor c=1.19258e-17
    cc_66 (c_51_n c_344_n) capacitor c=2.73208e-18
    cc_65 (c_56_p c_340_n) capacitor c=4.91574e-18
    cc_64 (c_55_p c_340_n) capacitor c=1.19258e-17
    cc_63 (c_66_p c_340_n) capacitor c=2.44725e-18
    cc_62 (c_65_p c_340_n) capacitor c=1.5973e-18
    cc_61 (c_64_p c_292_n) capacitor c=2.87982e-16
    cc_60 (c_63_p c_292_n) capacitor c=6.35214e-18
    cc_59 (c_62_p c_292_n) capacitor c=9.57897e-18
    cc_58 (c_51_n c_292_n) capacitor c=4.77502e-18
    cc_57 (c_60_p c_292_n) capacitor c=1.10608e-17
    cc_56 (c_59_p c_292_n) capacitor c=1.63195e-17
    cc_55 (c_58_p c_292_n) capacitor c=1.9831e-17
    cc_54 (c_57_p c_292_n) capacitor c=7.38389e-18
    cc_53 (c_56_p c_289_n) capacitor c=9.41882e-18
    cc_52 (c_55_p c_289_n) capacitor c=8.11018e-17
    cc_51 (c_51_n c_289_n) capacitor c=3.09819e-18
    cc_50 (c_7_p c_1302_n) capacitor c=1.48827e-16
    cc_49 (c_7_p c_1301_n) capacitor c=3.18718e-17
    cc_48 (c_48_p c_1300_n) capacitor c=1.02385e-17
    cc_47 (c_1_p c_1204_n) capacitor c=5.12972e-17
    cc_46 (c_46_p c_1203_n) capacitor c=1.13714e-17
    cc_45 (E c_1201_n) capacitor c=1.35796e-18
    cc_44 (c_44_p c_1201_n) capacitor c=7.84631e-18
    cc_43 (c_26_p c_327_n) capacitor c=8.81675e-18
    cc_42 (E c_327_n) capacitor c=1.31744e-18
    cc_41 (c_26_p c_325_n) capacitor c=1.178e-18
    cc_40 (E c_325_n) capacitor c=1.48787e-17
    cc_39 (c_7_p c_324_n) capacitor c=1.81623e-18
    cc_38 (c_1_p c_323_n) capacitor c=3.00563e-19
    cc_37 (c_26_p c_320_n) capacitor c=1.70798e-18
    cc_36 (E c_320_n) capacitor c=9.64017e-18
    cc_35 (c_21_p c_320_n) capacitor c=7.81825e-18
    cc_34 (c_26_p c_316_n) capacitor c=2.05691e-19
    cc_33 (c_8_p c_316_n) capacitor c=1.7575e-18
    cc_32 (c_21_p c_316_n) capacitor c=7.28381e-19
    cc_31 (c_7_p c_316_n) capacitor c=4.9275e-18
    cc_30 (c_26_p c_312_n) capacitor c=1.88446e-18
    cc_29 (E c_312_n) capacitor c=1.55345e-17
    cc_28 (c_13_p c_312_n) capacitor c=1.76499e-18
    cc_27 (c_1_p c_312_n) capacitor c=2.7695e-18
    cc_26 (c_26_p c_309_n) capacitor c=3.82474e-19
    cc_25 (c_2_p c_309_n) capacitor c=4.45698e-18
    cc_24 (c_13_p c_309_n) capacitor c=3.44179e-18
    cc_23 (E c_305_n) capacitor c=4.29218e-19
    cc_22 (c_19_p c_305_n) capacitor c=5.09084e-18
    cc_21 (c_21_p c_305_n) capacitor c=5.09084e-18
    cc_20 (c_7_p c_305_n) capacitor c=2.66348e-16
    cc_19 (c_19_p c_303_n) capacitor c=2.07718e-18
    cc_18 (c_7_p c_303_n) capacitor c=8.72852e-17
    cc_17 (E c_299_n) capacitor c=5.62162e-19
    cc_16 (c_13_p c_299_n) capacitor c=1.19258e-17
    cc_15 (c_12_p c_299_n) capacitor c=1.19258e-17
    cc_14 (c_1_p c_299_n) capacitor c=8.11018e-17
    cc_13 (c_13_p c_296_n) capacitor c=6.14207e-18
    cc_12 (c_12_p c_296_n) capacitor c=2.25994e-18
    cc_11 (c_1_p c_296_n) capacitor c=2.11751e-17
    cc_10 (c_10_p c_295_n) capacitor c=4.28479e-18
    cc_9 (E c_292_n) capacitor c=3.81854e-19
    cc_8 (c_8_p c_292_n) capacitor c=4.28479e-18
    cc_7 (c_7_p c_292_n) capacitor c=7.02134e-18
    cc_6 (E c_289_n) capacitor c=3.81854e-19
    cc_5 (c_2_p c_289_n) capacitor c=4.13183e-18
    cc_4 (c_1_p c_289_n) capacitor c=6.96457e-18
    cc_3 (E c_51_n) capacitor c=2.10406e-18
    cc_2 (c_2_p c_51_n) capacitor c=2.61623e-19
    cc_1 (c_1_p c_51_n) capacitor c=2.88537e-19
    cinet29_15 (c_1611_n VSS) capacitor c=1.73116e-19
    cinet72_19 (c_1580_n VSS) capacitor c=1.0387e-19
    ciQ_141 (c_1447_n VSS) capacitor c=7.69343e-18
    ciQ_140 (c_1442_n VSS) capacitor c=1.05173e-19
    ciQ_139 (c_1444_n VSS) capacitor c=5.20972e-18
    ciQ_138 (c_1509_n VSS) capacitor c=1.13083e-19
    ciQ_137 (c_1527_n VSS) capacitor c=1.79793e-20
    ciQ_136 (c_1461_n VSS) capacitor c=8.82584e-18
    ciQ_135 (c_1466_n VSS) capacitor c=1.15417e-17
    ciQ_134 (c_1468_n VSS) capacitor c=6.47934e-19
    ciQ_133 (c_1472_n VSS) capacitor c=1.75629e-18
    ciQ_132 (c_1482_n VSS) capacitor c=1.15889e-20
    ciQ_131 (Q VSS) capacitor c=1.65717e-17
    ciQ_130 (c_1491_n VSS) capacitor c=3.56888e-20
    ciQ_129 (c_1448_n VSS) capacitor c=2.15534e-17
    ciVDD_155 (c_1300_n VSS) capacitor c=4.86652e-17
    ciVDD_154 (c_1301_n VSS) capacitor c=4.25321e-18
    ciVDD_153 (c_1302_n VSS) capacitor c=1.02587e-19
    ciVDD_152 (c_1309_n VSS) capacitor c=3.25161e-17
    ciVDD_151 (c_1312_n VSS) capacitor c=4.07568e-18
    ciVDD_150 (c_1342_n VSS) capacitor c=7.4241e-17
    ciVDD_149 (c_1345_n VSS) capacitor c=4.3278e-18
    ciVDD_148 (c_1365_n VSS) capacitor c=4.47773e-17
    ciVDD_147 (c_1368_n VSS) capacitor c=4.50612e-18
    ciVDD_146 (c_1374_n VSS) capacitor c=6.38386e-17
    ciVDD_145 (VDD_70 VSS) capacitor c=3.58509e-18
    ciVDD_144 (VDD_71 VSS) capacitor c=3.58509e-18
    ciVDD_143 (VDD_72 VSS) capacitor c=3.58509e-18
    ciVDD_142 (VDD_73 VSS) capacitor c=3.58509e-18
    ciVSS_108 (c_1201_n VSS) capacitor c=4.7974e-17
    ciVSS_107 (c_1203_n VSS) capacitor c=5.35129e-18
    ciVSS_106 (c_1210_n VSS) capacitor c=1.11464e-16
    ciVSS_105 (c_1214_n VSS) capacitor c=4.12329e-18
    ciVSS_104 (c_1241_n VSS) capacitor c=3.26695e-17
    ciVSS_103 (c_1242_n VSS) capacitor c=4.07568e-18
    ciVSS_102 (c_1245_n VSS) capacitor c=6.3463e-17
    ciVSS_101 (VSS_54 VSS) capacitor c=3.58509e-18
    ciVSS_100 (VSS_55 VSS) capacitor c=3.58509e-18
    ciVSS_99 (VSS_56 VSS) capacitor c=3.58509e-18
    cinet25_73 (c_1142_n VSS) capacitor c=2.14712e-20
    cinet25_72 (c_1145_n VSS) capacitor c=6.55848e-20
    cinet25_71 (c_1135_n VSS) capacitor c=5.36053e-18
    cinet25_70 (c_1165_n VSS) capacitor c=2.31777e-20
    cinet25_69 (c_1136_n VSS) capacitor c=2.27032e-20
    cinet20_41 (c_1095_n VSS) capacitor c=2.31777e-20
    cinet20_40 (c_1097_n VSS) capacitor c=4.43492e-18
    cinet20_39 (c_1113_n VSS) capacitor c=2.31777e-20
    cinet20_38 (c_1117_n VSS) capacitor c=5.49587e-20
    ciCDN_115 (c_993_n VSS) capacitor c=3.32895e-18
    ciCDN_114 (c_1028_p VSS) capacitor c=4.84664e-20
    ciCDN_113 (c_1031_p VSS) capacitor c=4.87848e-20
    ciCDN_112 (c_1000_n VSS) capacitor c=2.87212e-18
    ciCDN_111 (c_1048_p VSS) capacitor c=2.27032e-20
    ciCDN_110 (c_1003_n VSS) capacitor c=5.75609e-17
    ciCDN_109 (c_1010_n VSS) capacitor c=1.50888e-19
    ciCDN_108 (CDN VSS) capacitor c=1.3067e-17
    ciCDN_107 (c_1037_p VSS) capacitor c=7.0057e-18
    ciCDN_106 (c_1018_n VSS) capacitor c=1.74565e-17
    ciCDN_105 (c_998_n VSS) capacitor c=7.93196e-18
    ciCDN_104 (c_1083_p VSS) capacitor c=1.34953e-18
    ciCDN_103 (c_1045_p VSS) capacitor c=1.68894e-18
    ciD_98 (c_932_n VSS) capacitor c=7.0456e-18
    ciD_97 (c_905_n VSS) capacitor c=2.77056e-20
    ciD_96 (c_907_n VSS) capacitor c=5.27644e-18
    ciD_95 (c_980_p VSS) capacitor c=8.02167e-20
    ciD_94 (c_910_n VSS) capacitor c=3.40619e-20
    ciD_93 (D VSS) capacitor c=8.14867e-18
    ciD_92 (c_944_n VSS) capacitor c=2.05094e-17
    ciD_91 (c_918_n VSS) capacitor c=2.36426e-18
    ciD_90 (c_921_n VSS) capacitor c=4.58512e-17
    ciD_89 (c_924_n VSS) capacitor c=1.23866e-17
    ciD_88 (c_926_n VSS) capacitor c=6.85859e-18
    cinet49_82 (c_845_n VSS) capacitor c=1.03484e-19
    cinet49_81 (c_831_n VSS) capacitor c=5.60686e-18
    cinet49_80 (c_839_n VSS) capacitor c=1.22901e-18
    cinet67_307 (c_668_p VSS) capacitor c=4.92745e-18
    cinet67_306 (c_671_p VSS) capacitor c=4.62705e-18
    cinet67_305 (c_770_p VSS) capacitor c=3.56888e-20
    cinet67_304 (c_540_n VSS) capacitor c=4.07487e-18
    cinet67_303 (c_546_n VSS) capacitor c=1.24103e-17
    cinet67_302 (c_547_n VSS) capacitor c=1.73684e-18
    cinet67_301 (c_591_n VSS) capacitor c=2.26199e-18
    cinet67_300 (c_549_n VSS) capacitor c=1.93845e-19
    cinet67_299 (c_550_n VSS) capacitor c=4.68065e-20
    cinet67_298 (c_554_n VSS) capacitor c=2.14712e-20
    cinet67_297 (c_558_n VSS) capacitor c=1.24091e-18
    cinet67_296 (c_607_n VSS) capacitor c=3.67672e-18
    cinet67_295 (c_692_p VSS) capacitor c=4.56151e-18
    cinet67_294 (c_670_p VSS) capacitor c=3.926e-18
    cinet67_293 (c_673_p VSS) capacitor c=1.55114e-17
    cinet67_292 (c_669_p VSS) capacitor c=1.18839e-18
    cinet67_291 (c_674_p VSS) capacitor c=1.63184e-17
    cinet67_290 (c_675_p VSS) capacitor c=1.62951e-19
    cinet67_289 (c_676_p VSS) capacitor c=1.15889e-20
    cinet67_288 (c_560_n VSS) capacitor c=3.60279e-19
    cinet67_287 (c_615_n VSS) capacitor c=6.28306e-19
    cinet67_286 (c_563_n VSS) capacitor c=2.0522e-18
    cinet67_285 (c_688_p VSS) capacitor c=9.98325e-18
    cinet67_284 (c_766_p VSS) capacitor c=7.48772e-18
    cinet67_283 (c_578_n VSS) capacitor c=2.31777e-20
    ciENN_274 (c_289_n VSS) capacitor c=4.05501e-18
    ciENN_273 (c_292_n VSS) capacitor c=4.10114e-18
    ciENN_272 (c_354_n VSS) capacitor c=1.76511e-19
    ciENN_271 (c_355_n VSS) capacitor c=5.41405e-18
    ciENN_270 (c_362_n VSS) capacitor c=1.5819e-19
    ciENN_269 (c_405_p VSS) capacitor c=6.13447e-18
    ciENN_268 (c_299_n VSS) capacitor c=2.17258e-20
    ciENN_267 (c_305_n VSS) capacitor c=7.68117e-20
    ciENN_266 (c_309_n VSS) capacitor c=9.51036e-20
    ciENN_265 (c_323_n VSS) capacitor c=7.20955e-19
    ciENN_264 (c_324_n VSS) capacitor c=1.33506e-18
    ciENN_263 (c_369_n VSS) capacitor c=5.81502e-18
    ciENN_262 (c_374_n VSS) capacitor c=9.34066e-18
    ciENN_261 (c_325_n VSS) capacitor c=1.03112e-18
    ciENN_260 (ENN_297 VSS) capacitor c=2.32177e-18
    ciENN_259 (c_376_n VSS) capacitor c=7.71993e-18
    ciENN_258 (c_380_n VSS) capacitor c=8.77987e-18
    ciENN_257 (c_387_n VSS) capacitor c=9.73644e-19
    ciENN_256 (c_388_n VSS) capacitor c=8.83224e-18
    ciENN_255 (c_391_n VSS) capacitor c=7.66893e-18
    ciENN_254 (c_393_n VSS) capacitor c=1.98027e-17
    ciENN_253 (c_394_n VSS) capacitor c=9.8344e-18
    ciENN_252 (c_395_n VSS) capacitor c=9.68686e-18
    ciENN_251 (c_327_n VSS) capacitor c=1.41971e-17
    ciEN_258 (c_78_p VSS) capacitor c=1.74657e-19
    ciEN_257 (c_57_p VSS) capacitor c=5.34438e-18
    ciEN_256 (c_113_p VSS) capacitor c=4.33902e-20
    ciEN_255 (c_123_p VSS) capacitor c=1.06119e-19
    ciEN_254 (c_124_p VSS) capacitor c=4.83157e-18
    ciEN_253 (c_139_p VSS) capacitor c=1.11849e-19
    ciEN_252 (c_106_p VSS) capacitor c=9.18465e-20
    ciEN_251 (c_60_p VSS) capacitor c=1.15774e-18
    ciEN_250 (c_65_p VSS) capacitor c=4.19562e-18
    ciEN_249 (c_126_p VSS) capacitor c=3.17503e-20
    ciEN_248 (c_80_p VSS) capacitor c=7.6044e-20
    ciEN_247 (c_129_p VSS) capacitor c=2.92684e-18
    ciEN_246 (c_134_p VSS) capacitor c=3.00961e-19
    ciEN_245 (c_51_n VSS) capacitor c=1.92635e-18
    ciEN_244 (c_62_p VSS) capacitor c=3.91266e-20
    ciEN_243 (c_63_p VSS) capacitor c=2.63354e-17
    ciEN_242 (c_194_p VSS) capacitor c=1.08974e-17
    ciEN_241 (c_211_p VSS) capacitor c=1.48561e-17
    ciEN_240 (c_55_p VSS) capacitor c=2.17258e-20
    ciEN_239 (c_56_p VSS) capacitor c=3.94126e-19
    ciEN_238 (c_64_p VSS) capacitor c=7.68117e-20
    ciE_54 (c_1_p VSS) capacitor c=5.88002e-18
    ciE_53 (c_7_p VSS) capacitor c=5.93505e-18
    ciE_52 (c_12_p VSS) capacitor c=1.90596e-20
    ciE_51 (E VSS) capacitor c=1.2495e-17
    ciE_50 (c_26_p VSS) capacitor c=1.77375e-17
    rnet29_41 (MM11_ELT_s net29_2) resistor r=18.0507
    rnet29_40 (MM11_ELT_s c_1611_n) resistor r=15.1041
    rnet29_39 (MM11_ELT_s c_1611_n) resistor r=2.67027
    rnet29_38 (MM11_ELT_s net29_7) resistor r=12.8495
    rnet29_37 (MM11_ELT_s net29_7) resistor r=1.69926
    rnet29_36 (MM11_ELT_s net29_11) resistor r=4.22001
    rnet29_35 (MM11_ELT_s net29) resistor r=10.6787
    rnet29_34 (net29_2 c_1610_n) resistor r=9.43134
    rnet29_33 (c_1610_n c_1611_n) resistor r=15.1041
    rnet29_32 (net29_6 net29_7) resistor r=12.8495
    rnet29_31 (net29_6 net29_18) resistor r=10.6787
    rnet29_30 (net29_8 net29_11) resistor r=4.22001
    rnet29_29 (net29_8 net29_18) resistor r=0.57282
    rnet29_28 (net29_9 net29_11) resistor r=4.22001
    rnet29_27 (net29_9 net29) resistor r=0.57282
    rnet29_26 (MM12_ELT_d net29_11) resistor r=4.22001
    rnet29_25 (MM12_ELT_d c_1622_n) resistor r=15.1041
    rnet29_24 (MM12_ELT_d c_1622_n) resistor r=2.67027
    rnet29_23 (MM12_ELT_d c_1615_n) resistor r=12.1643
    rnet29_22 (MM12_ELT_d c_1615_n) resistor r=1.36649
    rnet29_21 (MM12_ELT_d net29_17) resistor r=18.0507
    rnet29_20 (MM12_ELT_d net29_18) resistor r=10.6787
    rnet29_19 (c_1620_n c_1622_n) resistor r=15.1041
    rnet29_18 (c_1620_n net29_17) resistor r=9.43134
    rnet29_17 (net29_15 c_1615_n) resistor r=12.1643
    rnet29_16 (net29_15 net29) resistor r=10.6787
    rnet17_48 (MM16_ELT_s net17_2) resistor r=18.0507
    rnet17_47 (MM16_ELT_s c_1593_n) resistor r=2.67027
    rnet17_46 (MM16_ELT_s net17_7) resistor r=12.8495
    rnet17_45 (MM16_ELT_s net17_7) resistor r=1.69926
    rnet17_44 (MM16_ELT_s c_1594_n) resistor r=4.22001
    rnet17_43 (net17_2 c_1592_n) resistor r=9.43134
    rnet17_42 (net17_3 c_1593_n) resistor r=15.1041
    rnet17_41 (net17_3 c_1603_n) resistor r=11.0157
    rnet17_40 (c_1592_n c_1593_n) resistor r=15.1041
    rnet17_39 (net17_6 net17_7) resistor r=12.8495
    rnet17_38 (net17_6 net17) resistor r=10.6787
    rnet17_37 (net17_8 c_1594_n) resistor r=4.22001
    rnet17_36 (net17_8 c_1603_n) resistor r=0.762262
    rnet17_35 (net17_9 c_1594_n) resistor r=4.22001
    rnet17_34 (net17_9 net17) resistor r=0.57282
    rnet17_33 (MM17_ELT_d c_1594_n) resistor r=4.22001
    rnet17_32 (MM17_ELT_d net17_14) resistor r=2.67027
    rnet17_31 (MM17_ELT_d c_1600_n) resistor r=12.8495
    rnet17_30 (MM17_ELT_d c_1600_n) resistor r=1.69926
    rnet17_29 (MM17_ELT_d c_1602_n) resistor r=4.557
    rnet17_28 (MM17_ELT_d net17) resistor r=10.6787
    rnet17_27 (net17_12 net17_14) resistor r=15.1041
    rnet17_26 (net17_12 net17_17) resistor r=9.43134
    rnet17_25 (net17_13 net17_14) resistor r=15.1041
    rnet17_24 (net17_13 c_1603_n) resistor r=11.0157
    rnet17_23 (c_1598_n c_1600_n) resistor r=12.8495
    rnet17_22 (c_1598_n net17_18) resistor r=9.4369
    rnet17_21 (net17_17 c_1602_n) resistor r=21.1301
    rnet17_20 (net17_18 c_1602_n) resistor r=21.1301
    rnet72_48 (net72_1 c_1571_n) resistor r=20.2547
    rnet72_47 (net72_1 net72_5) resistor r=9.04595
    rnet72_46 (net72_2 c_1571_n) resistor r=20.2547
    rnet72_45 (net72_2 net72_8) resistor r=9.04062
    rnet72_44 (MM10_ELT_s c_1571_n) resistor r=4.36821
    rnet72_43 (MM10_ELT_s c_1572_n) resistor r=12.3172
    rnet72_42 (MM10_ELT_s c_1572_n) resistor r=1.62887
    rnet72_41 (MM10_ELT_s c_1576_n) resistor r=2.55965
    rnet72_40 (MM10_ELT_s c_1579_n) resistor r=4.04518
    rnet72_39 (MM10_ELT_s c_1583_n) resistor r=10.2363
    rnet72_38 (net72_5 c_1572_n) resistor r=12.3172
    rnet72_37 (net72_7 c_1576_n) resistor r=14.4784
    rnet72_36 (net72_7 net72) resistor r=10.5593
    rnet72_35 (net72_8 c_1576_n) resistor r=14.4784
    rnet72_34 (net72_10 c_1579_n) resistor r=4.04518
    rnet72_33 (net72_10 c_1583_n) resistor r=0.549089
    rnet72_32 (net72_11 c_1579_n) resistor r=4.04518
    rnet72_31 (net72_11 net72) resistor r=0.730683
    rnet72_30 (MM9_ELT_d c_1579_n) resistor r=4.04518
    rnet72_29 (MM9_ELT_d c_1580_n) resistor r=11.6604
    rnet72_28 (MM9_ELT_d c_1580_n) resistor r=1.30988
    rnet72_27 (MM9_ELT_d c_1588_n) resistor r=2.55965
    rnet72_26 (MM9_ELT_d net72_19) resistor r=17.3029
    rnet72_25 (net72_14 c_1580_n) resistor r=11.6604
    rnet72_24 (net72_14 c_1583_n) resistor r=10.2363
    rnet72_23 (net72_16 c_1588_n) resistor r=14.4784
    rnet72_22 (net72_16 net72_19) resistor r=9.04062
    rnet72_21 (net72_17 c_1588_n) resistor r=14.4784
    rnet72_20 (net72_17 net72) resistor r=10.5593
    rQ_248 (c_1445_n c_1447_n) resistor r=58.3583
    rQ_247 (c_1445_n c_1447_n) resistor r=4.16253
    rQ_246 (c_1445_n c_1447_n) resistor r=58.3583
    rQ_245 (c_1445_n c_1447_n) resistor r=4.16253
    rQ_244 (c_1446_n c_1447_n) resistor r=58.3583
    rQ_243 (c_1446_n c_1447_n) resistor r=4.16253
    rQ_242 (c_1446_n c_1447_n) resistor r=58.3583
    rQ_241 (c_1446_n c_1447_n) resistor r=4.16253
    rQ_240 (c_1447_n Q_33) resistor r=22.35
    rQ_239 (c_1447_n c_1455_n) resistor r=22.35
    rQ_238 (c_1447_n Q_41) resistor r=24.8333
    rQ_237 (c_1447_n c_1547_n) resistor r=24.8333
    rQ_236 (c_1447_n Q_54) resistor r=11.175
    rQ_235 (c_1447_n Q_76) resistor r=58.3583
    rQ_234 (c_1447_n c_1511_n) resistor r=58.3583
    rQ_233 (c_1447_n Q_33) resistor r=4.16253
    rQ_232 (c_1447_n Q_41) resistor r=4.16253
    rQ_231 (c_1447_n Q_76) resistor r=5.53947
    rQ_230 (c_1447_n Q_54) resistor r=5.53947
    rQ_229 (c_1447_n c_1455_n) resistor r=2.32428
    rQ_228 (c_1447_n c_1547_n) resistor r=4.16253
    rQ_227 (c_1447_n c_1511_n) resistor r=4.16253
    rQ_226 (c_1447_n Q_33) resistor r=22.35
    rQ_225 (c_1447_n c_1455_n) resistor r=22.35
    rQ_224 (c_1447_n Q_41) resistor r=24.8333
    rQ_223 (c_1447_n c_1547_n) resistor r=24.8333
    rQ_222 (c_1447_n Q_199) resistor r=35.3875
    rQ_221 (c_1447_n Q_54) resistor r=11.175
    rQ_220 (c_1447_n Q_76) resistor r=58.3583
    rQ_219 (c_1447_n MM9_ELT_g) resistor r=7.45
    rQ_218 (c_1447_n Q_33) resistor r=4.16253
    rQ_217 (c_1447_n Q_41) resistor r=4.16253
    rQ_216 (c_1447_n Q_76) resistor r=5.53947
    rQ_215 (c_1447_n Q_54) resistor r=5.53947
    rQ_214 (c_1447_n c_1455_n) resistor r=2.32428
    rQ_213 (c_1447_n c_1547_n) resistor r=4.16253
    rQ_212 (c_1447_n c_1511_n) resistor r=4.16253
    rQ_211 (c_1442_n c_1444_n) resistor r=58.3583
    rQ_210 (c_1442_n c_1444_n) resistor r=4.16253
    rQ_209 (c_1442_n c_1444_n) resistor r=58.3583
    rQ_208 (c_1442_n c_1444_n) resistor r=4.16253
    rQ_207 (c_1443_n c_1444_n) resistor r=58.3583
    rQ_206 (c_1443_n c_1444_n) resistor r=4.16253
    rQ_205 (c_1443_n c_1444_n) resistor r=58.3583
    rQ_204 (c_1443_n c_1444_n) resistor r=4.16253
    rQ_203 (c_1444_n Q_63) resistor r=24.8333
    rQ_202 (c_1444_n c_1509_n) resistor r=24.8333
    rQ_201 (c_1444_n Q_71) resistor r=22.35
    rQ_200 (c_1444_n c_1527_n) resistor r=22.35
    rQ_199 (c_1444_n Q_84) resistor r=11.175
    rQ_198 (c_1444_n c_1460_n) resistor r=58.3583
    rQ_197 (c_1444_n Q_93) resistor r=58.3583
    rQ_196 (c_1444_n Q_63) resistor r=4.16253
    rQ_195 (c_1444_n Q_71) resistor r=4.16253
    rQ_194 (c_1444_n Q_84) resistor r=5.53947
    rQ_193 (c_1444_n Q_93) resistor r=5.53947
    rQ_192 (c_1444_n c_1527_n) resistor r=2.32428
    rQ_191 (c_1444_n c_1509_n) resistor r=4.16253
    rQ_190 (c_1444_n c_1460_n) resistor r=4.16253
    rQ_189 (c_1444_n Q_63) resistor r=24.8333
    rQ_188 (c_1444_n c_1509_n) resistor r=24.8333
    rQ_187 (c_1444_n Q_71) resistor r=22.35
    rQ_186 (c_1444_n c_1527_n) resistor r=22.35
    rQ_185 (c_1444_n Q_84) resistor r=11.175
    rQ_184 (c_1444_n Q_214) resistor r=30.7313
    rQ_183 (c_1444_n c_1460_n) resistor r=58.3583
    rQ_182 (c_1444_n MM12_ELT_g) resistor r=22.35
    rQ_181 (c_1444_n Q_63) resistor r=4.16253
    rQ_180 (c_1444_n Q_71) resistor r=4.16253
    rQ_179 (c_1444_n Q_84) resistor r=5.53947
    rQ_178 (c_1444_n Q_93) resistor r=5.53947
    rQ_177 (c_1444_n c_1527_n) resistor r=2.32428
    rQ_176 (c_1444_n c_1509_n) resistor r=4.16253
    rQ_175 (c_1444_n c_1460_n) resistor r=4.16253
    rQ_174 (c_1511_n MM9_ELT_g) resistor r=50.9083
    rQ_173 (Q_93 MM12_ELT_g) resistor r=36.0083
    rQ_172 (c_1461_n Q_133) resistor r=0.796529
    rQ_171 (c_1461_n c_1466_n) resistor r=0.0970525
    rQ_170 (Q_133 Q_134) resistor r=10
    rQ_169 (Q_134 Q_231) resistor r=0.677273
    rQ_168 (Q_136 c_1466_n) resistor r=1.25607
    rQ_167 (Q_136 c_1472_n) resistor r=0.0960675
    rQ_166 (c_1468_n c_1472_n) resistor r=0.439787
    rQ_165 (c_1468_n Q_164) resistor r=0.046635
    rQ_164 (Q_140 c_1474_n) resistor r=0.303691
    rQ_163 (Q_140 Q_160) resistor r=0.0100978
    rQ_162 (c_1474_n c_1476_n) resistor r=13
    rQ_161 (c_1476_n MM7_ELT_d) resistor r=8.44
    rQ_160 (Q_145 c_1480_n) resistor r=0.442217
    rQ_159 (Q_145 Q_164) resistor r=0.0100978
    rQ_158 (c_1480_n c_1482_n) resistor r=8.66667
    rQ_157 (c_1480_n Q_150) resistor r=0.63935
    rQ_156 (c_1482_n MM6_ELT_d) resistor r=32.3614
    rQ_155 (Q_150 Q_151) resistor r=8.66667
    rQ_154 (Q_150 Q_153) resistor r=0.426233
    rQ_153 (Q_151 MM6_ELT_d) resistor r=16.1807
    rQ_152 (Q_151 Q_154) resistor r=32.3614
    rQ_151 (Q_153 Q_154) resistor r=26
    rQ_150 (Q_156 Q) resistor r=0.156112
    rQ_149 (Q_156 c_1491_n) resistor r=0.0100978
    rQ_148 (Q_157 Q) resistor r=0.497738
    rQ_147 (Q_157 c_1497_n) resistor r=0.0100978
    rQ_146 (Q_160 c_1491_n) resistor r=0.151071
    rQ_145 (Q_164 c_1497_n) resistor r=0.15545
    rQ_144 (Q_199 Q_231) resistor r=3.1797
    rQ_143 (Q_214 c_1448_n) resistor r=3.1797
    rQ_142 (Q_231 c_1448_n) resistor r=25.7364
    rVDD_295 (MM28_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_294 (MM15_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_293 (MM14_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_292 (MM10_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_291 (MM9_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_290 (MM8_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_289 (MM6_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_288 (MM1_ELT_b VDD_39) resistor r=8.66667
    rVDD_287 (MM1_ELT_b VDD_49) resistor r=8.66667
    rVDD_286 (MM1_ELT_b VDD_64) resistor r=8.66667
    rVDD_285 (MM1_ELT_b c_1374_n) resistor r=13
    rVDD_284 (MM1_ELT_b VDD_37) resistor r=22.5067
    rVDD_283 (c_1300_n VDD_7) resistor r=0.11463
    rVDD_282 (c_1300_n VDD_70) resistor r=0.0221538
    rVDD_281 (VDD VDD_7) resistor r=0.102772
    rVDD_280 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_279 (VDD_8 VDD_24) resistor r=67.52
    rVDD_278 (VDD_9 VDD_18) resistor r=0.538153
    rVDD_277 (VDD_9 VDD_70) resistor r=0.0882115
    rVDD_276 (c_1301_n c_1302_n) resistor r=8.66667
    rVDD_275 (c_1301_n VDD_15) resistor r=0.711069
    rVDD_274 (VDD_15 c_1302_n) resistor r=8.66667
    rVDD_273 (VDD_15 VDD_18) resistor r=0.467959
    rVDD_272 (VDD_18 c_1302_n) resistor r=13
    rVDD_271 (c_1302_n MM28_ELT_s) resistor r=4.04518
    rVDD_270 (c_1302_n VDD_121) resistor r=4.04518
    rVDD_269 (c_1302_n MM1_ELT_s) resistor r=4.04518
    rVDD_268 (c_1302_n VDD_119) resistor r=4.04518
    rVDD_267 (c_1309_n VDD_23) resistor r=0.167992
    rVDD_266 (c_1309_n VDD_71) resistor r=0.0221538
    rVDD_265 (VDD_21 VDD_23) resistor r=0.0869607
    rVDD_264 (VDD_21 VDD_70) resistor r=0.0221538
    rVDD_263 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_262 (VDD_24 VDD_34) resistor r=67.52
    rVDD_261 (VDD_25 c_1312_n) resistor r=0.51148
    rVDD_260 (VDD_25 VDD_71) resistor r=0.0882115
    rVDD_259 (c_1312_n c_1316_n) resistor r=8.66667
    rVDD_258 (c_1316_n VDD_124) resistor r=16.4995
    rVDD_257 (c_1316_n VDD_123) resistor r=16.4995
    rVDD_256 (c_1316_n MM14_ELT_s) resistor r=3.29107
    rVDD_255 (c_1342_n VDD_39) resistor r=0.0335985
    rVDD_254 (c_1342_n VDD_72) resistor r=0.0221538
    rVDD_253 (VDD_31 VDD_33) resistor r=0.0335985
    rVDD_252 (VDD_31 VDD_71) resistor r=0.0221538
    rVDD_251 (VDD_33 VDD_34) resistor r=8.66667
    rVDD_250 (VDD_33 VDD_36) resistor r=0.237166
    rVDD_249 (VDD_34 VDD_37) resistor r=67.52
    rVDD_248 (VDD_36 VDD_37) resistor r=8.66667
    rVDD_247 (VDD_36 VDD_39) resistor r=0.237166
    rVDD_246 (VDD_41 c_1345_n) resistor r=0.565904
    rVDD_245 (VDD_41 VDD_72) resistor r=0.0882115
    rVDD_244 (c_1345_n c_1362_n) resistor r=13
    rVDD_243 (c_1362_n MM9_ELT_s) resistor r=8.09035
    rVDD_242 (c_1365_n VDD_49) resistor r=0.167992
    rVDD_241 (c_1365_n VDD_73) resistor r=0.0221538
    rVDD_240 (VDD_47 VDD_49) resistor r=0.167992
    rVDD_239 (VDD_47 VDD_72) resistor r=0.0221538
    rVDD_238 (VDD_51 VDD_60) resistor r=0.538153
    rVDD_237 (VDD_51 VDD_73) resistor r=0.0882115
    rVDD_236 (c_1368_n VDD_54) resistor r=8.66667
    rVDD_235 (c_1368_n VDD_57) resistor r=0.850553
    rVDD_234 (VDD_54 MM6_ELT_s) resistor r=2.31356
    rVDD_233 (VDD_54 c_1421_p) resistor r=15.7867
    rVDD_232 (VDD_57 VDD_58) resistor r=8.66667
    rVDD_231 (VDD_57 VDD_60) resistor r=0.467959
    rVDD_230 (VDD_58 MM6_ELT_s) resistor r=3.65427
    rVDD_229 (VDD_58 VDD_144) resistor r=3.65427
    rVDD_228 (VDD_58 VDD_108) resistor r=4.45033
    rVDD_227 (VDD_58 c_1421_p) resistor r=4.45033
    rVDD_226 (VDD_60 c_1371_n) resistor r=13
    rVDD_225 (c_1371_n MM6_ELT_s) resistor r=4.04518
    rVDD_224 (c_1371_n VDD_125) resistor r=4.04518
    rVDD_223 (c_1371_n MM8_ELT_s) resistor r=4.04518
    rVDD_222 (c_1371_n VDD_144) resistor r=4.04518
    rVDD_221 (VDD_62 VDD_64) resistor r=0.0335985
    rVDD_220 (VDD_62 VDD_73) resistor r=0.0221538
    rVDD_219 (VDD_64 c_1374_n) resistor r=0.15811
    rVDD_218 (MM1_ELT_s VDD_77) resistor r=25.7298
    rVDD_217 (MM1_ELT_s c_1348_n) resistor r=2.55965
    rVDD_216 (MM1_ELT_s c_1349_n) resistor r=12.3172
    rVDD_215 (MM1_ELT_s c_1349_n) resistor r=1.62887
    rVDD_214 (VDD_77 VDD_79) resistor r=9.04062
    rVDD_213 (VDD_78 c_1348_n) resistor r=14.4784
    rVDD_212 (VDD_78 VDD_122) resistor r=10.5593
    rVDD_211 (VDD_79 c_1348_n) resistor r=14.4784
    rVDD_210 (VDD_81 c_1349_n) resistor r=12.3172
    rVDD_209 (VDD_81 c_1354_n) resistor r=10.2363
    rVDD_208 (MM28_ELT_s c_1320_n) resistor r=2.55965
    rVDD_207 (MM28_ELT_s c_1321_n) resistor r=12.3172
    rVDD_206 (MM28_ELT_s c_1321_n) resistor r=1.62887
    rVDD_205 (MM28_ELT_s c_1323_n) resistor r=6.12113
    rVDD_204 (MM28_ELT_s c_1354_n) resistor r=10.2363
    rVDD_203 (VDD_84 c_1320_n) resistor r=14.4784
    rVDD_202 (VDD_84 VDD_90) resistor r=9.04062
    rVDD_201 (VDD_85 c_1320_n) resistor r=14.4784
    rVDD_200 (VDD_85 VDD_122) resistor r=10.5593
    rVDD_199 (c_1350_n c_1321_n) resistor r=12.3172
    rVDD_198 (c_1350_n VDD_89) resistor r=9.04595
    rVDD_197 (VDD_89 c_1323_n) resistor r=31.2341
    rVDD_196 (VDD_90 c_1323_n) resistor r=31.2341
    rVDD_195 (MM14_ELT_s c_1395_n) resistor r=12.3172
    rVDD_194 (MM14_ELT_s c_1395_n) resistor r=1.62887
    rVDD_193 (MM14_ELT_s c_1398_n) resistor r=2.55965
    rVDD_192 (MM14_ELT_s VDD_98) resistor r=17.3029
    rVDD_191 (VDD_93 c_1395_n) resistor r=12.3172
    rVDD_190 (VDD_93 VDD_123) resistor r=9.39461
    rVDD_189 (VDD_95 c_1398_n) resistor r=14.4784
    rVDD_188 (VDD_95 VDD_98) resistor r=9.04062
    rVDD_187 (VDD_96 c_1398_n) resistor r=14.4784
    rVDD_186 (VDD_96 VDD_124) resistor r=9.48555
    rVDD_185 (VDD_99 c_1377_n) resistor r=20.2547
    rVDD_184 (VDD_99 c_1378_n) resistor r=9.04595
    rVDD_183 (VDD_100 c_1377_n) resistor r=20.2547
    rVDD_182 (VDD_100 VDD_106) resistor r=9.04062
    rVDD_181 (MM8_ELT_s c_1377_n) resistor r=4.36821
    rVDD_180 (MM8_ELT_s c_1379_n) resistor r=7.31976
    rVDD_179 (MM8_ELT_s c_1379_n) resistor r=1.40052
    rVDD_178 (MM8_ELT_s c_1382_n) resistor r=2.55965
    rVDD_177 (MM8_ELT_s c_1383_n) resistor r=7.31976
    rVDD_176 (MM8_ELT_s c_1383_n) resistor r=1.40052
    rVDD_175 (c_1378_n c_1379_n) resistor r=7.31976
    rVDD_174 (VDD_105 c_1382_n) resistor r=14.4784
    rVDD_173 (VDD_105 VDD_126) resistor r=10.5593
    rVDD_172 (VDD_106 c_1382_n) resistor r=14.4784
    rVDD_171 (VDD_108 c_1383_n) resistor r=7.31976
    rVDD_170 (MM6_ELT_s c_1428_p) resistor r=2.55965
    rVDD_169 (MM6_ELT_s c_1420_p) resistor r=11.6604
    rVDD_168 (MM6_ELT_s c_1420_p) resistor r=1.30988
    rVDD_167 (MM6_ELT_s c_1430_p) resistor r=6.12113
    rVDD_166 (VDD_111 c_1428_p) resistor r=14.4784
    rVDD_165 (VDD_111 VDD_117) resistor r=9.04062
    rVDD_164 (VDD_112 c_1428_p) resistor r=14.4784
    rVDD_163 (VDD_112 VDD_126) resistor r=10.5593
    rVDD_162 (c_1432_p c_1420_p) resistor r=11.6604
    rVDD_161 (c_1432_p VDD_116) resistor r=9.04595
    rVDD_160 (VDD_116 c_1430_p) resistor r=31.2341
    rVDD_159 (VDD_117 c_1430_p) resistor r=31.2341
    rVDD_158 (VDD_119 c_1354_n) resistor r=0.549089
    rVDD_157 (VDD_121 VDD_122) resistor r=0.730683
    rVDD_156 (VDD_125 VDD_126) resistor r=0.730683
    rVSS_227 (MM29_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_226 (MM16_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_225 (MM17_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_224 (MM11_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_223 (MM18_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_222 (MM12_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_221 (MM13_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_220 (MM7_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_219 (MM0_ELT_b VSS_26) resistor r=8.66667
    rVSS_218 (MM0_ELT_b VSS_36) resistor r=8.66667
    rVSS_217 (MM0_ELT_b VSS_48) resistor r=8.66667
    rVSS_216 (MM0_ELT_b c_1245_n) resistor r=13
    rVSS_215 (MM0_ELT_b VSS_24) resistor r=21.5743
    rVSS_214 (c_1201_n VSS_7) resistor r=0.11463
    rVSS_213 (c_1201_n VSS_54) resistor r=0.0221538
    rVSS_212 (VSS VSS_7) resistor r=0.100795
    rVSS_211 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_210 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_209 (VSS_9 c_1203_n) resistor r=0.444418
    rVSS_208 (VSS_9 VSS_54) resistor r=0.0882115
    rVSS_207 (c_1203_n c_1204_n) resistor r=8.66667
    rVSS_206 (c_1204_n MM29_ELT_s) resistor r=4.22001
    rVSS_205 (c_1204_n VSS_102) resistor r=4.22001
    rVSS_204 (c_1204_n MM0_ELT_s) resistor r=4.22001
    rVSS_203 (c_1204_n VSS_100) resistor r=4.22001
    rVSS_202 (c_1210_n VSS_26) resistor r=0.11463
    rVSS_201 (c_1210_n VSS_55) resistor r=0.0221538
    rVSS_200 (VSS_15 VSS_17) resistor r=0.0870861
    rVSS_199 (VSS_15 VSS_54) resistor r=0.0221538
    rVSS_198 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_197 (VSS_17 VSS_20) resistor r=0.237507
    rVSS_196 (VSS_18 VSS_21) resistor r=64.7228
    rVSS_195 (VSS_20 VSS_21) resistor r=8.66667
    rVSS_194 (VSS_20 VSS_23) resistor r=0.237507
    rVSS_193 (VSS_21 VSS_24) resistor r=64.7228
    rVSS_192 (VSS_23 VSS_24) resistor r=8.66667
    rVSS_191 (VSS_23 VSS_26) resistor r=0.237166
    rVSS_190 (VSS_28 c_1214_n) resistor r=0.438712
    rVSS_189 (VSS_28 VSS_55) resistor r=0.0882115
    rVSS_188 (c_1214_n c_1258_n) resistor r=8.66667
    rVSS_187 (c_1258_n MM13_ELT_s) resistor r=2.27123
    rVSS_186 (c_1258_n MM18_ELT_s) resistor r=2.27123
    rVSS_185 (c_1258_n VSS_104) resistor r=8.4738
    rVSS_184 (c_1241_n VSS_36) resistor r=0.167992
    rVSS_183 (c_1241_n VSS_56) resistor r=0.0221538
    rVSS_182 (VSS_34 VSS_36) resistor r=0.0869607
    rVSS_181 (VSS_34 VSS_55) resistor r=0.0221538
    rVSS_180 (VSS_38 c_1242_n) resistor r=0.399593
    rVSS_179 (VSS_38 VSS_56) resistor r=0.0882115
    rVSS_178 (c_1242_n VSS_44) resistor r=8.66667
    rVSS_177 (c_1242_n VSS_43) resistor r=0.426233
    rVSS_176 (VSS_43 VSS_44) resistor r=26
    rVSS_175 (VSS_44 MM7_ELT_s) resistor r=2.90692
    rVSS_174 (VSS_44 c_1248_n) resistor r=12.1406
    rVSS_173 (VSS_46 VSS_48) resistor r=0.0335985
    rVSS_172 (VSS_46 VSS_56) resistor r=0.0221538
    rVSS_171 (VSS_48 c_1245_n) resistor r=0.15811
    rVSS_170 (MM0_ELT_s VSS_58) resistor r=18.0507
    rVSS_169 (MM0_ELT_s VSS_61) resistor r=2.67027
    rVSS_168 (MM0_ELT_s c_1237_n) resistor r=12.8495
    rVSS_167 (MM0_ELT_s c_1237_n) resistor r=1.69926
    rVSS_166 (VSS_58 VSS_60) resistor r=9.43134
    rVSS_165 (VSS_59 VSS_61) resistor r=15.1041
    rVSS_164 (VSS_59 VSS_101) resistor r=11.0157
    rVSS_163 (VSS_60 VSS_61) resistor r=15.1041
    rVSS_162 (VSS_62 c_1237_n) resistor r=12.8495
    rVSS_161 (VSS_62 c_1239_n) resistor r=10.6787
    rVSS_160 (MM29_ELT_s c_1216_n) resistor r=2.67027
    rVSS_159 (MM29_ELT_s c_1218_n) resistor r=12.8495
    rVSS_158 (MM29_ELT_s c_1218_n) resistor r=1.69926
    rVSS_157 (MM29_ELT_s c_1219_n) resistor r=4.557
    rVSS_156 (MM29_ELT_s c_1239_n) resistor r=10.6787
    rVSS_155 (c_1215_n c_1216_n) resistor r=15.1041
    rVSS_154 (c_1215_n VSS_70) resistor r=9.43134
    rVSS_153 (VSS_66 c_1216_n) resistor r=15.1041
    rVSS_152 (VSS_66 VSS_101) resistor r=11.0157
    rVSS_151 (VSS_68 c_1218_n) resistor r=12.8495
    rVSS_150 (VSS_68 VSS_71) resistor r=9.4369
    rVSS_149 (VSS_70 c_1219_n) resistor r=21.1301
    rVSS_148 (VSS_71 c_1219_n) resistor r=21.1301
    rVSS_147 (VSS_73 c_1274_n) resistor r=21.1301
    rVSS_146 (VSS_73 VSS_78) resistor r=9.43134
    rVSS_145 (VSS_74 c_1274_n) resistor r=21.1301
    rVSS_144 (VSS_74 VSS_80) resistor r=9.4369
    rVSS_143 (MM18_ELT_s c_1274_n) resistor r=4.557
    rVSS_142 (MM18_ELT_s VSS_79) resistor r=2.67027
    rVSS_141 (MM18_ELT_s VSS_81) resistor r=12.8495
    rVSS_140 (MM18_ELT_s VSS_81) resistor r=1.69926
    rVSS_139 (VSS_77 VSS_79) resistor r=15.1041
    rVSS_138 (VSS_77 VSS_105) resistor r=11.0157
    rVSS_137 (VSS_78 VSS_79) resistor r=15.1041
    rVSS_136 (VSS_80 VSS_81) resistor r=12.8495
    rVSS_135 (MM13_ELT_s VSS_85) resistor r=2.67027
    rVSS_134 (MM13_ELT_s c_1286_n) resistor r=12.8495
    rVSS_133 (MM13_ELT_s c_1286_n) resistor r=1.69926
    rVSS_132 (MM13_ELT_s VSS_90) resistor r=4.557
    rVSS_131 (VSS_83 VSS_85) resistor r=15.1041
    rVSS_130 (VSS_83 VSS_88) resistor r=9.43134
    rVSS_129 (VSS_84 VSS_85) resistor r=15.1041
    rVSS_128 (VSS_84 VSS_105) resistor r=11.0157
    rVSS_127 (VSS_86 c_1286_n) resistor r=12.8495
    rVSS_126 (VSS_86 VSS_89) resistor r=9.4369
    rVSS_125 (VSS_88 VSS_90) resistor r=21.1301
    rVSS_124 (VSS_89 VSS_90) resistor r=21.1301
    rVSS_123 (MM7_ELT_s VSS_94) resistor r=2.67027
    rVSS_122 (MM7_ELT_s c_1296_p) resistor r=12.1643
    rVSS_121 (MM7_ELT_s c_1296_p) resistor r=1.36649
    rVSS_120 (MM7_ELT_s c_1297_p) resistor r=4.557
    rVSS_119 (VSS_92 VSS_94) resistor r=15.1041
    rVSS_118 (VSS_92 VSS_97) resistor r=9.43134
    rVSS_117 (VSS_93 VSS_94) resistor r=15.1041
    rVSS_116 (VSS_93 c_1248_n) resistor r=9.89549
    rVSS_115 (c_1295_p c_1296_p) resistor r=12.1643
    rVSS_114 (c_1295_p VSS_98) resistor r=9.4369
    rVSS_113 (VSS_97 c_1297_p) resistor r=21.1301
    rVSS_112 (VSS_98 c_1297_p) resistor r=21.1301
    rVSS_111 (VSS_100 VSS_101) resistor r=0.762262
    rVSS_110 (VSS_102 c_1239_n) resistor r=0.57282
    rVSS_109 (VSS_104 VSS_105) resistor r=0.762262
    rnet25_87 (MM13_ELT_d net25) resistor r=0.01
    rnet25_86 (net25_1 c_1132_n) resistor r=0.170747
    rnet25_85 (net25_1 c_1133_n) resistor r=0.0960675
    rnet25_84 (c_1132_n c_1142_n) resistor r=13
    rnet25_83 (c_1142_n MM12_ELT_s) resistor r=8.44
    rnet25_82 (c_1145_n c_1133_n) resistor r=0.127187
    rnet25_81 (c_1145_n c_1135_n) resistor r=0.0960675
    rnet25_80 (net25_8 c_1135_n) resistor r=0.705134
    rnet25_79 (net25_8 net25_15) resistor r=0.0100978
    rnet25_78 (net25_10 c_1161_n) resistor r=0.399593
    rnet25_77 (net25_10 c_1136_n) resistor r=0.0100978
    rnet25_76 (c_1161_n c_1165_n) resistor r=13
    rnet25_75 (c_1165_n net25) resistor r=8.44
    rnet25_74 (net25_15 c_1136_n) resistor r=0.0780558
    rnet20_53 (MM18_ELT_d net20) resistor r=0.01
    rnet20_52 (net20_1 c_1094_n) resistor r=0.0593255
    rnet20_51 (net20_1 c_1100_n) resistor r=0.072807
    rnet20_50 (c_1094_n c_1095_n) resistor r=13
    rnet20_49 (c_1095_n MM17_ELT_s) resistor r=8.44
    rnet20_48 (c_1097_n net20_9) resistor r=0.59211
    rnet20_47 (c_1097_n c_1117_n) resistor r=0.0189213
    rnet20_46 (net20_9 c_1100_n) resistor r=0.0189213
    rnet20_45 (net20_10 c_1111_n) resistor r=0.058607
    rnet20_44 (net20_10 c_1117_n) resistor r=0.072807
    rnet20_43 (c_1111_n c_1113_n) resistor r=13
    rnet20_42 (c_1113_n net20) resistor r=8.44
    rCDN_248 (c_1021_n c_993_n) resistor r=58.3583
    rCDN_247 (c_1021_n c_993_n) resistor r=4.16253
    rCDN_246 (c_1021_n c_993_n) resistor r=58.3583
    rCDN_245 (c_1021_n c_993_n) resistor r=4.16253
    rCDN_244 (c_991_n c_993_n) resistor r=58.3583
    rCDN_243 (c_991_n c_993_n) resistor r=4.16253
    rCDN_242 (c_991_n c_993_n) resistor r=58.3583
    rCDN_241 (c_991_n c_993_n) resistor r=4.16253
    rCDN_240 (c_993_n CDN_45) resistor r=24.8333
    rCDN_239 (c_993_n c_1028_p) resistor r=24.8333
    rCDN_238 (c_993_n CDN_53) resistor r=24.8333
    rCDN_237 (c_993_n c_1031_p) resistor r=24.8333
    rCDN_236 (c_993_n c_1059_p) resistor r=58.3583
    rCDN_235 (c_993_n CDN_61) resistor r=58.3583
    rCDN_234 (c_993_n CDN_66) resistor r=14.9
    rCDN_233 (c_993_n CDN_45) resistor r=4.16253
    rCDN_232 (c_993_n CDN_53) resistor r=4.16253
    rCDN_231 (c_993_n c_1028_p) resistor r=4.16253
    rCDN_230 (c_993_n c_1059_p) resistor r=4.16253
    rCDN_229 (c_993_n CDN_66) resistor r=6.30933
    rCDN_228 (c_993_n CDN_61) resistor r=6.30933
    rCDN_227 (c_993_n c_1031_p) resistor r=1.63969
    rCDN_226 (c_993_n CDN_45) resistor r=24.8333
    rCDN_225 (c_993_n c_1028_p) resistor r=24.8333
    rCDN_224 (c_993_n CDN_53) resistor r=24.8333
    rCDN_223 (c_993_n c_1031_p) resistor r=24.8333
    rCDN_222 (c_993_n c_1059_p) resistor r=58.3583
    rCDN_221 (c_993_n MM18_ELT_g) resistor r=22.35
    rCDN_220 (c_993_n CDN_66) resistor r=14.9
    rCDN_219 (c_993_n CDN_263) resistor r=39.7333
    rCDN_218 (c_993_n CDN_45) resistor r=4.16253
    rCDN_217 (c_993_n CDN_53) resistor r=4.16253
    rCDN_216 (c_993_n c_1028_p) resistor r=4.16253
    rCDN_215 (c_993_n c_1059_p) resistor r=4.16253
    rCDN_214 (c_993_n CDN_66) resistor r=6.30933
    rCDN_213 (c_993_n CDN_61) resistor r=6.30933
    rCDN_212 (c_993_n c_1031_p) resistor r=1.63969
    rCDN_211 (CDN_61 MM18_ELT_g) resistor r=36.0083
    rCDN_210 (c_1060_p c_1000_n) resistor r=58.3583
    rCDN_209 (c_1060_p c_1000_n) resistor r=4.16253
    rCDN_208 (c_1060_p c_1000_n) resistor r=58.3583
    rCDN_207 (c_1060_p c_1000_n) resistor r=4.16253
    rCDN_206 (CDN_75 c_1000_n) resistor r=58.3583
    rCDN_205 (CDN_75 c_1000_n) resistor r=6.30933
    rCDN_204 (CDN_75 c_1000_n) resistor r=58.3583
    rCDN_203 (CDN_75 c_1000_n) resistor r=6.30933
    rCDN_202 (c_1000_n CDN_80) resistor r=14.9
    rCDN_201 (c_1000_n CDN_89) resistor r=24.8333
    rCDN_200 (c_1000_n c_1048_p) resistor r=24.8333
    rCDN_199 (c_1000_n CDN_97) resistor r=24.8333
    rCDN_198 (c_1000_n c_1001_n) resistor r=24.8333
    rCDN_197 (c_1000_n c_1069_p) resistor r=58.3583
    rCDN_196 (c_1000_n c_1009_n) resistor r=58.3583
    rCDN_195 (c_1000_n CDN_89) resistor r=4.16253
    rCDN_194 (c_1000_n CDN_80) resistor r=6.30933
    rCDN_193 (c_1000_n CDN_97) resistor r=1.63969
    rCDN_192 (c_1000_n c_1048_p) resistor r=4.16253
    rCDN_191 (c_1000_n c_1069_p) resistor r=4.16253
    rCDN_190 (c_1000_n c_1001_n) resistor r=4.16253
    rCDN_189 (c_1000_n c_1009_n) resistor r=4.16253
    rCDN_188 (c_1000_n CDN_80) resistor r=14.9
    rCDN_187 (c_1000_n CDN_271) resistor r=39.7333
    rCDN_186 (c_1000_n CDN_89) resistor r=24.8333
    rCDN_185 (c_1000_n c_1048_p) resistor r=24.8333
    rCDN_184 (c_1000_n CDN_97) resistor r=24.8333
    rCDN_183 (c_1000_n c_1001_n) resistor r=24.8333
    rCDN_182 (c_1000_n c_1069_p) resistor r=58.3583
    rCDN_181 (c_1000_n MM13_ELT_g) resistor r=7.45
    rCDN_180 (c_1000_n CDN_89) resistor r=4.16253
    rCDN_179 (c_1000_n CDN_80) resistor r=6.30933
    rCDN_178 (c_1000_n CDN_97) resistor r=1.63969
    rCDN_177 (c_1000_n c_1048_p) resistor r=4.16253
    rCDN_176 (c_1000_n c_1069_p) resistor r=4.16253
    rCDN_175 (c_1000_n c_1001_n) resistor r=4.16253
    rCDN_174 (c_1000_n c_1009_n) resistor r=4.16253
    rCDN_173 (c_1002_n c_1003_n) resistor r=58.3583
    rCDN_172 (c_1002_n c_1003_n) resistor r=4.16253
    rCDN_171 (c_1002_n c_1003_n) resistor r=58.3583
    rCDN_170 (c_1002_n c_1003_n) resistor r=4.16253
    rCDN_169 (c_1071_p c_1003_n) resistor r=58.3583
    rCDN_168 (c_1071_p c_1003_n) resistor r=4.16253
    rCDN_167 (c_1071_p c_1003_n) resistor r=58.3583
    rCDN_166 (c_1071_p c_1003_n) resistor r=4.16253
    rCDN_165 (c_1003_n CDN_121) resistor r=8.69167
    rCDN_164 (c_1003_n c_1010_n) resistor r=8.69167
    rCDN_163 (c_1003_n CDN_129) resistor r=24.8333
    rCDN_162 (c_1003_n c_1012_n) resistor r=24.8333
    rCDN_161 (c_1003_n CDN_134) resistor r=14.9
    rCDN_160 (c_1003_n CDN_143) resistor r=8.69167
    rCDN_159 (c_1003_n c_1014_n) resistor r=8.69167
    rCDN_158 (c_1003_n c_1075_p) resistor r=58.3583
    rCDN_157 (c_1003_n c_1016_n) resistor r=58.3583
    rCDN_156 (c_1003_n CDN_121) resistor r=4.16253
    rCDN_155 (c_1003_n CDN_129) resistor r=4.16253
    rCDN_154 (c_1003_n CDN_143) resistor r=6.30933
    rCDN_153 (c_1003_n c_1010_n) resistor r=6.30933
    rCDN_152 (c_1003_n CDN_134) resistor r=1.63969
    rCDN_151 (c_1003_n c_1014_n) resistor r=4.16253
    rCDN_150 (c_1003_n c_1075_p) resistor r=4.16253
    rCDN_149 (c_1003_n c_1012_n) resistor r=4.16253
    rCDN_148 (c_1003_n c_1016_n) resistor r=4.16253
    rCDN_147 (c_1003_n CDN_121) resistor r=8.69167
    rCDN_146 (c_1003_n c_1010_n) resistor r=8.69167
    rCDN_145 (c_1003_n CDN_129) resistor r=24.8333
    rCDN_144 (c_1003_n c_1012_n) resistor r=24.8333
    rCDN_143 (c_1003_n CDN_295) resistor r=330.283
    rCDN_142 (c_1003_n CDN_134) resistor r=14.9
    rCDN_141 (c_1003_n CDN_143) resistor r=8.69167
    rCDN_140 (c_1003_n c_1014_n) resistor r=8.69167
    rCDN_139 (c_1003_n c_1075_p) resistor r=58.3583
    rCDN_138 (c_1003_n MM8_ELT_g) resistor r=7.45
    rCDN_137 (c_1003_n CDN_121) resistor r=4.16253
    rCDN_136 (c_1003_n CDN_129) resistor r=4.16253
    rCDN_135 (c_1003_n CDN_143) resistor r=6.30933
    rCDN_134 (c_1003_n c_1010_n) resistor r=6.30933
    rCDN_133 (c_1003_n CDN_134) resistor r=1.63969
    rCDN_132 (c_1003_n c_1014_n) resistor r=4.16253
    rCDN_131 (c_1003_n c_1075_p) resistor r=4.16253
    rCDN_130 (c_1003_n c_1012_n) resistor r=4.16253
    rCDN_129 (c_1003_n c_1016_n) resistor r=4.16253
    rCDN_128 (c_1009_n MM13_ELT_g) resistor r=50.9083
    rCDN_127 (c_1016_n MM8_ELT_g) resistor r=50.9083
    rCDN_126 (CDN CDN_214) resistor r=10
    rCDN_125 (CDN_214 c_998_n) resistor r=11.5136
    rCDN_124 (CDN_263 c_1083_p) resistor r=4.38767
    rCDN_123 (c_1037_p CDN_266) resistor r=27.0909
    rCDN_122 (c_1037_p c_1045_p) resistor r=3.71511
    rCDN_121 (CDN_266 c_1083_p) resistor r=3.71511
    rCDN_120 (CDN_271 c_1045_p) resistor r=4.38767
    rCDN_119 (c_1018_n CDN_280) resistor r=38.6045
    rCDN_118 (c_1018_n CDN_295) resistor r=9.29775
    rCDN_117 (CDN_280 c_1045_p) resistor r=3.71511
    rCDN_116 (c_998_n c_1083_p) resistor r=3.71511
    rD_183 (c_903_n c_932_n) resistor r=58.3583
    rD_182 (c_903_n c_932_n) resistor r=4.16253
    rD_181 (c_903_n c_932_n) resistor r=58.3583
    rD_180 (c_903_n c_932_n) resistor r=4.16253
    rD_179 (c_931_n c_932_n) resistor r=58.3583
    rD_178 (c_931_n c_932_n) resistor r=4.16253
    rD_177 (c_931_n c_932_n) resistor r=58.3583
    rD_176 (c_931_n c_932_n) resistor r=4.16253
    rD_175 (c_932_n D_33) resistor r=24.8333
    rD_174 (c_932_n c_905_n) resistor r=24.8333
    rD_173 (c_932_n D_41) resistor r=24.8333
    rD_172 (c_932_n c_970_n) resistor r=24.8333
    rD_171 (c_932_n D_46) resistor r=14.9
    rD_170 (c_932_n D_52) resistor r=58.3583
    rD_169 (c_932_n c_936_n) resistor r=58.3583
    rD_168 (c_932_n D_33) resistor r=4.16253
    rD_167 (c_932_n D_41) resistor r=4.16253
    rD_166 (c_932_n D_52) resistor r=6.30933
    rD_165 (c_932_n D_46) resistor r=6.30933
    rD_164 (c_932_n c_905_n) resistor r=1.63969
    rD_163 (c_932_n c_970_n) resistor r=4.16253
    rD_162 (c_932_n c_936_n) resistor r=4.16253
    rD_161 (c_932_n D_33) resistor r=24.8333
    rD_160 (c_932_n c_905_n) resistor r=24.8333
    rD_159 (c_932_n D_41) resistor r=24.8333
    rD_158 (c_932_n c_970_n) resistor r=24.8333
    rD_157 (c_932_n D_166) resistor r=47.1833
    rD_156 (c_932_n D_46) resistor r=14.9
    rD_155 (c_932_n D_52) resistor r=58.3583
    rD_154 (c_932_n MM14_ELT_g) resistor r=7.45
    rD_153 (c_932_n D_33) resistor r=4.16253
    rD_152 (c_932_n D_41) resistor r=4.16253
    rD_151 (c_932_n D_52) resistor r=6.30933
    rD_150 (c_932_n D_46) resistor r=6.30933
    rD_149 (c_932_n c_905_n) resistor r=1.63969
    rD_148 (c_932_n c_970_n) resistor r=4.16253
    rD_147 (c_932_n c_936_n) resistor r=4.16253
    rD_146 (c_936_n MM14_ELT_g) resistor r=50.9083
    rD_145 (c_906_n c_907_n) resistor r=58.3583
    rD_144 (c_906_n c_907_n) resistor r=4.16253
    rD_143 (c_906_n c_907_n) resistor r=58.3583
    rD_142 (c_906_n c_907_n) resistor r=4.16253
    rD_141 (D_63 c_907_n) resistor r=58.3583
    rD_140 (D_63 c_907_n) resistor r=6.30933
    rD_139 (D_63 c_907_n) resistor r=58.3583
    rD_138 (D_63 c_907_n) resistor r=6.30933
    rD_137 (c_907_n D_68) resistor r=14.9
    rD_136 (c_907_n D_77) resistor r=24.8333
    rD_135 (c_907_n c_980_p) resistor r=24.8333
    rD_134 (c_907_n D_85) resistor r=24.8333
    rD_133 (c_907_n c_910_n) resistor r=24.8333
    rD_132 (c_907_n c_975_p) resistor r=58.3583
    rD_131 (c_907_n c_911_n) resistor r=58.3583
    rD_130 (c_907_n D_77) resistor r=4.16253
    rD_129 (c_907_n D_68) resistor r=6.30933
    rD_128 (c_907_n D_85) resistor r=1.63969
    rD_127 (c_907_n c_980_p) resistor r=4.16253
    rD_126 (c_907_n c_975_p) resistor r=4.16253
    rD_125 (c_907_n c_910_n) resistor r=4.16253
    rD_124 (c_907_n c_911_n) resistor r=4.16253
    rD_123 (c_907_n D_68) resistor r=14.9
    rD_122 (c_907_n D_180) resistor r=39.7333
    rD_121 (c_907_n D_77) resistor r=24.8333
    rD_120 (c_907_n c_980_p) resistor r=24.8333
    rD_119 (c_907_n D_85) resistor r=24.8333
    rD_118 (c_907_n c_910_n) resistor r=24.8333
    rD_117 (c_907_n c_975_p) resistor r=58.3583
    rD_116 (c_907_n MM17_ELT_g) resistor r=7.45
    rD_115 (c_907_n D_77) resistor r=4.16253
    rD_114 (c_907_n D_68) resistor r=6.30933
    rD_113 (c_907_n D_85) resistor r=1.63969
    rD_112 (c_907_n c_980_p) resistor r=4.16253
    rD_111 (c_907_n c_975_p) resistor r=4.16253
    rD_110 (c_907_n c_910_n) resistor r=4.16253
    rD_109 (c_907_n c_911_n) resistor r=4.16253
    rD_108 (c_911_n MM17_ELT_g) resistor r=50.9083
    rD_107 (D D_135) resistor r=10
    rD_106 (D_135 c_924_n) resistor r=16.9318
    rD_105 (D_166 c_918_n) resistor r=9.29775
    rD_104 (c_944_n c_918_n) resistor r=22.35
    rD_103 (c_944_n c_921_n) resistor r=9.29775
    rD_102 (D_180 c_926_n) resistor r=10.0997
    rD_101 (D_182 c_921_n) resistor r=255.783
    rD_100 (D_182 c_926_n) resistor r=10.0997
    rD_99 (c_924_n c_926_n) resistor r=0.877078
    rnet49_96 (MM14_ELT_d net49) resistor r=0.01
    rnet49_95 (net49_1 c_823_n) resistor r=0.458607
    rnet49_94 (net49_1 net49_13) resistor r=0.0100978
    rnet49_93 (c_823_n c_826_n) resistor r=13
    rnet49_92 (c_826_n MM15_ELT_s) resistor r=8.09035
    rnet49_91 (net49_6 c_845_n) resistor r=0.266396
    rnet49_90 (net49_6 net49_17) resistor r=0.0100978
    rnet49_89 (c_845_n c_830_n) resistor r=13
    rnet49_88 (c_830_n net49) resistor r=8.09035
    rnet49_87 (net49_11 c_831_n) resistor r=0.402019
    rnet49_86 (net49_11 c_836_n) resistor r=0.0100978
    rnet49_85 (c_831_n c_839_n) resistor r=0.0100978
    rnet49_84 (net49_13 c_836_n) resistor r=0.0926912
    rnet49_83 (net49_17 c_839_n) resistor r=0.0926912
    rnet67_450 (MM8_ELT_d net67) resistor r=0.01
    rnet67_449 (c_704_p c_668_p) resistor r=58.3583
    rnet67_448 (c_704_p c_668_p) resistor r=4.16253
    rnet67_447 (c_704_p c_668_p) resistor r=58.3583
    rnet67_446 (c_704_p c_668_p) resistor r=4.16253
    rnet67_445 (net67_25 c_668_p) resistor r=58.3583
    rnet67_444 (net67_25 c_668_p) resistor r=5.53947
    rnet67_443 (net67_25 c_668_p) resistor r=58.3583
    rnet67_442 (net67_25 c_668_p) resistor r=5.53947
    rnet67_441 (c_668_p net67_30) resistor r=11.175
    rnet67_440 (c_668_p net67_53) resistor r=24.8333
    rnet67_439 (c_668_p c_770_p) resistor r=24.8333
    rnet67_438 (c_668_p net67_69) resistor r=22.35
    rnet67_437 (c_668_p c_773_p) resistor r=22.35
    rnet67_436 (c_668_p net67_82) resistor r=58.3583
    rnet67_435 (c_668_p c_782_p) resistor r=58.3583
    rnet67_434 (c_668_p net67_53) resistor r=4.16253
    rnet67_433 (c_668_p net67_30) resistor r=5.53947
    rnet67_432 (c_668_p net67_69) resistor r=2.32428
    rnet67_431 (c_668_p c_770_p) resistor r=4.16253
    rnet67_430 (c_668_p net67_82) resistor r=4.16253
    rnet67_429 (c_668_p c_773_p) resistor r=4.16253
    rnet67_428 (c_668_p c_782_p) resistor r=4.16253
    rnet67_427 (c_668_p net67_30) resistor r=11.175
    rnet67_426 (c_668_p net67_218) resistor r=29.8
    rnet67_425 (c_668_p net67_53) resistor r=24.8333
    rnet67_424 (c_668_p c_770_p) resistor r=24.8333
    rnet67_423 (c_668_p net67_69) resistor r=22.35
    rnet67_422 (c_668_p c_773_p) resistor r=22.35
    rnet67_421 (c_668_p net67_82) resistor r=58.3583
    rnet67_420 (c_668_p MM7_ELT_g) resistor r=7.45
    rnet67_419 (c_668_p net67_53) resistor r=4.16253
    rnet67_418 (c_668_p net67_30) resistor r=5.53947
    rnet67_417 (c_668_p net67_69) resistor r=2.32428
    rnet67_416 (c_668_p c_770_p) resistor r=4.16253
    rnet67_415 (c_668_p net67_82) resistor r=4.16253
    rnet67_414 (c_668_p c_773_p) resistor r=4.16253
    rnet67_413 (c_668_p c_782_p) resistor r=4.16253
    rnet67_412 (net67_36 c_671_p) resistor r=11.175
    rnet67_411 (net67_36 c_671_p) resistor r=5.53947
    rnet67_410 (net67_36 c_671_p) resistor r=11.175
    rnet67_409 (net67_36 c_671_p) resistor r=5.53947
    rnet67_408 (c_671_p net67_42) resistor r=202.392
    rnet67_407 (c_671_p c_684_p) resistor r=202.392
    rnet67_406 (c_671_p net67_61) resistor r=24.8333
    rnet67_405 (c_671_p c_776_p) resistor r=24.8333
    rnet67_404 (c_671_p net67_77) resistor r=22.35
    rnet67_403 (c_671_p c_764_p) resistor r=22.35
    rnet67_402 (c_671_p c_794_p) resistor r=202.392
    rnet67_401 (c_671_p net67_93) resistor r=202.392
    rnet67_400 (c_671_p net67_42) resistor r=5.53947
    rnet67_399 (c_671_p net67_77) resistor r=2.32428
    rnet67_398 (c_671_p net67_61) resistor r=4.16253
    rnet67_397 (c_671_p c_684_p) resistor r=4.16253
    rnet67_396 (c_671_p c_764_p) resistor r=4.16253
    rnet67_395 (c_671_p c_794_p) resistor r=4.16253
    rnet67_394 (c_671_p c_776_p) resistor r=4.16253
    rnet67_393 (c_671_p net67_93) resistor r=4.16253
    rnet67_392 (c_671_p net67_220) resistor r=31.6625
    rnet67_391 (c_671_p net67_42) resistor r=202.392
    rnet67_390 (c_671_p c_684_p) resistor r=202.392
    rnet67_389 (c_671_p net67_61) resistor r=24.8333
    rnet67_388 (c_671_p c_776_p) resistor r=24.8333
    rnet67_387 (c_671_p net67_77) resistor r=22.35
    rnet67_386 (c_671_p c_764_p) resistor r=22.35
    rnet67_385 (c_671_p c_794_p) resistor r=202.392
    rnet67_384 (c_671_p MM6_ELT_g) resistor r=7.45
    rnet67_383 (c_671_p net67_42) resistor r=5.53947
    rnet67_382 (c_671_p net67_77) resistor r=2.32428
    rnet67_381 (c_671_p net67_61) resistor r=4.16253
    rnet67_380 (c_671_p c_684_p) resistor r=4.16253
    rnet67_379 (c_671_p c_764_p) resistor r=4.16253
    rnet67_378 (c_671_p c_794_p) resistor r=4.16253
    rnet67_377 (c_671_p c_776_p) resistor r=4.16253
    rnet67_376 (c_671_p net67_93) resistor r=4.16253
    rnet67_375 (c_782_p MM7_ELT_g) resistor r=50.9083
    rnet67_374 (net67_93 MM6_ELT_g) resistor r=194.942
    rnet67_373 (c_540_n c_586_n) resistor r=1.02108
    rnet67_372 (c_540_n net67_135) resistor r=0.0960675
    rnet67_371 (c_586_n net67_183) resistor r=0.0964141
    rnet67_370 (net67_135 c_546_n) resistor r=0.58054
    rnet67_369 (c_546_n c_591_n) resistor r=0.0960675
    rnet67_368 (c_547_n c_591_n) resistor r=0.389629
    rnet67_367 (c_547_n c_615_n) resistor r=0.072807
    rnet67_366 (net67_139 c_593_n) resistor r=0.209775
    rnet67_365 (net67_139 c_602_n) resistor r=0.0960675
    rnet67_364 (c_593_n c_596_n) resistor r=13
    rnet67_363 (c_596_n MM10_ELT_d) resistor r=8.09035
    rnet67_362 (c_549_n c_602_n) resistor r=0.385505
    rnet67_361 (c_549_n c_750_p) resistor r=0.072807
    rnet67_360 (net67_146 c_550_n) resistor r=0.414671
    rnet67_359 (net67_146 c_615_n) resistor r=0.0189213
    rnet67_358 (c_550_n c_554_n) resistor r=13
    rnet67_357 (c_554_n MM11_ELT_d) resistor r=8.44
    rnet67_356 (c_558_n net67_152) resistor r=0.166984
    rnet67_355 (c_558_n c_822_p) resistor r=0.072807
    rnet67_354 (net67_152 c_615_n) resistor r=0.072807
    rnet67_353 (net67_153 c_607_n) resistor r=0.617219
    rnet67_352 (net67_153 c_822_p) resistor r=0.0189213
    rnet67_351 (c_607_n c_750_p) resistor r=0.0189213
    rnet67_350 (c_692_p net67_156) resistor r=0.864733
    rnet67_349 (c_692_p c_673_p) resistor r=0.0960675
    rnet67_348 (net67_156 c_822_p) resistor r=0.072807
    rnet67_347 (c_670_p net67_158) resistor r=0.980035
    rnet67_346 (c_670_p net67_166) resistor r=0.0960675
    rnet67_345 (net67_158 c_750_p) resistor r=0.072807
    rnet67_344 (net67_159 c_673_p) resistor r=1.40035
    rnet67_343 (net67_159 c_669_p) resistor r=0.101295
    rnet67_342 (c_669_p c_674_p) resistor r=0.330054
    rnet67_341 (c_674_p net67_164) resistor r=10
    rnet67_340 (net67_164 c_688_p) resistor r=12.8682
    rnet67_339 (net67_166 c_675_p) resistor r=0.2291
    rnet67_338 (c_675_p c_676_p) resistor r=13
    rnet67_337 (c_676_p net67) resistor r=8.09035
    rnet67_336 (c_559_n c_560_n) resistor r=0.046393
    rnet67_335 (c_559_n net67_183) resistor r=0.318124
    rnet67_334 (c_560_n net67_175) resistor r=8.66667
    rnet67_333 (net67_175 MM15_ELT_d) resistor r=2.78649
    rnet67_332 (net67_175 c_573_n) resistor r=11.6377
    rnet67_331 (net67_180 c_563_n) resistor r=0.513665
    rnet67_330 (net67_180 net67_190) resistor r=0.00803662
    rnet67_329 (c_563_n net67_183) resistor r=0.75
    rnet67_328 (net67_185 c_566_n) resistor r=0.147873
    rnet67_327 (net67_185 c_570_n) resistor r=0.00803662
    rnet67_326 (c_566_n c_579_n) resistor r=0.75
    rnet67_325 (net67_190 c_570_n) resistor r=0.155656
    rnet67_324 (net67_218 c_766_p) resistor r=8.1518
    rnet67_323 (net67_220 c_766_p) resistor r=8.1518
    rnet67_322 (c_688_p c_766_p) resistor r=0.275023
    rnet67_321 (MM15_ELT_d c_647_p) resistor r=2.55965
    rnet67_320 (MM15_ELT_d c_643_p) resistor r=12.3172
    rnet67_319 (MM15_ELT_d c_643_p) resistor r=1.62887
    rnet67_318 (MM15_ELT_d c_649_p) resistor r=4.36821
    rnet67_317 (net67_259 c_647_p) resistor r=14.4784
    rnet67_316 (net67_259 net67_264) resistor r=9.04062
    rnet67_315 (net67_260 c_647_p) resistor r=14.4784
    rnet67_314 (net67_260 c_573_n) resistor r=9.48555
    rnet67_313 (net67_262 c_643_p) resistor r=12.3172
    rnet67_312 (net67_262 net67_265) resistor r=9.04595
    rnet67_311 (net67_264 c_649_p) resistor r=20.2547
    rnet67_310 (net67_265 c_649_p) resistor r=20.2547
    rnet67_309 (c_578_n c_579_n) resistor r=13
    rnet67_308 (c_578_n MM16_ELT_d) resistor r=8.44
    rENN_473 (MM1_ELT_d ENN) resistor r=0.01
    rENN_472 (c_488_p c_289_n) resistor r=58.3583
    rENN_471 (c_488_p c_289_n) resistor r=4.16253
    rENN_470 (c_488_p c_289_n) resistor r=58.3583
    rENN_469 (c_488_p c_289_n) resistor r=4.16253
    rENN_468 (ENN_45 c_289_n) resistor r=58.3583
    rENN_467 (ENN_45 c_289_n) resistor r=6.30933
    rENN_466 (ENN_45 c_289_n) resistor r=58.3583
    rENN_465 (ENN_45 c_289_n) resistor r=6.30933
    rENN_464 (c_289_n ENN_50) resistor r=14.9
    rENN_463 (c_289_n ENN_73) resistor r=24.8333
    rENN_462 (c_289_n c_340_n) resistor r=24.8333
    rENN_461 (c_289_n ENN_81) resistor r=24.8333
    rENN_460 (c_289_n c_344_n) resistor r=24.8333
    rENN_459 (c_289_n c_352_n) resistor r=58.3583
    rENN_458 (c_289_n c_428_p) resistor r=58.3583
    rENN_457 (c_289_n ENN_73) resistor r=4.16253
    rENN_456 (c_289_n ENN_50) resistor r=6.30933
    rENN_455 (c_289_n ENN_81) resistor r=1.63969
    rENN_454 (c_289_n c_340_n) resistor r=4.16253
    rENN_453 (c_289_n c_352_n) resistor r=4.16253
    rENN_452 (c_289_n c_344_n) resistor r=4.16253
    rENN_451 (c_289_n c_428_p) resistor r=4.16253
    rENN_450 (c_289_n ENN_50) resistor r=14.9
    rENN_449 (c_289_n ENN_352) resistor r=40.975
    rENN_448 (c_289_n ENN_73) resistor r=24.8333
    rENN_447 (c_289_n c_340_n) resistor r=24.8333
    rENN_446 (c_289_n ENN_81) resistor r=24.8333
    rENN_445 (c_289_n c_344_n) resistor r=24.8333
    rENN_444 (c_289_n c_352_n) resistor r=58.3583
    rENN_443 (c_289_n MM29_ELT_g) resistor r=7.45
    rENN_442 (c_289_n ENN_73) resistor r=4.16253
    rENN_441 (c_289_n ENN_50) resistor r=6.30933
    rENN_440 (c_289_n ENN_81) resistor r=1.63969
    rENN_439 (c_289_n c_340_n) resistor r=4.16253
    rENN_438 (c_289_n c_352_n) resistor r=4.16253
    rENN_437 (c_289_n c_344_n) resistor r=4.16253
    rENN_436 (c_289_n c_428_p) resistor r=4.16253
    rENN_435 (ENN_56 c_292_n) resistor r=14.9
    rENN_434 (ENN_56 c_292_n) resistor r=6.30933
    rENN_433 (ENN_56 c_292_n) resistor r=14.9
    rENN_432 (ENN_56 c_292_n) resistor r=6.30933
    rENN_431 (c_292_n ENN_62) resistor r=202.392
    rENN_430 (c_292_n c_295_n) resistor r=202.392
    rENN_429 (c_292_n ENN_89) resistor r=24.8333
    rENN_428 (c_292_n c_347_n) resistor r=24.8333
    rENN_427 (c_292_n ENN_97) resistor r=24.8333
    rENN_426 (c_292_n c_350_n) resistor r=24.8333
    rENN_425 (c_292_n c_353_n) resistor r=202.392
    rENN_424 (c_292_n c_465_p) resistor r=202.392
    rENN_423 (c_292_n ENN_62) resistor r=6.30933
    rENN_422 (c_292_n ENN_89) resistor r=1.63969
    rENN_421 (c_292_n ENN_97) resistor r=4.16253
    rENN_420 (c_292_n c_295_n) resistor r=4.16253
    rENN_419 (c_292_n c_347_n) resistor r=4.16253
    rENN_418 (c_292_n c_353_n) resistor r=4.16253
    rENN_417 (c_292_n c_350_n) resistor r=4.16253
    rENN_416 (c_292_n c_465_p) resistor r=4.16253
    rENN_415 (c_292_n ENN_354) resistor r=40.975
    rENN_414 (c_292_n ENN_62) resistor r=202.392
    rENN_413 (c_292_n c_295_n) resistor r=202.392
    rENN_412 (c_292_n ENN_89) resistor r=24.8333
    rENN_411 (c_292_n c_347_n) resistor r=24.8333
    rENN_410 (c_292_n ENN_97) resistor r=24.8333
    rENN_409 (c_292_n c_350_n) resistor r=24.8333
    rENN_408 (c_292_n c_353_n) resistor r=202.392
    rENN_407 (c_292_n MM28_ELT_g) resistor r=7.45
    rENN_406 (c_292_n ENN_62) resistor r=6.30933
    rENN_405 (c_292_n ENN_89) resistor r=1.63969
    rENN_404 (c_292_n ENN_97) resistor r=4.16253
    rENN_403 (c_292_n c_295_n) resistor r=4.16253
    rENN_402 (c_292_n c_347_n) resistor r=4.16253
    rENN_401 (c_292_n c_353_n) resistor r=4.16253
    rENN_400 (c_292_n c_350_n) resistor r=4.16253
    rENN_399 (c_292_n c_465_p) resistor r=4.16253
    rENN_398 (c_428_p MM29_ELT_g) resistor r=50.9083
    rENN_397 (c_465_p MM28_ELT_g) resistor r=194.942
    rENN_396 (c_354_n c_355_n) resistor r=58.3583
    rENN_395 (c_354_n c_355_n) resistor r=4.16253
    rENN_394 (c_354_n c_355_n) resistor r=58.3583
    rENN_393 (c_354_n c_355_n) resistor r=4.16253
    rENN_392 (ENN_121 c_355_n) resistor r=58.3583
    rENN_391 (ENN_121 c_355_n) resistor r=6.30933
    rENN_390 (ENN_121 c_355_n) resistor r=58.3583
    rENN_389 (ENN_121 c_355_n) resistor r=6.30933
    rENN_388 (c_355_n ENN_126) resistor r=14.9
    rENN_387 (c_355_n ENN_135) resistor r=24.8333
    rENN_386 (c_355_n c_358_n) resistor r=24.8333
    rENN_385 (c_355_n ENN_143) resistor r=24.8333
    rENN_384 (c_355_n c_359_n) resistor r=24.8333
    rENN_383 (c_355_n c_360_n) resistor r=58.3583
    rENN_382 (c_355_n c_362_n) resistor r=58.3583
    rENN_381 (c_355_n ENN_135) resistor r=4.16253
    rENN_380 (c_355_n ENN_126) resistor r=6.30933
    rENN_379 (c_355_n ENN_143) resistor r=1.63969
    rENN_378 (c_355_n c_358_n) resistor r=4.16253
    rENN_377 (c_355_n c_360_n) resistor r=4.16253
    rENN_376 (c_355_n c_359_n) resistor r=4.16253
    rENN_375 (c_355_n c_362_n) resistor r=4.16253
    rENN_374 (c_355_n ENN_126) resistor r=14.9
    rENN_373 (c_355_n ENN_386) resistor r=40.975
    rENN_372 (c_355_n ENN_135) resistor r=24.8333
    rENN_371 (c_355_n c_358_n) resistor r=24.8333
    rENN_370 (c_355_n ENN_143) resistor r=24.8333
    rENN_369 (c_355_n c_359_n) resistor r=24.8333
    rENN_368 (c_355_n c_360_n) resistor r=58.3583
    rENN_367 (c_355_n MM16_ELT_g) resistor r=7.45
    rENN_366 (c_355_n ENN_135) resistor r=4.16253
    rENN_365 (c_355_n ENN_126) resistor r=6.30933
    rENN_364 (c_355_n ENN_143) resistor r=1.63969
    rENN_363 (c_355_n c_358_n) resistor r=4.16253
    rENN_362 (c_355_n c_360_n) resistor r=4.16253
    rENN_361 (c_355_n c_359_n) resistor r=4.16253
    rENN_360 (c_355_n c_362_n) resistor r=4.16253
    rENN_359 (c_362_n MM16_ELT_g) resistor r=50.9083
    rENN_358 (c_452_p c_405_p) resistor r=58.3583
    rENN_357 (c_452_p c_405_p) resistor r=4.16253
    rENN_356 (c_452_p c_405_p) resistor r=58.3583
    rENN_355 (c_452_p c_405_p) resistor r=4.16253
    rENN_354 (c_470_p c_405_p) resistor r=58.3583
    rENN_353 (c_470_p c_405_p) resistor r=4.16253
    rENN_352 (c_470_p c_405_p) resistor r=58.3583
    rENN_351 (c_470_p c_405_p) resistor r=4.16253
    rENN_350 (c_405_p ENN_167) resistor r=24.8333
    rENN_349 (c_405_p c_406_p) resistor r=24.8333
    rENN_348 (c_405_p ENN_175) resistor r=24.8333
    rENN_347 (c_405_p c_407_p) resistor r=24.8333
    rENN_346 (c_405_p ENN_180) resistor r=14.9
    rENN_345 (c_405_p ENN_186) resistor r=58.3583
    rENN_344 (c_405_p c_527_p) resistor r=58.3583
    rENN_343 (c_405_p ENN_167) resistor r=4.16253
    rENN_342 (c_405_p ENN_175) resistor r=4.16253
    rENN_341 (c_405_p ENN_186) resistor r=6.30933
    rENN_340 (c_405_p ENN_180) resistor r=6.30933
    rENN_339 (c_405_p c_406_p) resistor r=1.63969
    rENN_338 (c_405_p c_407_p) resistor r=4.16253
    rENN_337 (c_405_p c_527_p) resistor r=4.16253
    rENN_336 (c_405_p ENN_167) resistor r=24.8333
    rENN_335 (c_405_p c_406_p) resistor r=24.8333
    rENN_334 (c_405_p ENN_175) resistor r=24.8333
    rENN_333 (c_405_p c_407_p) resistor r=24.8333
    rENN_332 (c_405_p ENN_408) resistor r=47.1833
    rENN_331 (c_405_p ENN_180) resistor r=14.9
    rENN_330 (c_405_p ENN_186) resistor r=58.3583
    rENN_329 (c_405_p MM10_ELT_g) resistor r=7.45
    rENN_328 (c_405_p ENN_167) resistor r=4.16253
    rENN_327 (c_405_p ENN_175) resistor r=4.16253
    rENN_326 (c_405_p ENN_186) resistor r=6.30933
    rENN_325 (c_405_p ENN_180) resistor r=6.30933
    rENN_324 (c_405_p c_406_p) resistor r=1.63969
    rENN_323 (c_405_p c_407_p) resistor r=4.16253
    rENN_322 (c_405_p c_527_p) resistor r=4.16253
    rENN_321 (c_527_p MM10_ELT_g) resistor r=50.9083
    rENN_320 (ENN_261 c_296_n) resistor r=0.399593
    rENN_319 (ENN_261 c_312_n) resistor r=0.0960675
    rENN_318 (c_296_n c_299_n) resistor r=13
    rENN_317 (c_299_n MM0_ELT_d) resistor r=8.44
    rENN_316 (ENN_266 c_303_n) resistor r=0.399593
    rENN_315 (ENN_266 c_320_n) resistor r=0.0960675
    rENN_314 (c_303_n c_305_n) resistor r=8.66667
    rENN_313 (c_303_n ENN_271) resistor r=0.63935
    rENN_312 (c_305_n ENN) resistor r=32.3614
    rENN_311 (ENN_271 ENN_272) resistor r=8.66667
    rENN_310 (ENN_271 ENN_274) resistor r=0.426233
    rENN_309 (ENN_272 ENN) resistor r=16.1807
    rENN_308 (ENN_272 ENN_275) resistor r=32.3614
    rENN_307 (ENN_274 ENN_275) resistor r=26
    rENN_306 (c_309_n c_312_n) resistor r=0.342645
    rENN_305 (c_309_n ENN_281) resistor r=0.0964141
    rENN_304 (c_316_n c_320_n) resistor r=0.289819
    rENN_303 (c_316_n c_324_n) resistor r=0.0964141
    rENN_302 (ENN_281 c_323_n) resistor r=0.119771
    rENN_301 (c_323_n c_325_n) resistor r=0.110209
    rENN_300 (ENN_283 c_324_n) resistor r=0.196424
    rENN_299 (ENN_283 c_325_n) resistor r=0.110209
    rENN_298 (c_369_n ENN_288) resistor r=0.317419
    rENN_297 (c_369_n ENN_297) resistor r=0.0453797
    rENN_296 (ENN_286 ENN_288) resistor r=0.00423225
    rENN_295 (ENN_286 c_325_n) resistor r=0.00721031
    rENN_294 (ENN_288 ENN_289) resistor r=10
    rENN_293 (ENN_289 c_327_n) resistor r=3.38636
    rENN_292 (ENN_290 c_374_n) resistor r=0.0126968
    rENN_291 (ENN_290 ENN_297) resistor r=0.0453797
    rENN_290 (c_374_n ENN_293) resistor r=10
    rENN_289 (ENN_293 c_393_n) resistor r=25.0591
    rENN_288 (ENN_296 ENN_297) resistor r=0.0467694
    rENN_287 (ENN_296 c_380_n) resistor r=0.788289
    rENN_286 (ENN_298 c_376_n) resistor r=0.334602
    rENN_285 (ENN_298 c_387_n) resistor r=0.0764581
    rENN_284 (c_376_n c_380_n) resistor r=0.75
    rENN_283 (c_387_n c_388_n) resistor r=0.844434
    rENN_282 (c_388_n c_391_n) resistor r=0.75
    rENN_281 (c_391_n ENN_440) resistor r=10
    rENN_280 (ENN_352 c_327_n) resistor r=5.23411
    rENN_279 (ENN_354 c_327_n) resistor r=5.23411
    rENN_278 (ENN_386 c_393_n) resistor r=9.29775
    rENN_277 (ENN_408 c_395_n) resistor r=4.38767
    rENN_276 (c_394_n c_395_n) resistor r=3.71511
    rENN_275 (c_394_n ENN_440) resistor r=14.9
    rEN_373 (MM28_ELT_d EN) resistor r=0.01
    rEN_372 (c_78_p c_57_p) resistor r=58.3583
    rEN_371 (c_78_p c_57_p) resistor r=4.16253
    rEN_370 (c_78_p c_57_p) resistor r=58.3583
    rEN_369 (c_78_p c_57_p) resistor r=4.16253
    rEN_368 (EN_25 c_57_p) resistor r=58.3583
    rEN_367 (EN_25 c_57_p) resistor r=6.30933
    rEN_366 (EN_25 c_57_p) resistor r=58.3583
    rEN_365 (EN_25 c_57_p) resistor r=6.30933
    rEN_364 (c_57_p EN_30) resistor r=14.9
    rEN_363 (c_57_p EN_39) resistor r=24.8333
    rEN_362 (c_57_p c_87_p) resistor r=24.8333
    rEN_361 (c_57_p EN_47) resistor r=24.8333
    rEN_360 (c_57_p c_113_p) resistor r=24.8333
    rEN_359 (c_57_p c_123_p) resistor r=58.3583
    rEN_358 (c_57_p c_200_p) resistor r=58.3583
    rEN_357 (c_57_p EN_39) resistor r=4.16253
    rEN_356 (c_57_p EN_30) resistor r=6.30933
    rEN_355 (c_57_p EN_47) resistor r=1.63969
    rEN_354 (c_57_p c_87_p) resistor r=4.16253
    rEN_353 (c_57_p c_123_p) resistor r=4.16253
    rEN_352 (c_57_p c_113_p) resistor r=4.16253
    rEN_351 (c_57_p c_200_p) resistor r=4.16253
    rEN_350 (c_57_p EN_30) resistor r=14.9
    rEN_349 (c_57_p EN_194) resistor r=39.7333
    rEN_348 (c_57_p EN_39) resistor r=24.8333
    rEN_347 (c_57_p c_87_p) resistor r=24.8333
    rEN_346 (c_57_p EN_47) resistor r=24.8333
    rEN_345 (c_57_p c_113_p) resistor r=24.8333
    rEN_344 (c_57_p c_123_p) resistor r=58.3583
    rEN_343 (c_57_p MM15_ELT_g) resistor r=7.45
    rEN_342 (c_57_p EN_39) resistor r=4.16253
    rEN_341 (c_57_p EN_30) resistor r=6.30933
    rEN_340 (c_57_p EN_47) resistor r=1.63969
    rEN_339 (c_57_p c_87_p) resistor r=4.16253
    rEN_338 (c_57_p c_123_p) resistor r=4.16253
    rEN_337 (c_57_p c_113_p) resistor r=4.16253
    rEN_336 (c_57_p c_200_p) resistor r=4.16253
    rEN_335 (c_200_p MM15_ELT_g) resistor r=50.9083
    rEN_334 (EN_60 c_124_p) resistor r=14.9
    rEN_333 (EN_60 c_124_p) resistor r=6.30933
    rEN_332 (EN_60 c_124_p) resistor r=14.9
    rEN_331 (EN_60 c_124_p) resistor r=6.30933
    rEN_330 (c_124_p EN_66) resistor r=58.3583
    rEN_329 (c_124_p c_116_p) resistor r=58.3583
    rEN_328 (c_124_p EN_77) resistor r=24.8333
    rEN_327 (c_124_p c_132_p) resistor r=24.8333
    rEN_326 (c_124_p EN_85) resistor r=24.8333
    rEN_325 (c_124_p c_117_p) resistor r=24.8333
    rEN_324 (c_124_p c_212_p) resistor r=58.3583
    rEN_323 (c_124_p c_139_p) resistor r=58.3583
    rEN_322 (c_124_p EN_66) resistor r=6.30933
    rEN_321 (c_124_p EN_77) resistor r=1.63969
    rEN_320 (c_124_p EN_85) resistor r=4.16253
    rEN_319 (c_124_p c_116_p) resistor r=4.16253
    rEN_318 (c_124_p c_132_p) resistor r=4.16253
    rEN_317 (c_124_p c_212_p) resistor r=4.16253
    rEN_316 (c_124_p c_117_p) resistor r=4.16253
    rEN_315 (c_124_p c_139_p) resistor r=4.16253
    rEN_314 (c_124_p EN_207) resistor r=39.7333
    rEN_313 (c_124_p EN_66) resistor r=58.3583
    rEN_312 (c_124_p c_116_p) resistor r=58.3583
    rEN_311 (c_124_p EN_77) resistor r=24.8333
    rEN_310 (c_124_p c_132_p) resistor r=24.8333
    rEN_309 (c_124_p EN_85) resistor r=24.8333
    rEN_308 (c_124_p c_117_p) resistor r=24.8333
    rEN_307 (c_124_p c_212_p) resistor r=58.3583
    rEN_306 (c_124_p MM11_ELT_g) resistor r=7.45
    rEN_305 (c_124_p EN_66) resistor r=6.30933
    rEN_304 (c_124_p EN_77) resistor r=1.63969
    rEN_303 (c_124_p EN_85) resistor r=4.16253
    rEN_302 (c_124_p c_116_p) resistor r=4.16253
    rEN_301 (c_124_p c_132_p) resistor r=4.16253
    rEN_300 (c_124_p c_212_p) resistor r=4.16253
    rEN_299 (c_124_p c_117_p) resistor r=4.16253
    rEN_298 (c_124_p c_139_p) resistor r=4.16253
    rEN_297 (c_139_p MM11_ELT_g) resistor r=50.9083
    rEN_296 (c_106_p c_58_p) resistor r=0.323384
    rEN_295 (c_106_p EN_157) resistor r=0.0575343
    rEN_294 (c_58_p EN_158) resistor r=0.072807
    rEN_293 (EN_133 c_59_p) resistor r=0.181149
    rEN_292 (EN_133 EN_158) resistor r=0.072807
    rEN_291 (c_59_p EN_136) resistor r=8.66667
    rEN_290 (c_59_p EN_138) resistor r=0.426233
    rEN_289 (EN_136 EN) resistor r=16.1807
    rEN_288 (EN_136 EN_139) resistor r=32.3614
    rEN_287 (EN_138 EN_139) resistor r=26
    rEN_286 (EN_141 c_60_p) resistor r=0.446809
    rEN_285 (EN_141 EN_158) resistor r=0.0189213
    rEN_284 (c_60_p EN_144) resistor r=10
    rEN_283 (EN_144 c_63_p) resistor r=22.35
    rEN_282 (c_65_p c_66_p) resistor r=1.28061
    rEN_281 (c_65_p EN_148) resistor r=0.0959342
    rEN_280 (c_66_p EN_156) resistor r=0.0959342
    rEN_279 (EN_148 c_86_p) resistor r=0.713267
    rEN_278 (c_86_p c_80_p) resistor r=0.0964141
    rEN_277 (c_126_p c_80_p) resistor r=0.539131
    rEN_276 (c_126_p EN_152) resistor r=0.0960675
    rEN_275 (EN_152 c_129_p) resistor r=0.191785
    rEN_274 (c_129_p c_134_p) resistor r=0.0480338
    rEN_273 (EN_156 c_56_p) resistor r=0.178208
    rEN_272 (EN_157 EN_250) resistor r=0.0113976
    rEN_271 (c_134_p EN_161) resistor r=10
    rEN_270 (EN_161 c_194_p) resistor r=5.41818
    rEN_269 (c_51_n c_56_p) resistor r=0.75
    rEN_268 (c_51_n EN_167) resistor r=0.918371
    rEN_267 (EN_167 c_62_p) resistor r=0.75
    rEN_266 (c_62_p EN_250) resistor r=0.262144
    rEN_265 (EN_194 c_63_p) resistor r=9.29775
    rEN_264 (EN_207 c_211_p) resistor r=4.38767
    rEN_263 (c_194_p c_211_p) resistor r=3.71511
    rEN_262 (c_55_p c_56_p) resistor r=13
    rEN_261 (c_55_p MM29_ELT_d) resistor r=8.44
    rEN_260 (c_64_p EN_250) resistor r=8.66667
    rEN_259 (c_64_p EN) resistor r=32.3614
    rE_134 (c_44_p c_1_p) resistor r=58.3583
    rE_133 (c_44_p c_1_p) resistor r=4.16253
    rE_132 (c_44_p c_1_p) resistor r=58.3583
    rE_131 (c_44_p c_1_p) resistor r=4.16253
    rE_130 (E_25 c_1_p) resistor r=58.3583
    rE_129 (E_25 c_1_p) resistor r=6.30933
    rE_128 (E_25 c_1_p) resistor r=58.3583
    rE_127 (E_25 c_1_p) resistor r=6.30933
    rE_126 (c_1_p E_30) resistor r=14.9
    rE_125 (c_1_p E_53) resistor r=24.8333
    rE_124 (c_1_p c_12_p) resistor r=24.8333
    rE_123 (c_1_p E_61) resistor r=24.8333
    rE_122 (c_1_p c_13_p) resistor r=24.8333
    rE_121 (c_1_p c_46_p) resistor r=58.3583
    rE_120 (c_1_p c_2_p) resistor r=58.3583
    rE_119 (c_1_p E_53) resistor r=4.16253
    rE_118 (c_1_p E_30) resistor r=6.30933
    rE_117 (c_1_p E_61) resistor r=1.63969
    rE_116 (c_1_p c_12_p) resistor r=4.16253
    rE_115 (c_1_p c_46_p) resistor r=4.16253
    rE_114 (c_1_p c_13_p) resistor r=4.16253
    rE_113 (c_1_p c_2_p) resistor r=4.16253
    rE_112 (c_1_p E_30) resistor r=14.9
    rE_111 (c_1_p E_161) resistor r=40.975
    rE_110 (c_1_p E_53) resistor r=24.8333
    rE_109 (c_1_p c_12_p) resistor r=24.8333
    rE_108 (c_1_p E_61) resistor r=24.8333
    rE_107 (c_1_p c_13_p) resistor r=24.8333
    rE_106 (c_1_p c_46_p) resistor r=58.3583
    rE_105 (c_1_p MM0_ELT_g) resistor r=7.45
    rE_104 (c_1_p E_53) resistor r=4.16253
    rE_103 (c_1_p E_30) resistor r=6.30933
    rE_102 (c_1_p E_61) resistor r=1.63969
    rE_101 (c_1_p c_12_p) resistor r=4.16253
    rE_100 (c_1_p c_46_p) resistor r=4.16253
    rE_99 (c_1_p c_13_p) resistor r=4.16253
    rE_98 (c_1_p c_2_p) resistor r=4.16253
    rE_97 (E_36 c_7_p) resistor r=14.9
    rE_96 (E_36 c_7_p) resistor r=6.30933
    rE_95 (E_36 c_7_p) resistor r=14.9
    rE_94 (E_36 c_7_p) resistor r=6.30933
    rE_93 (c_7_p E_42) resistor r=202.392
    rE_92 (c_7_p c_48_p) resistor r=202.392
    rE_91 (c_7_p E_69) resistor r=24.8333
    rE_90 (c_7_p c_21_p) resistor r=24.8333
    rE_89 (c_7_p E_77) resistor r=24.8333
    rE_88 (c_7_p c_19_p) resistor r=24.8333
    rE_87 (c_7_p c_8_p) resistor r=202.392
    rE_86 (c_7_p c_10_p) resistor r=202.392
    rE_85 (c_7_p E_42) resistor r=6.30933
    rE_84 (c_7_p E_69) resistor r=1.63969
    rE_83 (c_7_p E_77) resistor r=4.16253
    rE_82 (c_7_p c_48_p) resistor r=4.16253
    rE_81 (c_7_p c_21_p) resistor r=4.16253
    rE_80 (c_7_p c_8_p) resistor r=4.16253
    rE_79 (c_7_p c_19_p) resistor r=4.16253
    rE_78 (c_7_p c_10_p) resistor r=4.16253
    rE_77 (c_7_p E_163) resistor r=40.975
    rE_76 (c_7_p E_42) resistor r=202.392
    rE_75 (c_7_p c_48_p) resistor r=202.392
    rE_74 (c_7_p E_69) resistor r=24.8333
    rE_73 (c_7_p c_21_p) resistor r=24.8333
    rE_72 (c_7_p E_77) resistor r=24.8333
    rE_71 (c_7_p c_19_p) resistor r=24.8333
    rE_70 (c_7_p c_8_p) resistor r=202.392
    rE_69 (c_7_p MM1_ELT_g) resistor r=7.45
    rE_68 (c_7_p E_42) resistor r=6.30933
    rE_67 (c_7_p E_69) resistor r=1.63969
    rE_66 (c_7_p E_77) resistor r=4.16253
    rE_65 (c_7_p c_48_p) resistor r=4.16253
    rE_64 (c_7_p c_21_p) resistor r=4.16253
    rE_63 (c_7_p c_8_p) resistor r=4.16253
    rE_62 (c_7_p c_19_p) resistor r=4.16253
    rE_61 (c_7_p c_10_p) resistor r=4.16253
    rE_60 (c_2_p MM0_ELT_g) resistor r=50.9083
    rE_59 (c_10_p MM1_ELT_g) resistor r=194.942
    rE_58 (E_133 E) resistor r=10
    rE_57 (E_133 c_26_p) resistor r=0.677273
    rE_56 (E_161 c_26_p) resistor r=5.23411
    rE_55 (E_163 c_26_p) resistor r=5.23411
ends LHENCNQD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: LHCNQD2_LVT_ELT
// View name: calibre
subckt LHCNQD2_LVT_ELT D E CDN Q VDD VSS
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.3885e-13 pd=1.34e-06 \
        ps=3.51e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM30_ELT (MM30_ELT_d MM30_ELT_g MM30_ELT_s MM30_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.3885e-13 pd=1.34e-06 \
        ps=3.51e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.3885e-13 pd=1.34e-06 \
        ps=3.51e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 \
        ps=4.76e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM16_ELT (MM16_ELT_d MM16_ELT_g MM16_ELT_s MM16_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM29_ELT (MM29_ELT_d MM29_ELT_g MM29_ELT_s MM29_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.2165e-13 pd=3.66e-06 \
        ps=6.89333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM42_ELT (MM42_ELT_d MM42_ELT_g MM42_ELT_s MM42_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.2165e-13 pd=3.66e-06 \
        ps=6.89333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.2165e-13 pd=3.66e-06 \
        ps=6.89333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=3.03125e-13 as=9.4e-14 pd=4.8e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM28_ELT (MM28_ELT_d MM28_ELT_g MM28_ELT_s MM28_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet29_6 (net29_4 VSS) capacitor c=5.47935e-18
    cinet29_5 (net29_5 VSS) capacitor c=2.81534e-18
    cinet29_4 (MM12_ELT_d VSS) capacitor c=5.49052e-18
    cinet29_3 (net29_12 VSS) capacitor c=1.20107e-18
    cinet29_2 (net29_14 VSS) capacitor c=5.70188e-18
    cinet29_1 (net29_16 VSS) capacitor c=4.71508e-18
    cinet29_0 (net29 VSS) capacitor c=9.46668e-18
    cinet17_8 (MM16_ELT_s VSS) capacitor c=6.741e-18
    cinet17_7 (net17_4 VSS) capacitor c=6.02701e-19
    cinet17_6 (net17_5 VSS) capacitor c=1.19602e-18
    cinet17_5 (net17_11 VSS) capacitor c=2.68406e-17
    cinet17_4 (net17_15 VSS) capacitor c=3.69063e-18
    cinet17_3 (net17_16 VSS) capacitor c=6.53282e-18
    cinet17_2 (net17_19 VSS) capacitor c=8.48875e-18
    cinet17_1 (net17_20 VSS) capacitor c=7.37056e-18
    cinet17_0 (net17 VSS) capacitor c=3.51213e-18
    cinet72_7 (net72_4 VSS) capacitor c=5.08287e-18
    cinet72_6 (net72_6 VSS) capacitor c=6.21964e-18
    cinet72_5 (net72_9 VSS) capacitor c=1.71175e-18
    cinet72_4 (MM9_ELT_d VSS) capacitor c=1.08186e-17
    cinet72_3 (net72_13 VSS) capacitor c=4.91492e-18
    cinet72_2 (net72_15 VSS) capacitor c=7.44397e-18
    cinet72_1 (net72_18 VSS) capacitor c=1.18424e-17
    cinet72_0 (net72_20 VSS) capacitor c=1.15496e-17
    ciQ_14 (Q_3 VSS) capacitor c=7.03835e-17
    ciQ_13 (Q_4 VSS) capacitor c=1.17262e-16
    ciQ_12 (Q_8 VSS) capacitor c=2.2063e-16
    ciQ_11 (Q_9 VSS) capacitor c=3.5231e-16
    ciQ_10 (Q_17 VSS) capacitor c=7.20035e-17
    ciQ_9 (Q_18 VSS) capacitor c=1.3993e-17
    ciQ_8 (Q_19 VSS) capacitor c=6.42426e-17
    ciQ_7 (Q_20 VSS) capacitor c=1.70149e-17
    ciQ_6 (Q_23 VSS) capacitor c=5.59342e-17
    ciQ_5 (Q_24 VSS) capacitor c=1.11559e-16
    ciQ_4 (Q_28 VSS) capacitor c=1.75499e-16
    ciQ_3 (Q_29 VSS) capacitor c=3.28883e-16
    ciQ_2 (Q VSS) capacitor c=3.95162e-17
    ciQ_1 (Q_42 VSS) capacitor c=2.1646e-17
    ciQ_0 (Q_45 VSS) capacitor c=2.8362e-17
    ciVDD_56 (VDD_2 VSS) capacitor c=6.33975e-17
    ciVDD_55 (VDD_11 VSS) capacitor c=2.75172e-16
    ciVDD_54 (VDD_19 VSS) capacitor c=3.85537e-16
    ciVDD_53 (VDD_20 VSS) capacitor c=5.04818e-17
    ciVDD_52 (VDD_27 VSS) capacitor c=8.23276e-17
    ciVDD_51 (VDD_28 VSS) capacitor c=8.25651e-17
    ciVDD_50 (VDD_30 VSS) capacitor c=1.08169e-16
    ciVDD_49 (VDD_43 VSS) capacitor c=5.80695e-17
    ciVDD_48 (VDD_44 VSS) capacitor c=1.18497e-16
    ciVDD_47 (VDD_46 VSS) capacitor c=6.27607e-17
    ciVDD_46 (VDD_53 VSS) capacitor c=8.01468e-17
    ciVDD_45 (VDD_54 VSS) capacitor c=1.42507e-16
    ciVDD_44 (VDD_56 VSS) capacitor c=8.77011e-17
    ciVDD_43 (VDD_66 VSS) capacitor c=2.25645e-16
    ciVDD_42 (VDD_74 VSS) capacitor c=3.74274e-16
    ciVDD_41 (VDD_75 VSS) capacitor c=2.99255e-17
    ciVDD_40 (VDD_82 VSS) capacitor c=2.32174e-16
    ciVDD_39 (VDD_90 VSS) capacitor c=3.79725e-16
    ciVDD_38 (VDD_96 VSS) capacitor c=6.92334e-17
    ciVDD_37 (VDD_99 VSS) capacitor c=3.58509e-18
    ciVDD_36 (VDD_100 VSS) capacitor c=3.58509e-18
    ciVDD_35 (VDD_101 VSS) capacitor c=3.58509e-18
    ciVDD_34 (VDD_102 VSS) capacitor c=3.58509e-18
    ciVDD_33 (VDD_103 VSS) capacitor c=3.58509e-18
    ciVDD_32 (VDD_104 VSS) capacitor c=3.58509e-18
    ciVDD_31 (MM1_ELT_s VSS) capacitor c=1.32762e-17
    ciVDD_30 (VDD_111 VSS) capacitor c=1.11099e-18
    ciVDD_29 (VDD_113 VSS) capacitor c=1.07074e-18
    ciVDD_28 (VDD_117 VSS) capacitor c=1.11099e-18
    ciVDD_27 (VDD_118 VSS) capacitor c=1.60033e-18
    ciVDD_26 (VDD_119 VSS) capacitor c=1.07074e-18
    ciVDD_25 (VDD_122 VSS) capacitor c=4.61254e-17
    ciVDD_24 (MM14_ELT_s VSS) capacitor c=5.08287e-18
    ciVDD_23 (VDD_125 VSS) capacitor c=6.12638e-18
    ciVDD_22 (VDD_128 VSS) capacitor c=1.71175e-18
    ciVDD_21 (VDD_133 VSS) capacitor c=3.97088e-18
    ciVDD_20 (VDD_134 VSS) capacitor c=7.12773e-18
    ciVDD_19 (VDD_135 VSS) capacitor c=4.39784e-18
    ciVDD_18 (VDD_138 VSS) capacitor c=1.71175e-18
    ciVDD_17 (VDD_140 VSS) capacitor c=4.16593e-18
    ciVDD_16 (VDD_144 VSS) capacitor c=1.71175e-18
    ciVDD_15 (VDD_146 VSS) capacitor c=7.02261e-18
    ciVDD_14 (MM4_ELT_s VSS) capacitor c=3.7279e-17
    ciVDD_13 (VDD_151 VSS) capacitor c=3.97088e-18
    ciVDD_12 (VDD_154 VSS) capacitor c=8.70264e-18
    ciVDD_11 (VDD_157 VSS) capacitor c=1.11099e-18
    ciVDD_10 (VDD_159 VSS) capacitor c=6.22982e-18
    ciVDD_9 (VDD_163 VSS) capacitor c=1.11099e-18
    ciVDD_8 (VDD_165 VSS) capacitor c=4.2035e-18
    ciVDD_7 (VDD_169 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_170 VSS) capacitor c=5.71245e-18
    ciVDD_5 (VDD_171 VSS) capacitor c=4.50558e-18
    ciVDD_4 (VDD_174 VSS) capacitor c=1.57204e-17
    ciVDD_3 (VDD_176 VSS) capacitor c=2.70329e-18
    ciVDD_2 (VDD_185 VSS) capacitor c=1.03458e-17
    ciVDD_1 (VDD_187 VSS) capacitor c=1.2097e-18
    ciVDD_0 (VDD_191 VSS) capacitor c=2.86265e-18
    ciVSS_40 (VSS_2 VSS) capacitor c=6.1349e-17
    ciVSS_39 (VSS_11 VSS) capacitor c=1.02339e-16
    ciVSS_38 (VSS_12 VSS) capacitor c=1.22554e-16
    ciVSS_37 (VSS_14 VSS) capacitor c=2.07051e-16
    ciVSS_36 (VSS_30 VSS) capacitor c=7.22359e-17
    ciVSS_35 (VSS_31 VSS) capacitor c=1.13397e-16
    ciVSS_34 (VSS_33 VSS) capacitor c=4.57221e-17
    ciVSS_33 (VSS_40 VSS) capacitor c=7.49479e-17
    ciVSS_32 (VSS_46 VSS) capacitor c=8.40993e-17
    ciVSS_31 (VSS_56 VSS) capacitor c=6.7919e-17
    ciVSS_30 (VSS_57 VSS) capacitor c=1.1594e-16
    ciVSS_29 (VSS_59 VSS) capacitor c=2.87128e-17
    ciVSS_28 (VSS_66 VSS) capacitor c=7.34039e-17
    ciVSS_27 (VSS_67 VSS) capacitor c=1.16919e-16
    ciVSS_26 (VSS_74 VSS) capacitor c=6.71508e-17
    ciVSS_25 (VSS_77 VSS) capacitor c=3.58509e-18
    ciVSS_24 (VSS_78 VSS) capacitor c=3.58509e-18
    ciVSS_23 (VSS_79 VSS) capacitor c=3.58509e-18
    ciVSS_22 (VSS_80 VSS) capacitor c=3.58509e-18
    ciVSS_21 (VSS_81 VSS) capacitor c=3.58509e-18
    ciVSS_20 (VSS_88 VSS) capacitor c=2.47056e-18
    ciVSS_19 (VSS_90 VSS) capacitor c=4.18247e-19
    ciVSS_18 (VSS_92 VSS) capacitor c=2.11324e-18
    ciVSS_17 (VSS_93 VSS) capacitor c=2.03427e-18
    ciVSS_16 (VSS_94 VSS) capacitor c=3.15923e-18
    ciVSS_15 (VSS_97 VSS) capacitor c=6.52035e-18
    ciVSS_14 (VSS_101 VSS) capacitor c=8.25279e-18
    ciVSS_13 (VSS_112 VSS) capacitor c=4.23028e-18
    ciVSS_12 (VSS_120 VSS) capacitor c=2.86916e-18
    ciVSS_11 (VSS_121 VSS) capacitor c=2.33721e-18
    ciVSS_10 (VSS_124 VSS) capacitor c=4.55049e-18
    ciVSS_9 (MM5_ELT_s VSS) capacitor c=1.112e-18
    ciVSS_8 (VSS_131 VSS) capacitor c=6.39143e-18
    ciVSS_7 (VSS_137 VSS) capacitor c=3.68047e-18
    ciVSS_6 (VSS_142 VSS) capacitor c=6.87668e-18
    ciVSS_5 (VSS_143 VSS) capacitor c=5.01966e-18
    ciVSS_4 (VSS_148 VSS) capacitor c=1.96311e-18
    ciVSS_3 (VSS_150 VSS) capacitor c=4.06582e-18
    ciVSS_2 (VSS_153 VSS) capacitor c=7.77889e-17
    ciVSS_1 (VSS_157 VSS) capacitor c=2.76296e-18
    ciVSS_0 (VSS_161 VSS) capacitor c=7.13294e-18
    cinet11_36 (net11_42 VSS) capacitor c=3.00043e-18
    cinet11_35 (net11_48 VSS) capacitor c=2.42308e-16
    cinet11_34 (net11_59 VSS) capacitor c=7.47661e-16
    cinet11_33 (net11_65 VSS) capacitor c=3.85496e-18
    cinet11_32 (net11_70 VSS) capacitor c=2.2416e-17
    cinet11_31 (net11_78 VSS) capacitor c=1.51948e-17
    cinet11_30 (net11_86 VSS) capacitor c=1.8249e-17
    cinet11_29 (net11_94 VSS) capacitor c=1.26948e-17
    cinet11_28 (net11_102 VSS) capacitor c=3.00043e-18
    cinet11_27 (net11_105 VSS) capacitor c=6.26439e-19
    cinet11_26 (net11_110 VSS) capacitor c=4.23923e-18
    cinet11_25 (net11_113 VSS) capacitor c=2.31953e-18
    cinet11_24 (net11_118 VSS) capacitor c=4.25215e-18
    cinet11_23 (net11_124 VSS) capacitor c=1.783e-16
    cinet11_22 (net11_135 VSS) capacitor c=5.51361e-16
    cinet11_21 (net11_141 VSS) capacitor c=3.60057e-18
    cinet11_20 (net11_146 VSS) capacitor c=2.23758e-17
    cinet11_19 (net11_154 VSS) capacitor c=1.51948e-17
    cinet11_18 (net11_162 VSS) capacitor c=2.06899e-17
    cinet11_17 (net11_170 VSS) capacitor c=1.62958e-17
    cinet11_16 (net11_178 VSS) capacitor c=2.1509e-18
    cinet11_15 (net11_181 VSS) capacitor c=1.75435e-18
    cinet11_14 (net11_186 VSS) capacitor c=7.5024e-18
    cinet11_13 (net11_189 VSS) capacitor c=2.22299e-18
    cinet11_12 (net11_263 VSS) capacitor c=5.68818e-17
    cinet11_11 (net11_264 VSS) capacitor c=1.12693e-16
    cinet11_10 (net11_268 VSS) capacitor c=1.57272e-16
    cinet11_9 (net11_269 VSS) capacitor c=3.2327e-16
    cinet11_8 (net11_278 VSS) capacitor c=4.2557e-18
    cinet11_7 (net11_280 VSS) capacitor c=1.00196e-17
    cinet11_6 (net11_286 VSS) capacitor c=1.27545e-16
    cinet11_5 (net11_287 VSS) capacitor c=1.6106e-17
    cinet11_4 (net11_291 VSS) capacitor c=2.50861e-17
    cinet11_3 (net11_295 VSS) capacitor c=3.33565e-17
    cinet11_2 (net11_297 VSS) capacitor c=1.50338e-17
    cinet11_1 (net11_411 VSS) capacitor c=2.52621e-17
    cinet11_0 (net11_426 VSS) capacitor c=3.27889e-17
    cinet5_40 (net5_42 VSS) capacitor c=6.89598e-18
    cinet5_39 (net5_45 VSS) capacitor c=4.27597e-18
    cinet5_38 (net5_48 VSS) capacitor c=1.70465e-16
    cinet5_37 (net5_50 VSS) capacitor c=2.08995e-17
    cinet5_36 (net5_58 VSS) capacitor c=2.30316e-17
    cinet5_35 (net5_66 VSS) capacitor c=6.31515e-18
    cinet5_34 (net5_69 VSS) capacitor c=4.47573e-18
    cinet5_33 (net5_72 VSS) capacitor c=1.67762e-16
    cinet5_32 (net5_80 VSS) capacitor c=3.15386e-17
    cinet5_31 (net5_88 VSS) capacitor c=1.77129e-17
    cinet5_30 (net5_99 VSS) capacitor c=2.80371e-18
    cinet5_29 (net5_110 VSS) capacitor c=9.33931e-18
    cinet5_28 (net5_118 VSS) capacitor c=4.15066e-18
    cinet5_27 (net5_124 VSS) capacitor c=1.92535e-16
    cinet5_26 (net5_135 VSS) capacitor c=5.84447e-16
    cinet5_25 (net5_141 VSS) capacitor c=4.15066e-18
    cinet5_24 (net5_146 VSS) capacitor c=2.23788e-17
    cinet5_23 (net5_154 VSS) capacitor c=1.51948e-17
    cinet5_22 (net5_162 VSS) capacitor c=2.08252e-17
    cinet5_21 (net5_170 VSS) capacitor c=1.7111e-17
    cinet5_20 (net5_178 VSS) capacitor c=2.9716e-18
    cinet5_19 (net5_181 VSS) capacitor c=5.3401e-18
    cinet5_18 (net5_186 VSS) capacitor c=1.02747e-17
    cinet5_17 (net5_189 VSS) capacitor c=3.85496e-18
    cinet5_16 (net5_261 VSS) capacitor c=1.44447e-16
    cinet5_15 (net5_267 VSS) capacitor c=8.83002e-17
    cinet5_14 (net5_268 VSS) capacitor c=4.3104e-17
    cinet5_13 (net5_269 VSS) capacitor c=1.56581e-17
    cinet5_12 (net5_272 VSS) capacitor c=3.9554e-17
    cinet5_11 (net5_273 VSS) capacitor c=1.12739e-16
    cinet5_10 (net5_277 VSS) capacitor c=1.46218e-16
    cinet5_9 (net5_278 VSS) capacitor c=1.2541e-16
    cinet5_8 (net5_281 VSS) capacitor c=2.17047e-17
    cinet5_7 (net5_283 VSS) capacitor c=1.45011e-17
    cinet5_6 (net5_286 VSS) capacitor c=5.04795e-17
    cinet5_5 (net5_291 VSS) capacitor c=2.76792e-17
    cinet5_4 (net5_294 VSS) capacitor c=2.00579e-17
    cinet5_3 (net5_296 VSS) capacitor c=1.57456e-17
    cinet5_2 (net5_415 VSS) capacitor c=1.422e-17
    cinet5_1 (net5_416 VSS) capacitor c=1.60993e-17
    cinet5_0 (net5_428 VSS) capacitor c=5.14318e-17
    cinet25_7 (net25_3 VSS) capacitor c=4.43967e-17
    cinet25_6 (net25_4 VSS) capacitor c=1.09459e-16
    cinet25_5 (net25_6 VSS) capacitor c=2.84881e-17
    cinet25_4 (net25_7 VSS) capacitor c=1.33164e-17
    cinet25_3 (net25_9 VSS) capacitor c=7.48619e-17
    cinet25_2 (net25_12 VSS) capacitor c=5.39838e-17
    cinet25_1 (net25_13 VSS) capacitor c=1.12958e-16
    cinet25_0 (net25_17 VSS) capacitor c=2.20156e-17
    cinet20_6 (net20_3 VSS) capacitor c=1.68784e-17
    cinet20_5 (net20_4 VSS) capacitor c=1.19099e-16
    cinet20_4 (net20_8 VSS) capacitor c=7.55219e-17
    cinet20_3 (net20_12 VSS) capacitor c=1.65663e-17
    cinet20_2 (net20_13 VSS) capacitor c=1.20843e-16
    cinet20_1 (net20_17 VSS) capacitor c=2.6936e-17
    cinet20_0 (net20_18 VSS) capacitor c=2.12361e-17
    ciCDN_25 (CDN_34 VSS) capacitor c=3.98759e-18
    ciCDN_24 (CDN_37 VSS) capacitor c=2.81125e-18
    ciCDN_23 (CDN_40 VSS) capacitor c=1.95592e-16
    ciCDN_22 (CDN_42 VSS) capacitor c=2.23316e-17
    ciCDN_21 (CDN_50 VSS) capacitor c=1.57811e-17
    ciCDN_20 (CDN_58 VSS) capacitor c=3.00043e-18
    ciCDN_19 (CDN_72 VSS) capacitor c=2.96645e-18
    ciCDN_18 (CDN_78 VSS) capacitor c=1.90269e-16
    ciCDN_17 (CDN_86 VSS) capacitor c=2.23697e-17
    ciCDN_16 (CDN_94 VSS) capacitor c=2.26195e-17
    ciCDN_15 (CDN_102 VSS) capacitor c=4.18692e-18
    ciCDN_14 (CDN_105 VSS) capacitor c=4.19476e-18
    ciCDN_13 (CDN_108 VSS) capacitor c=3.68568e-16
    ciCDN_12 (CDN_110 VSS) capacitor c=3.35294e-18
    ciCDN_11 (CDN_113 VSS) capacitor c=1.55908e-18
    ciCDN_10 (CDN_118 VSS) capacitor c=1.63704e-17
    ciCDN_9 (CDN_126 VSS) capacitor c=2.2416e-17
    ciCDN_8 (CDN_140 VSS) capacitor c=1.55679e-17
    ciCDN_7 (CDN_148 VSS) capacitor c=4.57276e-18
    ciCDN_6 (CDN_151 VSS) capacitor c=3.85496e-18
    ciCDN_5 (CDN VSS) capacitor c=6.45302e-17
    ciCDN_4 (CDN_265 VSS) capacitor c=2.01853e-17
    ciCDN_3 (CDN_279 VSS) capacitor c=4.66839e-17
    ciCDN_2 (CDN_310 VSS) capacitor c=1.91321e-17
    ciCDN_1 (CDN_311 VSS) capacitor c=4.02528e-18
    ciCDN_0 (CDN_314 VSS) capacitor c=6.67042e-18
    ciD_17 (D_22 VSS) capacitor c=5.05393e-18
    ciD_16 (D_25 VSS) capacitor c=3.25905e-18
    ciD_15 (D_28 VSS) capacitor c=2.15451e-16
    ciD_14 (D_30 VSS) capacitor c=2.59479e-17
    ciD_13 (D_38 VSS) capacitor c=2.23851e-17
    ciD_12 (D_55 VSS) capacitor c=4.11003e-18
    ciD_11 (D_60 VSS) capacitor c=5.62988e-18
    ciD_10 (D_66 VSS) capacitor c=1.76671e-16
    ciD_9 (D_74 VSS) capacitor c=2.23351e-17
    ciD_8 (D_82 VSS) capacitor c=2.46693e-17
    ciD_7 (D_90 VSS) capacitor c=3.98759e-18
    ciD_6 (D_93 VSS) capacitor c=6.94225e-18
    ciD_5 (D VSS) capacitor c=8.32953e-17
    ciD_4 (D_174 VSS) capacitor c=3.14753e-17
    ciD_3 (D_175 VSS) capacitor c=2.10073e-17
    ciD_2 (D_183 VSS) capacitor c=1.24865e-16
    ciD_1 (D_201 VSS) capacitor c=3.2397e-17
    ciD_0 (D_202 VSS) capacitor c=2.25462e-17
    cinet49_6 (net49_3 VSS) capacitor c=7.44723e-17
    cinet49_5 (net49_4 VSS) capacitor c=1.24817e-16
    cinet49_4 (net49_8 VSS) capacitor c=6.67236e-17
    cinet49_3 (net49_9 VSS) capacitor c=1.2637e-16
    cinet49_2 (net49_12 VSS) capacitor c=5.08291e-17
    cinet49_1 (net49_15 VSS) capacitor c=1.83108e-17
    cinet49_0 (net49_19 VSS) capacitor c=2.0289e-17
    cinet67_47 (net67_22 VSS) capacitor c=3.00043e-18
    cinet67_46 (net67_28 VSS) capacitor c=2.06954e-16
    cinet67_45 (net67_39 VSS) capacitor c=3.51822e-16
    cinet67_44 (net67_45 VSS) capacitor c=3.85496e-18
    cinet67_43 (net67_50 VSS) capacitor c=2.23559e-17
    cinet67_42 (net67_58 VSS) capacitor c=2.2416e-17
    cinet67_41 (net67_66 VSS) capacitor c=1.99182e-17
    cinet67_40 (net67_74 VSS) capacitor c=2.07696e-17
    cinet67_39 (net67_82 VSS) capacitor c=4.04637e-18
    cinet67_38 (net67_85 VSS) capacitor c=6.27322e-18
    cinet67_37 (net67_90 VSS) capacitor c=2e-18
    cinet67_36 (net67_93 VSS) capacitor c=4.15066e-18
    cinet67_35 (net67_133 VSS) capacitor c=9.15105e-17
    cinet67_34 (net67_134 VSS) capacitor c=1.57558e-17
    cinet67_33 (net67_136 VSS) capacitor c=4.46242e-17
    cinet67_32 (net67_137 VSS) capacitor c=4.07318e-17
    cinet67_31 (net67_138 VSS) capacitor c=1.36216e-17
    cinet67_30 (net67_141 VSS) capacitor c=4.12757e-17
    cinet67_29 (net67_142 VSS) capacitor c=1.1901e-16
    cinet67_28 (net67_144 VSS) capacitor c=4.51374e-17
    cinet67_27 (net67_145 VSS) capacitor c=1.26665e-17
    cinet67_26 (net67_148 VSS) capacitor c=3.24745e-17
    cinet67_25 (net67_149 VSS) capacitor c=1.07086e-16
    cinet67_24 (net67_151 VSS) capacitor c=7.95579e-18
    cinet67_23 (net67_154 VSS) capacitor c=3.29296e-17
    cinet67_22 (net67_155 VSS) capacitor c=1.13847e-16
    cinet67_21 (net67_157 VSS) capacitor c=1.21091e-16
    cinet67_20 (net67_160 VSS) capacitor c=1.33994e-16
    cinet67_19 (net67_161 VSS) capacitor c=2.59231e-17
    cinet67_18 (net67_163 VSS) capacitor c=9.11204e-17
    cinet67_17 (net67_168 VSS) capacitor c=5.98196e-17
    cinet67_16 (net67_169 VSS) capacitor c=1.5298e-16
    cinet67_15 (net67_172 VSS) capacitor c=2.5077e-17
    cinet67_14 (net67_174 VSS) capacitor c=4.06316e-17
    cinet67_13 (net67_177 VSS) capacitor c=8.49293e-18
    cinet67_12 (net67_178 VSS) capacitor c=5.24848e-18
    cinet67_11 (net67_179 VSS) capacitor c=6.81209e-18
    cinet67_10 (net67_182 VSS) capacitor c=1.19868e-16
    cinet67_9 (net67_187 VSS) capacitor c=2.82302e-17
    cinet67_8 (net67_192 VSS) capacitor c=1.94667e-17
    cinet67_7 (net67_250 VSS) capacitor c=3.18439e-17
    cinet67_6 (net67_251 VSS) capacitor c=1.70312e-17
    cinet67_5 (net67_261 VSS) capacitor c=1.71175e-18
    cinet67_4 (net67_263 VSS) capacitor c=8.43559e-18
    cinet67_3 (net67_266 VSS) capacitor c=3.97088e-18
    cinet67_2 (net67_267 VSS) capacitor c=1.55537e-16
    cinet67_1 (net67_271 VSS) capacitor c=1.06436e-16
    cinet67_0 (net67_272 VSS) capacitor c=7.96958e-17
    ciENN_30 (ENN_22 VSS) capacitor c=5.91538e-18
    ciENN_29 (ENN_28 VSS) capacitor c=1.69846e-16
    ciENN_28 (ENN_36 VSS) capacitor c=2.47942e-17
    ciENN_27 (ENN_44 VSS) capacitor c=1.8502e-17
    ciENN_26 (ENN_52 VSS) capacitor c=6.51671e-18
    ciENN_25 (ENN_55 VSS) capacitor c=5.2401e-18
    ciENN_24 (ENN_60 VSS) capacitor c=2e-18
    ciENN_23 (ENN_63 VSS) capacitor c=4.15066e-18
    ciENN_22 (ENN_66 VSS) capacitor c=1.64728e-16
    ciENN_21 (ENN_68 VSS) capacitor c=1.99757e-17
    ciENN_20 (ENN_76 VSS) capacitor c=2.2416e-17
    ciENN_19 (ENN_93 VSS) capacitor c=5.86975e-18
    ciENN_18 (ENN_133 VSS) capacitor c=5.3829e-17
    ciENN_17 (ENN_134 VSS) capacitor c=1.12678e-16
    ciENN_16 (ENN_138 VSS) capacitor c=1.95226e-16
    ciENN_15 (ENN_139 VSS) capacitor c=3.35581e-16
    ciENN_14 (ENN_147 VSS) capacitor c=3.27496e-17
    ciENN_13 (ENN_148 VSS) capacitor c=1.71093e-17
    ciENN_12 (ENN_149 VSS) capacitor c=3.14889e-17
    ciENN_11 (ENN_150 VSS) capacitor c=1.83968e-17
    ciENN_10 (ENN_152 VSS) capacitor c=2.37749e-17
    ciENN_9 (ENN_155 VSS) capacitor c=5.14437e-17
    ciENN_8 (ENN_160 VSS) capacitor c=1.85321e-17
    ciENN_7 (ENN_163 VSS) capacitor c=1.47025e-16
    ciENN_6 (ENN_164 VSS) capacitor c=7.50508e-18
    ciENN_5 (ENN_166 VSS) capacitor c=1.50933e-17
    ciENN_4 (ENN_168 VSS) capacitor c=1.07663e-16
    ciENN_3 (ENN_169 VSS) capacitor c=1.01192e-16
    ciENN_2 (ENN_229 VSS) capacitor c=4.60146e-17
    ciENN_1 (ENN_234 VSS) capacitor c=2.56178e-17
    ciENN_0 (ENN_235 VSS) capacitor c=2.9223e-17
    ciEN_55 (EN_42 VSS) capacitor c=3.65279e-18
    ciEN_54 (EN_48 VSS) capacitor c=1.98308e-16
    ciEN_53 (EN_59 VSS) capacitor c=6.10342e-16
    ciEN_52 (EN_65 VSS) capacitor c=3.83402e-18
    ciEN_51 (EN_70 VSS) capacitor c=2.28658e-17
    ciEN_50 (EN_78 VSS) capacitor c=2.15312e-17
    ciEN_49 (EN_86 VSS) capacitor c=1.20384e-17
    ciEN_48 (EN_94 VSS) capacitor c=1.51914e-17
    ciEN_47 (EN_102 VSS) capacitor c=4.17058e-18
    ciEN_46 (EN_105 VSS) capacitor c=6.84204e-18
    ciEN_45 (EN_110 VSS) capacitor c=6.81726e-18
    ciEN_44 (EN_113 VSS) capacitor c=3.81698e-18
    ciEN_43 (EN_118 VSS) capacitor c=2.94403e-17
    ciEN_42 (EN_124 VSS) capacitor c=2.47379e-16
    ciEN_41 (EN_132 VSS) capacitor c=2.76116e-17
    ciEN_40 (EN_140 VSS) capacitor c=2.33696e-17
    ciEN_39 (EN_148 VSS) capacitor c=1.12527e-17
    ciEN_38 (EN_151 VSS) capacitor c=7.60354e-18
    ciEN_37 (EN_159 VSS) capacitor c=1.54527e-16
    ciEN_36 (EN_165 VSS) capacitor c=5.55839e-18
    ciEN_35 (EN_170 VSS) capacitor c=1.57439e-17
    ciEN_34 (EN_178 VSS) capacitor c=2.93189e-17
    ciEN_33 (EN_186 VSS) capacitor c=4.57751e-18
    ciEN_32 (EN_189 VSS) capacitor c=5.30821e-18
    ciEN_31 (EN_263 VSS) capacitor c=5.28823e-17
    ciEN_30 (EN_264 VSS) capacitor c=1.11566e-16
    ciEN_29 (EN_268 VSS) capacitor c=1.7344e-16
    ciEN_28 (EN_269 VSS) capacitor c=3.29385e-16
    ciEN_27 (EN_277 VSS) capacitor c=4.76651e-17
    ciEN_26 (EN_278 VSS) capacitor c=1.44503e-17
    ciEN_25 (EN_279 VSS) capacitor c=4.09362e-17
    ciEN_24 (EN_280 VSS) capacitor c=1.26431e-17
    ciEN_23 (EN_282 VSS) capacitor c=9.85829e-18
    ciEN_22 (EN_285 VSS) capacitor c=4.37001e-17
    ciEN_21 (EN_288 VSS) capacitor c=1.34012e-17
    ciEN_20 (EN_290 VSS) capacitor c=3.59791e-17
    ciEN_19 (EN_293 VSS) capacitor c=7.73688e-17
    ciEN_18 (EN_294 VSS) capacitor c=1.474e-17
    ciEN_17 (EN_296 VSS) capacitor c=2.52931e-17
    ciEN_16 (EN_301 VSS) capacitor c=1.58842e-17
    ciEN_15 (EN_305 VSS) capacitor c=2.16207e-17
    ciEN_14 (EN_310 VSS) capacitor c=1.29257e-16
    ciEN_13 (EN_311 VSS) capacitor c=4.56946e-18
    ciEN_12 (EN_312 VSS) capacitor c=9.26711e-17
    ciEN_11 (EN_313 VSS) capacitor c=1.15594e-17
    ciEN_10 (EN_314 VSS) capacitor c=2.34522e-17
    ciEN_9 (EN_315 VSS) capacitor c=6.84749e-18
    ciEN_8 (EN_318 VSS) capacitor c=1.74248e-17
    ciEN_7 (EN_319 VSS) capacitor c=7.97916e-17
    ciEN_6 (EN_325 VSS) capacitor c=2.41722e-17
    ciEN_5 (EN_327 VSS) capacitor c=3.33216e-17
    ciEN_4 (EN_328 VSS) capacitor c=1.08649e-16
    ciEN_3 (EN_449 VSS) capacitor c=5.89137e-17
    ciEN_2 (EN_452 VSS) capacitor c=2.35535e-17
    ciEN_1 (EN_453 VSS) capacitor c=3.04019e-17
    ciEN_0 (EN_464 VSS) capacitor c=4.22912e-17
    ciE_13 (E_22 VSS) capacitor c=2.22299e-18
    ciE_12 (E_28 VSS) capacitor c=1.77638e-16
    ciE_11 (E_39 VSS) capacitor c=5.58555e-16
    ciE_10 (E_45 VSS) capacitor c=2.22299e-18
    ciE_9 (E_50 VSS) capacitor c=2.23697e-17
    ciE_8 (E_58 VSS) capacitor c=2.25728e-17
    ciE_7 (E_66 VSS) capacitor c=1.36936e-17
    ciE_6 (E_74 VSS) capacitor c=1.51948e-17
    ciE_5 (E_82 VSS) capacitor c=4.2013e-18
    ciE_4 (E_85 VSS) capacitor c=8.18924e-18
    ciE_3 (E_90 VSS) capacitor c=5.03111e-18
    ciE_2 (E_93 VSS) capacitor c=5.13601e-18
    ciE_1 (E VSS) capacitor c=5.55221e-17
    ciE_0 (E_201 VSS) capacitor c=3.21202e-17
    rnet29_32 (MM11_ELT_s net29_2) resistor r=18.0507
    rnet29_31 (MM11_ELT_s net29_5) resistor r=15.1041
    rnet29_30 (MM11_ELT_s net29_5) resistor r=2.67027
    rnet29_29 (MM11_ELT_s net29_7) resistor r=12.8495
    rnet29_28 (MM11_ELT_s net29_7) resistor r=1.69926
    rnet29_27 (MM11_ELT_s net29_11) resistor r=4.22001
    rnet29_26 (MM11_ELT_s net29) resistor r=10.6787
    rnet29_25 (net29_2 net29_4) resistor r=9.43134
    rnet29_24 (net29_4 net29_5) resistor r=15.1041
    rnet29_23 (net29_6 net29_7) resistor r=12.8495
    rnet29_22 (net29_6 net29_18) resistor r=10.6787
    rnet29_21 (net29_8 net29_11) resistor r=4.22001
    rnet29_20 (net29_8 net29_18) resistor r=0.57282
    rnet29_19 (net29_9 net29_11) resistor r=4.22001
    rnet29_18 (net29_9 net29) resistor r=0.57282
    rnet29_17 (MM12_ELT_d net29_11) resistor r=4.22001
    rnet29_16 (MM12_ELT_d net29_14) resistor r=15.1041
    rnet29_15 (MM12_ELT_d net29_14) resistor r=2.67027
    rnet29_14 (MM12_ELT_d net29_16) resistor r=12.1643
    rnet29_13 (MM12_ELT_d net29_16) resistor r=1.36649
    rnet29_12 (MM12_ELT_d net29_17) resistor r=18.0507
    rnet29_11 (MM12_ELT_d net29_18) resistor r=10.6787
    rnet29_10 (net29_12 net29_14) resistor r=15.1041
    rnet29_9 (net29_12 net29_17) resistor r=9.43134
    rnet29_8 (net29_15 net29_16) resistor r=12.1643
    rnet29_7 (net29_15 net29) resistor r=10.6787
    rnet17_37 (MM16_ELT_s net17_2) resistor r=18.0507
    rnet17_36 (MM16_ELT_s net17_5) resistor r=2.67027
    rnet17_35 (MM16_ELT_s net17_7) resistor r=12.8495
    rnet17_34 (MM16_ELT_s net17_7) resistor r=1.69926
    rnet17_33 (MM16_ELT_s net17_11) resistor r=4.22001
    rnet17_32 (net17_2 net17_4) resistor r=9.43134
    rnet17_31 (net17_3 net17_5) resistor r=15.1041
    rnet17_30 (net17_3 net17_20) resistor r=11.0157
    rnet17_29 (net17_4 net17_5) resistor r=15.1041
    rnet17_28 (net17_6 net17_7) resistor r=12.8495
    rnet17_27 (net17_6 net17) resistor r=10.6787
    rnet17_26 (net17_8 net17_11) resistor r=4.22001
    rnet17_25 (net17_8 net17_20) resistor r=0.762262
    rnet17_24 (net17_9 net17_11) resistor r=4.22001
    rnet17_23 (net17_9 net17) resistor r=0.57282
    rnet17_22 (MM17_ELT_d net17_11) resistor r=4.22001
    rnet17_21 (MM17_ELT_d net17_14) resistor r=2.67027
    rnet17_20 (MM17_ELT_d net17_16) resistor r=12.8495
    rnet17_19 (MM17_ELT_d net17_16) resistor r=1.69926
    rnet17_18 (MM17_ELT_d net17_19) resistor r=4.557
    rnet17_17 (MM17_ELT_d net17) resistor r=10.6787
    rnet17_16 (net17_12 net17_14) resistor r=15.1041
    rnet17_15 (net17_12 net17_17) resistor r=9.43134
    rnet17_14 (net17_13 net17_14) resistor r=15.1041
    rnet17_13 (net17_13 net17_20) resistor r=11.0157
    rnet17_12 (net17_15 net17_16) resistor r=12.8495
    rnet17_11 (net17_15 net17_18) resistor r=9.4369
    rnet17_10 (net17_17 net17_19) resistor r=21.1301
    rnet17_9 (net17_18 net17_19) resistor r=21.1301
    rnet72_36 (net72_1 net72_4) resistor r=20.2547
    rnet72_35 (net72_1 net72_5) resistor r=9.04595
    rnet72_34 (net72_2 net72_4) resistor r=20.2547
    rnet72_33 (net72_2 net72_8) resistor r=9.04062
    rnet72_32 (MM10_ELT_s net72_4) resistor r=4.36821
    rnet72_31 (MM10_ELT_s net72_6) resistor r=12.3172
    rnet72_30 (MM10_ELT_s net72_6) resistor r=1.62887
    rnet72_29 (MM10_ELT_s net72_9) resistor r=2.55965
    rnet72_28 (MM10_ELT_s net72_13) resistor r=4.04518
    rnet72_27 (MM10_ELT_s net72_20) resistor r=10.2363
    rnet72_26 (net72_5 net72_6) resistor r=12.3172
    rnet72_25 (net72_7 net72_9) resistor r=14.4784
    rnet72_24 (net72_7 net72) resistor r=10.5593
    rnet72_23 (net72_8 net72_9) resistor r=14.4784
    rnet72_22 (net72_10 net72_13) resistor r=4.04518
    rnet72_21 (net72_10 net72_20) resistor r=0.549089
    rnet72_20 (net72_11 net72_13) resistor r=4.04518
    rnet72_19 (net72_11 net72) resistor r=0.730683
    rnet72_18 (MM9_ELT_d net72_13) resistor r=4.04518
    rnet72_17 (MM9_ELT_d net72_15) resistor r=11.6604
    rnet72_16 (MM9_ELT_d net72_15) resistor r=1.30988
    rnet72_15 (MM9_ELT_d net72_18) resistor r=2.55965
    rnet72_14 (MM9_ELT_d net72_19) resistor r=17.3029
    rnet72_13 (net72_14 net72_15) resistor r=11.6604
    rnet72_12 (net72_14 net72_20) resistor r=10.2363
    rnet72_11 (net72_16 net72_18) resistor r=14.4784
    rnet72_10 (net72_16 net72_19) resistor r=9.04062
    rnet72_9 (net72_17 net72_18) resistor r=14.4784
    rnet72_8 (net72_17 net72) resistor r=10.5593
    rQ_52 (Q_1 Q_3) resistor r=0.473837
    rQ_51 (Q_1 Q_18) resistor r=0.0960733
    rQ_50 (Q_3 Q_4) resistor r=13
    rQ_49 (Q_4 MM30_ELT_d) resistor r=8.44
    rQ_48 (Q_6 Q_8) resistor r=0.485537
    rQ_47 (Q_6 Q_20) resistor r=0.0960733
    rQ_46 (Q_8 Q_9) resistor r=8.66667
    rQ_45 (Q_8 Q_11) resistor r=0.701981
    rQ_44 (Q_9 MM42_ELT_d) resistor r=32.3614
    rQ_43 (Q_11 Q_12) resistor r=8.66667
    rQ_42 (Q_11 Q_14) resistor r=0.467987
    rQ_41 (Q_12 MM42_ELT_d) resistor r=16.1807
    rQ_40 (Q_12 Q_15) resistor r=32.3614
    rQ_39 (Q_14 Q_15) resistor r=26
    rQ_38 (Q_17 Q_18) resistor r=0.669039
    rQ_37 (Q_17 Q_41) resistor r=0.0556646
    rQ_36 (Q_19 Q_20) resistor r=0.540343
    rQ_35 (Q_19 Q_44) resistor r=0.0466378
    rQ_34 (Q_21 Q_23) resistor r=0.431587
    rQ_33 (Q_21 Q_41) resistor r=0.0100984
    rQ_32 (Q_23 Q_24) resistor r=13
    rQ_31 (Q_24 MM3_ELT_d) resistor r=8.44
    rQ_30 (Q_26 Q_28) resistor r=0.442243
    rQ_29 (Q_26 Q_44) resistor r=0.0100984
    rQ_28 (Q_28 Q_29) resistor r=8.66667
    rQ_27 (Q_28 Q_31) resistor r=0.639388
    rQ_26 (Q_29 MM2_ELT_d) resistor r=32.3614
    rQ_25 (Q_31 Q_32) resistor r=8.66667
    rQ_24 (Q_31 Q_34) resistor r=0.426259
    rQ_23 (Q_32 MM2_ELT_d) resistor r=16.1807
    rQ_22 (Q_32 Q_35) resistor r=32.3614
    rQ_21 (Q_34 Q_35) resistor r=26
    rQ_20 (Q_37 Q) resistor r=0.087818
    rQ_19 (Q_37 Q_42) resistor r=0.0100984
    rQ_18 (Q_38 Q) resistor r=0.433952
    rQ_17 (Q_38 Q_45) resistor r=0.0100984
    rQ_16 (Q_41 Q_42) resistor r=0.185549
    rQ_15 (Q_44 Q_45) resistor r=0.155459
    rVDD_270 (MM28_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_269 (MM15_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_268 (MM14_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_267 (MM10_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_266 (MM9_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_265 (MM8_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_264 (MM6_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_263 (MM4_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_262 (MM42_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_261 (MM2_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_260 (MM1_ELT_b VDD_49) resistor r=8.66667
    rVDD_259 (MM1_ELT_b VDD_59) resistor r=8.66667
    rVDD_258 (MM1_ELT_b VDD_62) resistor r=8.66667
    rVDD_257 (MM1_ELT_b VDD_78) resistor r=8.66667
    rVDD_256 (MM1_ELT_b VDD_93) resistor r=8.66667
    rVDD_255 (MM1_ELT_b VDD_96) resistor r=26
    rVDD_254 (MM1_ELT_b VDD_40) resistor r=45.0133
    rVDD_253 (VDD_2 VDD_7) resistor r=0.114631
    rVDD_252 (VDD_2 VDD_99) resistor r=0.0221539
    rVDD_251 (VDD VDD_7) resistor r=0.102772
    rVDD_250 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_249 (VDD_8 VDD_24) resistor r=67.52
    rVDD_248 (VDD_9 VDD_18) resistor r=0.538185
    rVDD_247 (VDD_9 VDD_99) resistor r=0.0882174
    rVDD_246 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_245 (VDD_11 VDD_15) resistor r=0.701981
    rVDD_244 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_243 (VDD_15 VDD_18) resistor r=0.467987
    rVDD_242 (VDD_18 VDD_19) resistor r=13
    rVDD_241 (VDD_19 MM28_ELT_s) resistor r=4.04518
    rVDD_240 (VDD_19 VDD_177) resistor r=4.04518
    rVDD_239 (VDD_19 MM1_ELT_s) resistor r=4.04518
    rVDD_238 (VDD_19 VDD_175) resistor r=4.04518
    rVDD_237 (VDD_20 VDD_23) resistor r=0.167993
    rVDD_236 (VDD_20 VDD_100) resistor r=0.0221539
    rVDD_235 (VDD_21 VDD_23) resistor r=0.0869613
    rVDD_234 (VDD_21 VDD_99) resistor r=0.0221539
    rVDD_233 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_232 (VDD_24 VDD_34) resistor r=67.52
    rVDD_231 (VDD_25 VDD_27) resistor r=0.51151
    rVDD_230 (VDD_25 VDD_100) resistor r=0.0882174
    rVDD_229 (VDD_27 VDD_28) resistor r=8.66667
    rVDD_228 (VDD_28 VDD_180) resistor r=16.4995
    rVDD_227 (VDD_28 VDD_179) resistor r=16.4995
    rVDD_226 (VDD_28 MM14_ELT_s) resistor r=3.29107
    rVDD_225 (VDD_30 VDD_39) resistor r=0.0335987
    rVDD_224 (VDD_30 VDD_101) resistor r=0.0221539
    rVDD_223 (VDD_31 VDD_33) resistor r=0.0335987
    rVDD_222 (VDD_31 VDD_100) resistor r=0.0221539
    rVDD_221 (VDD_33 VDD_34) resistor r=8.66667
    rVDD_220 (VDD_33 VDD_36) resistor r=0.237167
    rVDD_219 (VDD_34 VDD_37) resistor r=67.52
    rVDD_218 (VDD_36 VDD_37) resistor r=8.66667
    rVDD_217 (VDD_36 VDD_39) resistor r=0.237167
    rVDD_216 (VDD_37 VDD_40) resistor r=67.52
    rVDD_215 (VDD_39 VDD_40) resistor r=8.66667
    rVDD_214 (VDD_41 VDD_43) resistor r=0.565938
    rVDD_213 (VDD_41 VDD_101) resistor r=0.0882174
    rVDD_212 (VDD_43 VDD_44) resistor r=13
    rVDD_211 (VDD_44 MM9_ELT_s) resistor r=8.09035
    rVDD_210 (VDD_46 VDD_49) resistor r=0.167993
    rVDD_209 (VDD_46 VDD_102) resistor r=0.0221539
    rVDD_208 (VDD_47 VDD_49) resistor r=0.167993
    rVDD_207 (VDD_47 VDD_101) resistor r=0.0221539
    rVDD_206 (VDD_51 VDD_53) resistor r=0.538185
    rVDD_205 (VDD_51 VDD_102) resistor r=0.0882174
    rVDD_204 (VDD_53 VDD_54) resistor r=8.66667
    rVDD_203 (VDD_54 MM6_ELT_s) resistor r=4.04518
    rVDD_202 (VDD_54 VDD_183) resistor r=4.04518
    rVDD_201 (VDD_54 MM8_ELT_s) resistor r=4.04518
    rVDD_200 (VDD_54 VDD_181) resistor r=4.04518
    rVDD_199 (VDD_56 VDD_62) resistor r=0.167993
    rVDD_198 (VDD_56 VDD_103) resistor r=0.0221539
    rVDD_197 (VDD_57 VDD_59) resistor r=0.0335987
    rVDD_196 (VDD_57 VDD_102) resistor r=0.0221539
    rVDD_195 (VDD_59 VDD_62) resistor r=0.237167
    rVDD_194 (VDD_64 VDD_73) resistor r=0.538185
    rVDD_193 (VDD_64 VDD_103) resistor r=0.0882174
    rVDD_192 (VDD_66 VDD_74) resistor r=8.66667
    rVDD_191 (VDD_66 VDD_70) resistor r=0.701981
    rVDD_190 (VDD_70 VDD_74) resistor r=8.66667
    rVDD_189 (VDD_70 VDD_73) resistor r=0.467987
    rVDD_188 (VDD_73 VDD_74) resistor r=13
    rVDD_187 (VDD_74 MM42_ELT_s) resistor r=4.04518
    rVDD_186 (VDD_74 VDD_188) resistor r=4.04518
    rVDD_185 (VDD_74 MM4_ELT_s) resistor r=4.04518
    rVDD_184 (VDD_74 VDD_186) resistor r=4.04518
    rVDD_183 (VDD_75 VDD_78) resistor r=0.136371
    rVDD_182 (VDD_75 VDD_104) resistor r=0.0221539
    rVDD_181 (VDD_76 VDD_78) resistor r=0.0335987
    rVDD_180 (VDD_76 VDD_103) resistor r=0.0221539
    rVDD_179 (VDD_80 VDD_89) resistor r=0.538185
    rVDD_178 (VDD_80 VDD_104) resistor r=0.0882174
    rVDD_177 (VDD_82 VDD_90) resistor r=8.66667
    rVDD_176 (VDD_82 VDD_86) resistor r=0.701981
    rVDD_175 (VDD_86 VDD_90) resistor r=8.66667
    rVDD_174 (VDD_86 VDD_89) resistor r=0.467987
    rVDD_173 (VDD_89 VDD_90) resistor r=13
    rVDD_172 (VDD_90 MM2_ELT_s) resistor r=4.04518
    rVDD_171 (VDD_90 VDD_192) resistor r=4.04518
    rVDD_170 (VDD_90 MM42_ELT_s) resistor r=4.04518
    rVDD_169 (VDD_90 VDD_190) resistor r=4.04518
    rVDD_168 (VDD_91 VDD_93) resistor r=0.065221
    rVDD_167 (VDD_91 VDD_104) resistor r=0.0221539
    rVDD_166 (VDD_93 VDD_96) resistor r=0.158111
    rVDD_165 (MM1_ELT_s VDD_108) resistor r=25.7298
    rVDD_164 (MM1_ELT_s VDD_111) resistor r=2.55965
    rVDD_163 (MM1_ELT_s VDD_113) resistor r=12.3172
    rVDD_162 (MM1_ELT_s VDD_113) resistor r=1.62887
    rVDD_161 (VDD_108 VDD_110) resistor r=9.04062
    rVDD_160 (VDD_109 VDD_111) resistor r=14.4784
    rVDD_159 (VDD_109 VDD_178) resistor r=10.5593
    rVDD_158 (VDD_110 VDD_111) resistor r=14.4784
    rVDD_157 (VDD_112 VDD_113) resistor r=12.3172
    rVDD_156 (VDD_112 VDD_176) resistor r=10.2363
    rVDD_155 (MM28_ELT_s VDD_117) resistor r=2.55965
    rVDD_154 (MM28_ELT_s VDD_119) resistor r=12.3172
    rVDD_153 (MM28_ELT_s VDD_119) resistor r=1.62887
    rVDD_152 (MM28_ELT_s VDD_122) resistor r=6.12113
    rVDD_151 (MM28_ELT_s VDD_176) resistor r=10.2363
    rVDD_150 (VDD_115 VDD_117) resistor r=14.4784
    rVDD_149 (VDD_115 VDD_121) resistor r=9.04062
    rVDD_148 (VDD_116 VDD_117) resistor r=14.4784
    rVDD_147 (VDD_116 VDD_178) resistor r=10.5593
    rVDD_146 (VDD_118 VDD_119) resistor r=12.3172
    rVDD_145 (VDD_118 VDD_120) resistor r=9.04595
    rVDD_144 (VDD_120 VDD_122) resistor r=31.2341
    rVDD_143 (VDD_121 VDD_122) resistor r=31.2341
    rVDD_142 (MM14_ELT_s VDD_125) resistor r=12.3172
    rVDD_141 (MM14_ELT_s VDD_125) resistor r=1.62887
    rVDD_140 (MM14_ELT_s VDD_128) resistor r=2.55965
    rVDD_139 (MM14_ELT_s VDD_129) resistor r=17.3029
    rVDD_138 (VDD_124 VDD_125) resistor r=12.3172
    rVDD_137 (VDD_124 VDD_179) resistor r=9.39461
    rVDD_136 (VDD_126 VDD_128) resistor r=14.4784
    rVDD_135 (VDD_126 VDD_129) resistor r=9.04062
    rVDD_134 (VDD_127 VDD_128) resistor r=14.4784
    rVDD_133 (VDD_127 VDD_180) resistor r=9.48555
    rVDD_132 (VDD_130 VDD_133) resistor r=20.2547
    rVDD_131 (VDD_130 VDD_134) resistor r=9.04595
    rVDD_130 (VDD_131 VDD_133) resistor r=20.2547
    rVDD_129 (VDD_131 VDD_137) resistor r=9.04062
    rVDD_128 (MM8_ELT_s VDD_133) resistor r=4.36821
    rVDD_127 (MM8_ELT_s VDD_135) resistor r=7.31976
    rVDD_126 (MM8_ELT_s VDD_135) resistor r=1.40052
    rVDD_125 (MM8_ELT_s VDD_138) resistor r=2.55965
    rVDD_124 (MM8_ELT_s VDD_140) resistor r=7.31976
    rVDD_123 (MM8_ELT_s VDD_140) resistor r=1.40052
    rVDD_122 (VDD_134 VDD_135) resistor r=7.31976
    rVDD_121 (VDD_136 VDD_138) resistor r=14.4784
    rVDD_120 (VDD_136 VDD_184) resistor r=10.5593
    rVDD_119 (VDD_137 VDD_138) resistor r=14.4784
    rVDD_118 (VDD_139 VDD_140) resistor r=7.31976
    rVDD_117 (VDD_139 VDD_182) resistor r=10.2363
    rVDD_116 (MM6_ELT_s VDD_144) resistor r=2.55965
    rVDD_115 (MM6_ELT_s VDD_146) resistor r=11.6604
    rVDD_114 (MM6_ELT_s VDD_146) resistor r=1.30988
    rVDD_113 (MM6_ELT_s VDD_151) resistor r=4.36821
    rVDD_112 (MM6_ELT_s VDD_182) resistor r=10.2363
    rVDD_111 (VDD_142 VDD_144) resistor r=14.4784
    rVDD_110 (VDD_142 VDD_150) resistor r=9.04062
    rVDD_109 (VDD_143 VDD_144) resistor r=14.4784
    rVDD_108 (VDD_143 VDD_184) resistor r=10.5593
    rVDD_107 (VDD_145 VDD_146) resistor r=11.6604
    rVDD_106 (VDD_145 VDD_149) resistor r=9.04595
    rVDD_105 (MM4_ELT_s VDD_148) resistor r=9.18184
    rVDD_104 (MM4_ELT_s VDD_154) resistor r=5.25806
    rVDD_103 (MM4_ELT_s VDD_157) resistor r=2.55965
    rVDD_102 (MM4_ELT_s VDD_159) resistor r=11.6604
    rVDD_101 (MM4_ELT_s VDD_159) resistor r=1.30988
    rVDD_100 (MM4_ELT_s VDD_185) resistor r=2.69818
    rVDD_99 (VDD_148 VDD_185) resistor r=5.83401
    rVDD_98 (VDD_149 VDD_151) resistor r=20.2547
    rVDD_97 (VDD_150 VDD_151) resistor r=20.2547
    rVDD_96 (VDD_152 VDD_154) resistor r=24.5762
    rVDD_95 (VDD_152 VDD_185) resistor r=5.83401
    rVDD_94 (VDD_153 VDD_154) resistor r=24.5762
    rVDD_93 (VDD_153 VDD_156) resistor r=9.04062
    rVDD_92 (VDD_155 VDD_157) resistor r=14.4784
    rVDD_91 (VDD_155 VDD_189) resistor r=10.5593
    rVDD_90 (VDD_156 VDD_157) resistor r=14.4784
    rVDD_89 (VDD_158 VDD_159) resistor r=11.6604
    rVDD_88 (VDD_158 VDD_187) resistor r=10.2363
    rVDD_87 (MM42_ELT_s VDD_163) resistor r=2.55965
    rVDD_86 (MM42_ELT_s VDD_165) resistor r=11.6604
    rVDD_85 (MM42_ELT_s VDD_165) resistor r=1.30988
    rVDD_84 (MM42_ELT_s VDD_187) resistor r=10.2363
    rVDD_83 (VDD_161 VDD_163) resistor r=14.4784
    rVDD_82 (VDD_161 VDD_193) resistor r=10.5593
    rVDD_81 (VDD_162 VDD_163) resistor r=14.4784
    rVDD_80 (VDD_162 VDD_189) resistor r=10.5593
    rVDD_79 (VDD_164 VDD_165) resistor r=11.6604
    rVDD_78 (VDD_164 VDD_191) resistor r=10.2363
    rVDD_77 (MM2_ELT_s VDD_169) resistor r=2.55965
    rVDD_76 (MM2_ELT_s VDD_171) resistor r=11.6604
    rVDD_75 (MM2_ELT_s VDD_171) resistor r=1.30988
    rVDD_74 (MM2_ELT_s VDD_174) resistor r=6.12113
    rVDD_73 (MM2_ELT_s VDD_191) resistor r=10.2363
    rVDD_72 (VDD_167 VDD_169) resistor r=14.4784
    rVDD_71 (VDD_167 VDD_173) resistor r=9.04062
    rVDD_70 (VDD_168 VDD_169) resistor r=14.4784
    rVDD_69 (VDD_168 VDD_193) resistor r=10.5593
    rVDD_68 (VDD_170 VDD_171) resistor r=11.6604
    rVDD_67 (VDD_170 VDD_172) resistor r=9.04595
    rVDD_66 (VDD_172 VDD_174) resistor r=31.2341
    rVDD_65 (VDD_173 VDD_174) resistor r=31.2341
    rVDD_64 (VDD_175 VDD_176) resistor r=0.549089
    rVDD_63 (VDD_177 VDD_178) resistor r=0.730683
    rVDD_62 (VDD_181 VDD_182) resistor r=0.549089
    rVDD_61 (VDD_183 VDD_184) resistor r=0.730683
    rVDD_60 (VDD_186 VDD_187) resistor r=0.549089
    rVDD_59 (VDD_188 VDD_189) resistor r=0.730683
    rVDD_58 (VDD_190 VDD_191) resistor r=0.549089
    rVDD_57 (VDD_192 VDD_193) resistor r=0.730683
    rVSS_226 (MM29_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_225 (MM16_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_224 (MM17_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_223 (MM11_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_222 (MM18_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_221 (MM12_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_220 (MM13_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_219 (MM7_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_218 (MM5_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_217 (MM30_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_216 (MM3_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_215 (MM0_ELT_b VSS_36) resistor r=8.66667
    rVSS_214 (MM0_ELT_b VSS_49) resistor r=8.66667
    rVSS_213 (MM0_ELT_b VSS_52) resistor r=8.66667
    rVSS_212 (MM0_ELT_b VSS_62) resistor r=8.66667
    rVSS_211 (MM0_ELT_b VSS_71) resistor r=8.66667
    rVSS_210 (MM0_ELT_b VSS_74) resistor r=26
    rVSS_209 (MM0_ELT_b VSS_27) resistor r=43.1485
    rVSS_208 (VSS_2 VSS_7) resistor r=0.114631
    rVSS_207 (VSS_2 VSS_77) resistor r=0.0221539
    rVSS_206 (VSS VSS_7) resistor r=0.100796
    rVSS_205 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_204 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_203 (VSS_9 VSS_11) resistor r=0.438738
    rVSS_202 (VSS_9 VSS_77) resistor r=0.0882174
    rVSS_201 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_200 (VSS_12 MM29_ELT_s) resistor r=4.22001
    rVSS_199 (VSS_12 VSS_149) resistor r=4.22001
    rVSS_198 (VSS_12 MM0_ELT_s) resistor r=4.22001
    rVSS_197 (VSS_12 VSS_147) resistor r=4.22001
    rVSS_196 (VSS_14 VSS_26) resistor r=0.114631
    rVSS_195 (VSS_14 VSS_78) resistor r=0.0221539
    rVSS_194 (VSS_15 VSS_17) resistor r=0.0869613
    rVSS_193 (VSS_15 VSS_77) resistor r=0.0221539
    rVSS_192 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_191 (VSS_17 VSS_20) resistor r=0.237167
    rVSS_190 (VSS_18 VSS_21) resistor r=64.7228
    rVSS_189 (VSS_20 VSS_21) resistor r=8.66667
    rVSS_188 (VSS_20 VSS_23) resistor r=0.237509
    rVSS_187 (VSS_21 VSS_24) resistor r=64.7228
    rVSS_186 (VSS_23 VSS_24) resistor r=8.66667
    rVSS_185 (VSS_23 VSS_26) resistor r=0.237167
    rVSS_184 (VSS_24 VSS_27) resistor r=64.7228
    rVSS_183 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_182 (VSS_28 VSS_30) resistor r=0.438738
    rVSS_181 (VSS_28 VSS_78) resistor r=0.0882174
    rVSS_180 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_179 (VSS_31 MM13_ELT_s) resistor r=2.27123
    rVSS_178 (VSS_31 MM18_ELT_s) resistor r=2.27123
    rVSS_177 (VSS_31 VSS_151) resistor r=8.4738
    rVSS_176 (VSS_33 VSS_36) resistor r=0.167993
    rVSS_175 (VSS_33 VSS_79) resistor r=0.0221539
    rVSS_174 (VSS_34 VSS_36) resistor r=0.0869613
    rVSS_173 (VSS_34 VSS_78) resistor r=0.0221539
    rVSS_172 (VSS_38 VSS_40) resistor r=0.399618
    rVSS_171 (VSS_38 VSS_79) resistor r=0.0882174
    rVSS_170 (VSS_40 VSS_44) resistor r=8.66667
    rVSS_169 (VSS_40 VSS_43) resistor r=0.426259
    rVSS_168 (VSS_43 VSS_44) resistor r=26
    rVSS_167 (VSS_44 MM7_ELT_s) resistor r=2.90692
    rVSS_166 (VSS_44 VSS_153) resistor r=12.1406
    rVSS_165 (VSS_46 VSS_52) resistor r=0.167993
    rVSS_164 (VSS_46 VSS_80) resistor r=0.0221539
    rVSS_163 (VSS_47 VSS_49) resistor r=0.0335987
    rVSS_162 (VSS_47 VSS_79) resistor r=0.0221539
    rVSS_161 (VSS_49 VSS_52) resistor r=0.237167
    rVSS_160 (VSS_54 VSS_56) resistor r=0.438738
    rVSS_159 (VSS_54 VSS_80) resistor r=0.0882174
    rVSS_158 (VSS_56 VSS_57) resistor r=8.66667
    rVSS_157 (VSS_57 MM30_ELT_s) resistor r=4.22001
    rVSS_156 (VSS_57 VSS_156) resistor r=4.22001
    rVSS_155 (VSS_57 MM5_ELT_s) resistor r=4.22001
    rVSS_154 (VSS_57 VSS_154) resistor r=4.22001
    rVSS_153 (VSS_59 VSS_62) resistor r=0.136371
    rVSS_152 (VSS_59 VSS_81) resistor r=0.0221539
    rVSS_151 (VSS_60 VSS_62) resistor r=0.0335987
    rVSS_150 (VSS_60 VSS_80) resistor r=0.0221539
    rVSS_149 (VSS_64 VSS_66) resistor r=0.438738
    rVSS_148 (VSS_64 VSS_81) resistor r=0.0882174
    rVSS_147 (VSS_66 VSS_67) resistor r=8.66667
    rVSS_146 (VSS_67 MM3_ELT_s) resistor r=4.22001
    rVSS_145 (VSS_67 VSS_160) resistor r=4.22001
    rVSS_144 (VSS_67 MM30_ELT_s) resistor r=4.22001
    rVSS_143 (VSS_67 VSS_158) resistor r=4.22001
    rVSS_142 (VSS_69 VSS_71) resistor r=0.065221
    rVSS_141 (VSS_69 VSS_81) resistor r=0.0221539
    rVSS_140 (VSS_71 VSS_74) resistor r=0.158111
    rVSS_139 (MM0_ELT_s VSS_83) resistor r=18.0507
    rVSS_138 (MM0_ELT_s VSS_86) resistor r=2.67027
    rVSS_137 (MM0_ELT_s VSS_88) resistor r=12.8495
    rVSS_136 (MM0_ELT_s VSS_88) resistor r=1.69926
    rVSS_135 (VSS_83 VSS_85) resistor r=9.43134
    rVSS_134 (VSS_84 VSS_86) resistor r=15.1041
    rVSS_133 (VSS_84 VSS_148) resistor r=11.0157
    rVSS_132 (VSS_85 VSS_86) resistor r=15.1041
    rVSS_131 (VSS_87 VSS_88) resistor r=12.8495
    rVSS_130 (VSS_87 VSS_150) resistor r=10.6787
    rVSS_129 (MM29_ELT_s VSS_92) resistor r=2.67027
    rVSS_128 (MM29_ELT_s VSS_94) resistor r=12.8495
    rVSS_127 (MM29_ELT_s VSS_94) resistor r=1.69926
    rVSS_126 (MM29_ELT_s VSS_97) resistor r=4.557
    rVSS_125 (MM29_ELT_s VSS_150) resistor r=10.6787
    rVSS_124 (VSS_90 VSS_92) resistor r=15.1041
    rVSS_123 (VSS_90 VSS_95) resistor r=9.43134
    rVSS_122 (VSS_91 VSS_92) resistor r=15.1041
    rVSS_121 (VSS_91 VSS_148) resistor r=11.0157
    rVSS_120 (VSS_93 VSS_94) resistor r=12.8495
    rVSS_119 (VSS_93 VSS_96) resistor r=9.4369
    rVSS_118 (VSS_95 VSS_97) resistor r=21.1301
    rVSS_117 (VSS_96 VSS_97) resistor r=21.1301
    rVSS_116 (VSS_98 VSS_101) resistor r=21.1301
    rVSS_115 (VSS_98 VSS_103) resistor r=9.43134
    rVSS_114 (VSS_99 VSS_101) resistor r=21.1301
    rVSS_113 (VSS_99 VSS_105) resistor r=9.4369
    rVSS_112 (MM18_ELT_s VSS_101) resistor r=4.557
    rVSS_111 (MM18_ELT_s VSS_104) resistor r=2.67027
    rVSS_110 (MM18_ELT_s VSS_106) resistor r=12.8495
    rVSS_109 (MM18_ELT_s VSS_106) resistor r=1.69926
    rVSS_108 (VSS_102 VSS_104) resistor r=15.1041
    rVSS_107 (VSS_102 VSS_152) resistor r=11.0157
    rVSS_106 (VSS_103 VSS_104) resistor r=15.1041
    rVSS_105 (VSS_105 VSS_106) resistor r=12.8495
    rVSS_104 (MM13_ELT_s VSS_110) resistor r=2.67027
    rVSS_103 (MM13_ELT_s VSS_112) resistor r=12.8495
    rVSS_102 (MM13_ELT_s VSS_112) resistor r=1.69926
    rVSS_101 (MM13_ELT_s VSS_115) resistor r=4.557
    rVSS_100 (VSS_108 VSS_110) resistor r=15.1041
    rVSS_99 (VSS_108 VSS_113) resistor r=9.43134
    rVSS_98 (VSS_109 VSS_110) resistor r=15.1041
    rVSS_97 (VSS_109 VSS_152) resistor r=11.0157
    rVSS_96 (VSS_111 VSS_112) resistor r=12.8495
    rVSS_95 (VSS_111 VSS_114) resistor r=9.4369
    rVSS_94 (VSS_113 VSS_115) resistor r=21.1301
    rVSS_93 (VSS_114 VSS_115) resistor r=21.1301
    rVSS_92 (MM7_ELT_s VSS_119) resistor r=2.67027
    rVSS_91 (MM7_ELT_s VSS_121) resistor r=12.1643
    rVSS_90 (MM7_ELT_s VSS_121) resistor r=1.36649
    rVSS_89 (MM7_ELT_s VSS_124) resistor r=4.557
    rVSS_88 (VSS_117 VSS_119) resistor r=15.1041
    rVSS_87 (VSS_117 VSS_122) resistor r=9.43134
    rVSS_86 (VSS_118 VSS_119) resistor r=15.1041
    rVSS_85 (VSS_118 VSS_153) resistor r=9.89549
    rVSS_84 (VSS_120 VSS_121) resistor r=12.1643
    rVSS_83 (VSS_120 VSS_123) resistor r=9.4369
    rVSS_82 (VSS_122 VSS_124) resistor r=21.1301
    rVSS_81 (VSS_123 VSS_124) resistor r=21.1301
    rVSS_80 (MM5_ELT_s VSS_126) resistor r=18.0507
    rVSS_79 (MM5_ELT_s VSS_129) resistor r=2.67027
    rVSS_78 (MM5_ELT_s VSS_131) resistor r=12.1643
    rVSS_77 (MM5_ELT_s VSS_131) resistor r=1.36649
    rVSS_76 (VSS_126 VSS_128) resistor r=9.43134
    rVSS_75 (VSS_127 VSS_129) resistor r=15.1041
    rVSS_74 (VSS_127 VSS_155) resistor r=11.0157
    rVSS_73 (VSS_128 VSS_129) resistor r=15.1041
    rVSS_72 (VSS_130 VSS_131) resistor r=12.1643
    rVSS_71 (VSS_130 VSS_157) resistor r=10.6787
    rVSS_70 (MM30_ELT_s VSS_135) resistor r=2.67027
    rVSS_69 (MM30_ELT_s VSS_137) resistor r=12.1643
    rVSS_68 (MM30_ELT_s VSS_137) resistor r=1.36649
    rVSS_67 (MM30_ELT_s VSS_157) resistor r=10.6787
    rVSS_66 (VSS_133 VSS_135) resistor r=15.1041
    rVSS_65 (VSS_133 VSS_159) resistor r=11.0157
    rVSS_64 (VSS_134 VSS_135) resistor r=15.1041
    rVSS_63 (VSS_134 VSS_155) resistor r=11.0157
    rVSS_62 (VSS_136 VSS_137) resistor r=12.1643
    rVSS_61 (VSS_136 VSS_161) resistor r=10.6787
    rVSS_60 (MM3_ELT_s VSS_141) resistor r=2.67027
    rVSS_59 (MM3_ELT_s VSS_143) resistor r=12.1643
    rVSS_58 (MM3_ELT_s VSS_143) resistor r=1.36649
    rVSS_57 (MM3_ELT_s VSS_146) resistor r=4.557
    rVSS_56 (MM3_ELT_s VSS_161) resistor r=10.6787
    rVSS_55 (VSS_139 VSS_141) resistor r=15.1041
    rVSS_54 (VSS_139 VSS_144) resistor r=9.43134
    rVSS_53 (VSS_140 VSS_141) resistor r=15.1041
    rVSS_52 (VSS_140 VSS_159) resistor r=11.0157
    rVSS_51 (VSS_142 VSS_143) resistor r=12.1643
    rVSS_50 (VSS_142 VSS_145) resistor r=9.4369
    rVSS_49 (VSS_144 VSS_146) resistor r=21.1301
    rVSS_48 (VSS_145 VSS_146) resistor r=21.1301
    rVSS_47 (VSS_147 VSS_148) resistor r=0.762262
    rVSS_46 (VSS_149 VSS_150) resistor r=0.57282
    rVSS_45 (VSS_151 VSS_152) resistor r=0.762262
    rVSS_44 (VSS_154 VSS_155) resistor r=0.762262
    rVSS_43 (VSS_156 VSS_157) resistor r=0.57282
    rVSS_42 (VSS_158 VSS_159) resistor r=0.762262
    rVSS_41 (VSS_160 VSS_161) resistor r=0.57282
    rnet11_225 (MM4_ELT_d net11) resistor r=0.01
    rnet11_224 (net11_42 net11_48) resistor r=58.3583
    rnet11_223 (net11_42 net11_48) resistor r=4.16253
    rnet11_222 (net11_42 net11_48) resistor r=58.3583
    rnet11_221 (net11_42 net11_48) resistor r=4.16253
    rnet11_220 (net11_45 net11_48) resistor r=58.3583
    rnet11_219 (net11_45 net11_48) resistor r=5.53947
    rnet11_218 (net11_45 net11_48) resistor r=58.3583
    rnet11_217 (net11_45 net11_48) resistor r=5.53947
    rnet11_216 (net11_48 net11_50) resistor r=11.175
    rnet11_215 (net11_48 net11_73) resistor r=24.8333
    rnet11_214 (net11_48 net11_70) resistor r=24.8333
    rnet11_213 (net11_48 net11_89) resistor r=22.35
    rnet11_212 (net11_48 net11_86) resistor r=22.35
    rnet11_211 (net11_48 net11_102) resistor r=58.3583
    rnet11_210 (net11_48 net11_105) resistor r=58.3583
    rnet11_209 (net11_48 net11_73) resistor r=4.16253
    rnet11_208 (net11_48 net11_50) resistor r=5.53947
    rnet11_207 (net11_48 net11_89) resistor r=2.32428
    rnet11_206 (net11_48 net11_70) resistor r=4.16253
    rnet11_205 (net11_48 net11_102) resistor r=4.16253
    rnet11_204 (net11_48 net11_86) resistor r=4.16253
    rnet11_203 (net11_48 net11_105) resistor r=4.16253
    rnet11_202 (net11_48 net11_50) resistor r=11.175
    rnet11_201 (net11_48 net11_344) resistor r=29.8
    rnet11_200 (net11_48 net11_73) resistor r=24.8333
    rnet11_199 (net11_48 net11_70) resistor r=24.8333
    rnet11_198 (net11_48 net11_89) resistor r=22.35
    rnet11_197 (net11_48 net11_86) resistor r=22.35
    rnet11_196 (net11_48 net11_102) resistor r=58.3583
    rnet11_195 (net11_48 MM30_ELT_g) resistor r=7.45
    rnet11_194 (net11_48 net11_73) resistor r=4.16253
    rnet11_193 (net11_48 net11_50) resistor r=5.53947
    rnet11_192 (net11_48 net11_89) resistor r=2.32428
    rnet11_191 (net11_48 net11_70) resistor r=4.16253
    rnet11_190 (net11_48 net11_102) resistor r=4.16253
    rnet11_189 (net11_48 net11_86) resistor r=4.16253
    rnet11_188 (net11_48 net11_105) resistor r=4.16253
    rnet11_187 (net11_56 net11_59) resistor r=11.175
    rnet11_186 (net11_56 net11_59) resistor r=5.53947
    rnet11_185 (net11_56 net11_59) resistor r=11.175
    rnet11_184 (net11_56 net11_59) resistor r=5.53947
    rnet11_183 (net11_59 net11_62) resistor r=202.392
    rnet11_182 (net11_59 net11_65) resistor r=202.392
    rnet11_181 (net11_59 net11_81) resistor r=24.8333
    rnet11_180 (net11_59 net11_78) resistor r=24.8333
    rnet11_179 (net11_59 net11_97) resistor r=22.35
    rnet11_178 (net11_59 net11_94) resistor r=22.35
    rnet11_177 (net11_59 net11_110) resistor r=202.392
    rnet11_176 (net11_59 net11_113) resistor r=202.392
    rnet11_175 (net11_59 net11_62) resistor r=5.53947
    rnet11_174 (net11_59 net11_97) resistor r=2.32428
    rnet11_173 (net11_59 net11_81) resistor r=4.16253
    rnet11_172 (net11_59 net11_65) resistor r=4.16253
    rnet11_171 (net11_59 net11_94) resistor r=4.16253
    rnet11_170 (net11_59 net11_110) resistor r=4.16253
    rnet11_169 (net11_59 net11_78) resistor r=4.16253
    rnet11_168 (net11_59 net11_113) resistor r=4.16253
    rnet11_167 (net11_59 net11_346) resistor r=31.6625
    rnet11_166 (net11_59 net11_62) resistor r=202.392
    rnet11_165 (net11_59 net11_65) resistor r=202.392
    rnet11_164 (net11_59 net11_81) resistor r=24.8333
    rnet11_163 (net11_59 net11_78) resistor r=24.8333
    rnet11_162 (net11_59 net11_97) resistor r=22.35
    rnet11_161 (net11_59 net11_94) resistor r=22.35
    rnet11_160 (net11_59 net11_110) resistor r=202.392
    rnet11_159 (net11_59 MM42_ELT_g) resistor r=7.45
    rnet11_158 (net11_59 net11_62) resistor r=5.53947
    rnet11_157 (net11_59 net11_97) resistor r=2.32428
    rnet11_156 (net11_59 net11_81) resistor r=4.16253
    rnet11_155 (net11_59 net11_65) resistor r=4.16253
    rnet11_154 (net11_59 net11_94) resistor r=4.16253
    rnet11_153 (net11_59 net11_110) resistor r=4.16253
    rnet11_152 (net11_59 net11_78) resistor r=4.16253
    rnet11_151 (net11_59 net11_113) resistor r=4.16253
    rnet11_150 (net11_105 MM30_ELT_g) resistor r=50.9083
    rnet11_149 (net11_113 MM42_ELT_g) resistor r=194.942
    rnet11_148 (net11_118 net11_124) resistor r=58.3583
    rnet11_147 (net11_118 net11_124) resistor r=4.16253
    rnet11_146 (net11_118 net11_124) resistor r=58.3583
    rnet11_145 (net11_118 net11_124) resistor r=4.16253
    rnet11_144 (net11_121 net11_124) resistor r=58.3583
    rnet11_143 (net11_121 net11_124) resistor r=5.53947
    rnet11_142 (net11_121 net11_124) resistor r=58.3583
    rnet11_141 (net11_121 net11_124) resistor r=5.53947
    rnet11_140 (net11_124 net11_126) resistor r=11.175
    rnet11_139 (net11_124 net11_149) resistor r=24.8333
    rnet11_138 (net11_124 net11_146) resistor r=24.8333
    rnet11_137 (net11_124 net11_165) resistor r=22.35
    rnet11_136 (net11_124 net11_162) resistor r=22.35
    rnet11_135 (net11_124 net11_178) resistor r=58.3583
    rnet11_134 (net11_124 net11_181) resistor r=58.3583
    rnet11_133 (net11_124 net11_149) resistor r=4.16253
    rnet11_132 (net11_124 net11_126) resistor r=5.53947
    rnet11_131 (net11_124 net11_165) resistor r=2.32428
    rnet11_130 (net11_124 net11_146) resistor r=4.16253
    rnet11_129 (net11_124 net11_178) resistor r=4.16253
    rnet11_128 (net11_124 net11_162) resistor r=4.16253
    rnet11_127 (net11_124 net11_181) resistor r=4.16253
    rnet11_126 (net11_124 net11_126) resistor r=11.175
    rnet11_125 (net11_124 net11_378) resistor r=29.8
    rnet11_124 (net11_124 net11_149) resistor r=24.8333
    rnet11_123 (net11_124 net11_146) resistor r=24.8333
    rnet11_122 (net11_124 net11_165) resistor r=22.35
    rnet11_121 (net11_124 net11_162) resistor r=22.35
    rnet11_120 (net11_124 net11_178) resistor r=58.3583
    rnet11_119 (net11_124 MM3_ELT_g) resistor r=7.45
    rnet11_118 (net11_124 net11_149) resistor r=4.16253
    rnet11_117 (net11_124 net11_126) resistor r=5.53947
    rnet11_116 (net11_124 net11_165) resistor r=2.32428
    rnet11_115 (net11_124 net11_146) resistor r=4.16253
    rnet11_114 (net11_124 net11_178) resistor r=4.16253
    rnet11_113 (net11_124 net11_162) resistor r=4.16253
    rnet11_112 (net11_124 net11_181) resistor r=4.16253
    rnet11_111 (net11_132 net11_135) resistor r=11.175
    rnet11_110 (net11_132 net11_135) resistor r=5.53947
    rnet11_109 (net11_132 net11_135) resistor r=11.175
    rnet11_108 (net11_132 net11_135) resistor r=5.53947
    rnet11_107 (net11_135 net11_138) resistor r=202.392
    rnet11_106 (net11_135 net11_141) resistor r=202.392
    rnet11_105 (net11_135 net11_157) resistor r=24.8333
    rnet11_104 (net11_135 net11_154) resistor r=24.8333
    rnet11_103 (net11_135 net11_173) resistor r=22.35
    rnet11_102 (net11_135 net11_170) resistor r=22.35
    rnet11_101 (net11_135 net11_186) resistor r=202.392
    rnet11_100 (net11_135 net11_189) resistor r=202.392
    rnet11_99 (net11_135 net11_138) resistor r=5.53947
    rnet11_98 (net11_135 net11_173) resistor r=2.32428
    rnet11_97 (net11_135 net11_157) resistor r=4.16253
    rnet11_96 (net11_135 net11_141) resistor r=4.16253
    rnet11_95 (net11_135 net11_170) resistor r=4.16253
    rnet11_94 (net11_135 net11_186) resistor r=4.16253
    rnet11_93 (net11_135 net11_154) resistor r=4.16253
    rnet11_92 (net11_135 net11_189) resistor r=4.16253
    rnet11_91 (net11_135 net11_380) resistor r=31.6625
    rnet11_90 (net11_135 net11_138) resistor r=202.392
    rnet11_89 (net11_135 net11_141) resistor r=202.392
    rnet11_88 (net11_135 net11_157) resistor r=24.8333
    rnet11_87 (net11_135 net11_154) resistor r=24.8333
    rnet11_86 (net11_135 net11_173) resistor r=22.35
    rnet11_85 (net11_135 net11_170) resistor r=22.35
    rnet11_84 (net11_135 net11_186) resistor r=202.392
    rnet11_83 (net11_135 MM2_ELT_g) resistor r=7.45
    rnet11_82 (net11_135 net11_138) resistor r=5.53947
    rnet11_81 (net11_135 net11_173) resistor r=2.32428
    rnet11_80 (net11_135 net11_157) resistor r=4.16253
    rnet11_79 (net11_135 net11_141) resistor r=4.16253
    rnet11_78 (net11_135 net11_170) resistor r=4.16253
    rnet11_77 (net11_135 net11_186) resistor r=4.16253
    rnet11_76 (net11_135 net11_154) resistor r=4.16253
    rnet11_75 (net11_135 net11_189) resistor r=4.16253
    rnet11_74 (net11_181 MM3_ELT_g) resistor r=50.9083
    rnet11_73 (net11_189 MM2_ELT_g) resistor r=194.942
    rnet11_72 (net11_261 net11_263) resistor r=0.447572
    rnet11_71 (net11_261 net11_289) resistor r=0.0100984
    rnet11_70 (net11_263 net11_264) resistor r=13
    rnet11_69 (net11_264 MM5_ELT_d) resistor r=8.44
    rnet11_68 (net11_266 net11_268) resistor r=0.442243
    rnet11_67 (net11_266 net11_293) resistor r=0.0100984
    rnet11_66 (net11_268 net11_269) resistor r=8.66667
    rnet11_65 (net11_268 net11_271) resistor r=0.639388
    rnet11_64 (net11_269 net11) resistor r=32.3614
    rnet11_63 (net11_271 net11_272) resistor r=8.66667
    rnet11_62 (net11_271 net11_274) resistor r=0.426259
    rnet11_61 (net11_272 net11) resistor r=16.1807
    rnet11_60 (net11_272 net11_275) resistor r=32.3614
    rnet11_59 (net11_274 net11_275) resistor r=26
    rnet11_58 (net11_277 net11_278) resistor r=0.087818
    rnet11_57 (net11_277 net11_291) resistor r=0.0100984
    rnet11_56 (net11_278 net11_297) resistor r=0.103351
    rnet11_55 (net11_279 net11_280) resistor r=0.180515
    rnet11_54 (net11_279 net11_297) resistor r=0.103351
    rnet11_53 (net11_280 net11_295) resistor r=0.0100984
    rnet11_52 (net11_281 net11_283) resistor r=0.234607
    rnet11_51 (net11_281 net11_297) resistor r=0.00304145
    rnet11_50 (net11_283 net11_284) resistor r=6.66667
    rnet11_49 (net11_283 net11_286) resistor r=0.516984
    rnet11_48 (net11_284 net11_410) resistor r=3.38636
    rnet11_47 (net11_284 net11_426) resistor r=56.2136
    rnet11_46 (net11_286 net11_287) resistor r=20
    rnet11_45 (net11_287 net11_428) resistor r=8.80455
    rnet11_44 (net11_289 net11_291) resistor r=0.191449
    rnet11_43 (net11_293 net11_295) resistor r=0.155459
    rnet11_42 (net11_344 net11_411) resistor r=3.725
    rnet11_41 (net11_346 net11_411) resistor r=3.725
    rnet11_40 (net11_378 net11_428) resistor r=3.1797
    rnet11_39 (net11_380 net11_428) resistor r=3.1797
    rnet11_38 (net11_410 net11_411) resistor r=3.725
    rnet11_37 (net11_426 net11_428) resistor r=5.41818
    rnet5_227 (MM6_ELT_d net5) resistor r=0.01
    rnet5_226 (net5_42 net5_48) resistor r=58.3583
    rnet5_225 (net5_42 net5_48) resistor r=4.16253
    rnet5_224 (net5_42 net5_48) resistor r=58.3583
    rnet5_223 (net5_42 net5_48) resistor r=4.16253
    rnet5_222 (net5_45 net5_48) resistor r=58.3583
    rnet5_221 (net5_45 net5_48) resistor r=4.16253
    rnet5_220 (net5_45 net5_48) resistor r=58.3583
    rnet5_219 (net5_45 net5_48) resistor r=4.16253
    rnet5_218 (net5_48 net5_53) resistor r=22.35
    rnet5_217 (net5_48 net5_50) resistor r=22.35
    rnet5_216 (net5_48 net5_61) resistor r=24.8333
    rnet5_215 (net5_48 net5_58) resistor r=24.8333
    rnet5_214 (net5_48 net5_74) resistor r=11.175
    rnet5_213 (net5_48 net5_96) resistor r=58.3583
    rnet5_212 (net5_48 net5_99) resistor r=58.3583
    rnet5_211 (net5_48 net5_53) resistor r=4.16253
    rnet5_210 (net5_48 net5_61) resistor r=4.16253
    rnet5_209 (net5_48 net5_96) resistor r=5.53947
    rnet5_208 (net5_48 net5_74) resistor r=5.53947
    rnet5_207 (net5_48 net5_50) resistor r=2.32428
    rnet5_206 (net5_48 net5_58) resistor r=4.16253
    rnet5_205 (net5_48 net5_99) resistor r=4.16253
    rnet5_204 (net5_48 net5_53) resistor r=22.35
    rnet5_203 (net5_48 net5_50) resistor r=22.35
    rnet5_202 (net5_48 net5_61) resistor r=24.8333
    rnet5_201 (net5_48 net5_58) resistor r=24.8333
    rnet5_200 (net5_48 net5_349) resistor r=35.3875
    rnet5_199 (net5_48 net5_74) resistor r=11.175
    rnet5_198 (net5_48 net5_96) resistor r=58.3583
    rnet5_197 (net5_48 MM9_ELT_g) resistor r=7.45
    rnet5_196 (net5_48 net5_53) resistor r=4.16253
    rnet5_195 (net5_48 net5_61) resistor r=4.16253
    rnet5_194 (net5_48 net5_96) resistor r=5.53947
    rnet5_193 (net5_48 net5_74) resistor r=5.53947
    rnet5_192 (net5_48 net5_50) resistor r=2.32428
    rnet5_191 (net5_48 net5_58) resistor r=4.16253
    rnet5_190 (net5_48 net5_99) resistor r=4.16253
    rnet5_189 (net5_66 net5_72) resistor r=58.3583
    rnet5_188 (net5_66 net5_72) resistor r=4.16253
    rnet5_187 (net5_66 net5_72) resistor r=58.3583
    rnet5_186 (net5_66 net5_72) resistor r=4.16253
    rnet5_185 (net5_69 net5_72) resistor r=58.3583
    rnet5_184 (net5_69 net5_72) resistor r=4.16253
    rnet5_183 (net5_69 net5_72) resistor r=58.3583
    rnet5_182 (net5_69 net5_72) resistor r=4.16253
    rnet5_181 (net5_72 net5_83) resistor r=24.8333
    rnet5_180 (net5_72 net5_80) resistor r=24.8333
    rnet5_179 (net5_72 net5_91) resistor r=22.35
    rnet5_178 (net5_72 net5_88) resistor r=22.35
    rnet5_177 (net5_72 net5_104) resistor r=11.175
    rnet5_176 (net5_72 net5_110) resistor r=58.3583
    rnet5_175 (net5_72 net5_113) resistor r=58.3583
    rnet5_174 (net5_72 net5_83) resistor r=4.16253
    rnet5_173 (net5_72 net5_91) resistor r=4.16253
    rnet5_172 (net5_72 net5_104) resistor r=5.53947
    rnet5_171 (net5_72 net5_113) resistor r=5.53947
    rnet5_170 (net5_72 net5_88) resistor r=2.32428
    rnet5_169 (net5_72 net5_80) resistor r=4.16253
    rnet5_168 (net5_72 net5_110) resistor r=4.16253
    rnet5_167 (net5_72 net5_83) resistor r=24.8333
    rnet5_166 (net5_72 net5_80) resistor r=24.8333
    rnet5_165 (net5_72 net5_91) resistor r=22.35
    rnet5_164 (net5_72 net5_88) resistor r=22.35
    rnet5_163 (net5_72 net5_104) resistor r=11.175
    rnet5_162 (net5_72 net5_364) resistor r=30.7313
    rnet5_161 (net5_72 net5_110) resistor r=58.3583
    rnet5_160 (net5_72 MM12_ELT_g) resistor r=22.35
    rnet5_159 (net5_72 net5_83) resistor r=4.16253
    rnet5_158 (net5_72 net5_91) resistor r=4.16253
    rnet5_157 (net5_72 net5_104) resistor r=5.53947
    rnet5_156 (net5_72 net5_113) resistor r=5.53947
    rnet5_155 (net5_72 net5_88) resistor r=2.32428
    rnet5_154 (net5_72 net5_80) resistor r=4.16253
    rnet5_153 (net5_72 net5_110) resistor r=4.16253
    rnet5_152 (net5_99 MM9_ELT_g) resistor r=50.9083
    rnet5_151 (net5_113 MM12_ELT_g) resistor r=36.0083
    rnet5_150 (net5_118 net5_124) resistor r=58.3583
    rnet5_149 (net5_118 net5_124) resistor r=4.16253
    rnet5_148 (net5_118 net5_124) resistor r=58.3583
    rnet5_147 (net5_118 net5_124) resistor r=4.16253
    rnet5_146 (net5_121 net5_124) resistor r=58.3583
    rnet5_145 (net5_121 net5_124) resistor r=5.53947
    rnet5_144 (net5_121 net5_124) resistor r=58.3583
    rnet5_143 (net5_121 net5_124) resistor r=5.53947
    rnet5_142 (net5_124 net5_126) resistor r=11.175
    rnet5_141 (net5_124 net5_149) resistor r=24.8333
    rnet5_140 (net5_124 net5_146) resistor r=24.8333
    rnet5_139 (net5_124 net5_165) resistor r=22.35
    rnet5_138 (net5_124 net5_162) resistor r=22.35
    rnet5_137 (net5_124 net5_178) resistor r=58.3583
    rnet5_136 (net5_124 net5_181) resistor r=58.3583
    rnet5_135 (net5_124 net5_149) resistor r=4.16253
    rnet5_134 (net5_124 net5_126) resistor r=5.53947
    rnet5_133 (net5_124 net5_165) resistor r=2.32428
    rnet5_132 (net5_124 net5_146) resistor r=4.16253
    rnet5_131 (net5_124 net5_178) resistor r=4.16253
    rnet5_130 (net5_124 net5_162) resistor r=4.16253
    rnet5_129 (net5_124 net5_181) resistor r=4.16253
    rnet5_128 (net5_124 net5_126) resistor r=11.175
    rnet5_127 (net5_124 net5_375) resistor r=29.8
    rnet5_126 (net5_124 net5_149) resistor r=24.8333
    rnet5_125 (net5_124 net5_146) resistor r=24.8333
    rnet5_124 (net5_124 net5_165) resistor r=22.35
    rnet5_123 (net5_124 net5_162) resistor r=22.35
    rnet5_122 (net5_124 net5_178) resistor r=58.3583
    rnet5_121 (net5_124 MM5_ELT_g) resistor r=7.45
    rnet5_120 (net5_124 net5_149) resistor r=4.16253
    rnet5_119 (net5_124 net5_126) resistor r=5.53947
    rnet5_118 (net5_124 net5_165) resistor r=2.32428
    rnet5_117 (net5_124 net5_146) resistor r=4.16253
    rnet5_116 (net5_124 net5_178) resistor r=4.16253
    rnet5_115 (net5_124 net5_162) resistor r=4.16253
    rnet5_114 (net5_124 net5_181) resistor r=4.16253
    rnet5_113 (net5_132 net5_135) resistor r=11.175
    rnet5_112 (net5_132 net5_135) resistor r=5.53947
    rnet5_111 (net5_132 net5_135) resistor r=11.175
    rnet5_110 (net5_132 net5_135) resistor r=5.53947
    rnet5_109 (net5_135 net5_138) resistor r=202.392
    rnet5_108 (net5_135 net5_141) resistor r=202.392
    rnet5_107 (net5_135 net5_157) resistor r=24.8333
    rnet5_106 (net5_135 net5_154) resistor r=24.8333
    rnet5_105 (net5_135 net5_173) resistor r=22.35
    rnet5_104 (net5_135 net5_170) resistor r=22.35
    rnet5_103 (net5_135 net5_186) resistor r=202.392
    rnet5_102 (net5_135 net5_189) resistor r=202.392
    rnet5_101 (net5_135 net5_138) resistor r=5.53947
    rnet5_100 (net5_135 net5_173) resistor r=2.32428
    rnet5_99 (net5_135 net5_157) resistor r=4.16253
    rnet5_98 (net5_135 net5_141) resistor r=4.16253
    rnet5_97 (net5_135 net5_170) resistor r=4.16253
    rnet5_96 (net5_135 net5_186) resistor r=4.16253
    rnet5_95 (net5_135 net5_154) resistor r=4.16253
    rnet5_94 (net5_135 net5_189) resistor r=4.16253
    rnet5_93 (net5_135 net5_377) resistor r=31.6625
    rnet5_92 (net5_135 net5_138) resistor r=202.392
    rnet5_91 (net5_135 net5_141) resistor r=202.392
    rnet5_90 (net5_135 net5_157) resistor r=24.8333
    rnet5_89 (net5_135 net5_154) resistor r=24.8333
    rnet5_88 (net5_135 net5_173) resistor r=22.35
    rnet5_87 (net5_135 net5_170) resistor r=22.35
    rnet5_86 (net5_135 net5_186) resistor r=202.392
    rnet5_85 (net5_135 MM4_ELT_g) resistor r=7.45
    rnet5_84 (net5_135 net5_138) resistor r=5.53947
    rnet5_83 (net5_135 net5_173) resistor r=2.32428
    rnet5_82 (net5_135 net5_157) resistor r=4.16253
    rnet5_81 (net5_135 net5_141) resistor r=4.16253
    rnet5_80 (net5_135 net5_170) resistor r=4.16253
    rnet5_79 (net5_135 net5_186) resistor r=4.16253
    rnet5_78 (net5_135 net5_154) resistor r=4.16253
    rnet5_77 (net5_135 net5_189) resistor r=4.16253
    rnet5_76 (net5_181 MM5_ELT_g) resistor r=50.9083
    rnet5_75 (net5_189 MM4_ELT_g) resistor r=194.942
    rnet5_74 (net5_261 net5_263) resistor r=0.796557
    rnet5_73 (net5_261 net5_267) resistor r=0.0970559
    rnet5_72 (net5_263 net5_264) resistor r=10
    rnet5_71 (net5_264 net5_427) resistor r=0.677273
    rnet5_70 (net5_266 net5_267) resistor r=0.915374
    rnet5_69 (net5_266 net5_269) resistor r=0.0960733
    rnet5_68 (net5_268 net5_269) resistor r=0.362739
    rnet5_67 (net5_268 net5_293) resistor r=0.0466378
    rnet5_66 (net5_270 net5_272) resistor r=0.303709
    rnet5_65 (net5_270 net5_289) resistor r=0.0100984
    rnet5_64 (net5_272 net5_273) resistor r=13
    rnet5_63 (net5_273 MM7_ELT_d) resistor r=8.44
    rnet5_62 (net5_275 net5_277) resistor r=1.38001
    rnet5_61 (net5_275 net5_293) resistor r=0.0100984
    rnet5_60 (net5_277 net5_278) resistor r=13
    rnet5_59 (net5_278 net5) resistor r=8.09035
    rnet5_58 (net5_280 net5_281) resistor r=0.219545
    rnet5_57 (net5_280 net5_291) resistor r=0.0100984
    rnet5_56 (net5_281 net5_296) resistor r=0.103351
    rnet5_55 (net5_282 net5_283) resistor r=0.180515
    rnet5_54 (net5_282 net5_296) resistor r=0.103351
    rnet5_53 (net5_283 net5_294) resistor r=0.0100984
    rnet5_52 (net5_284 net5_286) resistor r=0.19985
    rnet5_51 (net5_284 net5_296) resistor r=0.00304145
    rnet5_50 (net5_286 net5_287) resistor r=10
    rnet5_49 (net5_287 net5_415) resistor r=12.8682
    rnet5_48 (net5_289 net5_291) resistor r=0.15108
    rnet5_47 (net5_293 net5_294) resistor r=0.155459
    rnet5_46 (net5_349 net5_427) resistor r=3.1797
    rnet5_45 (net5_364 net5_428) resistor r=3.1797
    rnet5_44 (net5_375 net5_416) resistor r=8.1518
    rnet5_43 (net5_377 net5_416) resistor r=8.1518
    rnet5_42 (net5_415 net5_416) resistor r=0.275023
    rnet5_41 (net5_427 net5_428) resistor r=25.7364
    rnet25_21 (MM13_ELT_d net25) resistor r=0.01
    rnet25_20 (net25_1 net25_3) resistor r=0.170757
    rnet25_19 (net25_1 net25_7) resistor r=0.0960733
    rnet25_18 (net25_3 net25_4) resistor r=13
    rnet25_17 (net25_4 MM12_ELT_s) resistor r=8.44
    rnet25_16 (net25_6 net25_7) resistor r=0.127195
    rnet25_15 (net25_6 net25_9) resistor r=0.0960733
    rnet25_14 (net25_8 net25_9) resistor r=0.705176
    rnet25_13 (net25_8 net25_15) resistor r=0.0100984
    rnet25_12 (net25_10 net25_12) resistor r=0.399618
    rnet25_11 (net25_10 net25_17) resistor r=0.0100984
    rnet25_10 (net25_12 net25_13) resistor r=13
    rnet25_9 (net25_13 net25) resistor r=8.44
    rnet25_8 (net25_15 net25_17) resistor r=0.0780605
    rnet20_18 (MM18_ELT_d net20) resistor r=0.01
    rnet20_17 (net20_1 net20_3) resistor r=0.0593291
    rnet20_16 (net20_1 net20_17) resistor r=0.0728113
    rnet20_15 (net20_3 net20_4) resistor r=13
    rnet20_14 (net20_4 MM17_ELT_s) resistor r=8.44
    rnet20_13 (net20_8 net20_9) resistor r=0.592146
    rnet20_12 (net20_8 net20_18) resistor r=0.0189224
    rnet20_11 (net20_9 net20_17) resistor r=0.0189224
    rnet20_10 (net20_10 net20_12) resistor r=0.0586106
    rnet20_9 (net20_10 net20_18) resistor r=0.0728113
    rnet20_8 (net20_12 net20_13) resistor r=13
    rnet20_7 (net20_13 net20) resistor r=8.44
    rCDN_158 (CDN_34 CDN_40) resistor r=58.3583
    rCDN_157 (CDN_34 CDN_40) resistor r=4.16253
    rCDN_156 (CDN_34 CDN_40) resistor r=58.3583
    rCDN_155 (CDN_34 CDN_40) resistor r=4.16253
    rCDN_154 (CDN_37 CDN_40) resistor r=58.3583
    rCDN_153 (CDN_37 CDN_40) resistor r=4.16253
    rCDN_152 (CDN_37 CDN_40) resistor r=58.3583
    rCDN_151 (CDN_37 CDN_40) resistor r=4.16253
    rCDN_150 (CDN_40 CDN_45) resistor r=24.8333
    rCDN_149 (CDN_40 CDN_42) resistor r=24.8333
    rCDN_148 (CDN_40 CDN_53) resistor r=24.8333
    rCDN_147 (CDN_40 CDN_50) resistor r=24.8333
    rCDN_146 (CDN_40 CDN_58) resistor r=58.3583
    rCDN_145 (CDN_40 CDN_61) resistor r=58.3583
    rCDN_144 (CDN_40 CDN_66) resistor r=14.9
    rCDN_143 (CDN_40 CDN_45) resistor r=4.16253
    rCDN_142 (CDN_40 CDN_53) resistor r=4.16253
    rCDN_141 (CDN_40 CDN_42) resistor r=4.16253
    rCDN_140 (CDN_40 CDN_58) resistor r=4.16253
    rCDN_139 (CDN_40 CDN_66) resistor r=6.30933
    rCDN_138 (CDN_40 CDN_61) resistor r=6.30933
    rCDN_137 (CDN_40 CDN_50) resistor r=1.63969
    rCDN_136 (CDN_40 CDN_45) resistor r=24.8333
    rCDN_135 (CDN_40 CDN_42) resistor r=24.8333
    rCDN_134 (CDN_40 CDN_53) resistor r=24.8333
    rCDN_133 (CDN_40 CDN_50) resistor r=24.8333
    rCDN_132 (CDN_40 CDN_58) resistor r=58.3583
    rCDN_131 (CDN_40 MM18_ELT_g) resistor r=22.35
    rCDN_130 (CDN_40 CDN_66) resistor r=14.9
    rCDN_129 (CDN_40 CDN_263) resistor r=39.7333
    rCDN_128 (CDN_40 CDN_45) resistor r=4.16253
    rCDN_127 (CDN_40 CDN_53) resistor r=4.16253
    rCDN_126 (CDN_40 CDN_42) resistor r=4.16253
    rCDN_125 (CDN_40 CDN_58) resistor r=4.16253
    rCDN_124 (CDN_40 CDN_66) resistor r=6.30933
    rCDN_123 (CDN_40 CDN_61) resistor r=6.30933
    rCDN_122 (CDN_40 CDN_50) resistor r=1.63969
    rCDN_121 (CDN_61 MM18_ELT_g) resistor r=36.0083
    rCDN_120 (CDN_72 CDN_78) resistor r=58.3583
    rCDN_119 (CDN_72 CDN_78) resistor r=4.16253
    rCDN_118 (CDN_72 CDN_78) resistor r=58.3583
    rCDN_117 (CDN_72 CDN_78) resistor r=4.16253
    rCDN_116 (CDN_75 CDN_78) resistor r=58.3583
    rCDN_115 (CDN_75 CDN_78) resistor r=6.30933
    rCDN_114 (CDN_75 CDN_78) resistor r=58.3583
    rCDN_113 (CDN_75 CDN_78) resistor r=6.30933
    rCDN_112 (CDN_78 CDN_80) resistor r=14.9
    rCDN_111 (CDN_78 CDN_89) resistor r=24.8333
    rCDN_110 (CDN_78 CDN_86) resistor r=24.8333
    rCDN_109 (CDN_78 CDN_97) resistor r=24.8333
    rCDN_108 (CDN_78 CDN_94) resistor r=24.8333
    rCDN_107 (CDN_78 CDN_110) resistor r=58.3583
    rCDN_106 (CDN_78 CDN_113) resistor r=58.3583
    rCDN_105 (CDN_78 CDN_89) resistor r=4.16253
    rCDN_104 (CDN_78 CDN_80) resistor r=6.30933
    rCDN_103 (CDN_78 CDN_97) resistor r=1.63969
    rCDN_102 (CDN_78 CDN_86) resistor r=4.16253
    rCDN_101 (CDN_78 CDN_110) resistor r=4.16253
    rCDN_100 (CDN_78 CDN_94) resistor r=4.16253
    rCDN_99 (CDN_78 CDN_113) resistor r=4.16253
    rCDN_98 (CDN_78 CDN_80) resistor r=14.9
    rCDN_97 (CDN_78 CDN_271) resistor r=39.7333
    rCDN_96 (CDN_78 CDN_89) resistor r=24.8333
    rCDN_95 (CDN_78 CDN_86) resistor r=24.8333
    rCDN_94 (CDN_78 CDN_97) resistor r=24.8333
    rCDN_93 (CDN_78 CDN_94) resistor r=24.8333
    rCDN_92 (CDN_78 CDN_110) resistor r=58.3583
    rCDN_91 (CDN_78 MM13_ELT_g) resistor r=7.45
    rCDN_90 (CDN_78 CDN_89) resistor r=4.16253
    rCDN_89 (CDN_78 CDN_80) resistor r=6.30933
    rCDN_88 (CDN_78 CDN_97) resistor r=1.63969
    rCDN_87 (CDN_78 CDN_86) resistor r=4.16253
    rCDN_86 (CDN_78 CDN_110) resistor r=4.16253
    rCDN_85 (CDN_78 CDN_94) resistor r=4.16253
    rCDN_84 (CDN_78 CDN_113) resistor r=4.16253
    rCDN_83 (CDN_102 CDN_108) resistor r=58.3583
    rCDN_82 (CDN_102 CDN_108) resistor r=4.16253
    rCDN_81 (CDN_102 CDN_108) resistor r=58.3583
    rCDN_80 (CDN_102 CDN_108) resistor r=4.16253
    rCDN_79 (CDN_105 CDN_108) resistor r=58.3583
    rCDN_78 (CDN_105 CDN_108) resistor r=4.16253
    rCDN_77 (CDN_105 CDN_108) resistor r=58.3583
    rCDN_76 (CDN_105 CDN_108) resistor r=4.16253
    rCDN_75 (CDN_108 CDN_121) resistor r=8.69167
    rCDN_74 (CDN_108 CDN_118) resistor r=8.69167
    rCDN_73 (CDN_108 CDN_129) resistor r=24.8333
    rCDN_72 (CDN_108 CDN_126) resistor r=24.8333
    rCDN_71 (CDN_108 CDN_134) resistor r=14.9
    rCDN_70 (CDN_108 CDN_143) resistor r=8.69167
    rCDN_69 (CDN_108 CDN_140) resistor r=8.69167
    rCDN_68 (CDN_108 CDN_148) resistor r=58.3583
    rCDN_67 (CDN_108 CDN_151) resistor r=58.3583
    rCDN_66 (CDN_108 CDN_121) resistor r=4.16253
    rCDN_65 (CDN_108 CDN_129) resistor r=4.16253
    rCDN_64 (CDN_108 CDN_143) resistor r=6.30933
    rCDN_63 (CDN_108 CDN_118) resistor r=6.30933
    rCDN_62 (CDN_108 CDN_134) resistor r=1.63969
    rCDN_61 (CDN_108 CDN_140) resistor r=4.16253
    rCDN_60 (CDN_108 CDN_148) resistor r=4.16253
    rCDN_59 (CDN_108 CDN_126) resistor r=4.16253
    rCDN_58 (CDN_108 CDN_151) resistor r=4.16253
    rCDN_57 (CDN_108 CDN_121) resistor r=8.69167
    rCDN_56 (CDN_108 CDN_118) resistor r=8.69167
    rCDN_55 (CDN_108 CDN_129) resistor r=24.8333
    rCDN_54 (CDN_108 CDN_126) resistor r=24.8333
    rCDN_53 (CDN_108 CDN_295) resistor r=330.283
    rCDN_52 (CDN_108 CDN_134) resistor r=14.9
    rCDN_51 (CDN_108 CDN_143) resistor r=8.69167
    rCDN_50 (CDN_108 CDN_140) resistor r=8.69167
    rCDN_49 (CDN_108 CDN_148) resistor r=58.3583
    rCDN_48 (CDN_108 MM8_ELT_g) resistor r=7.45
    rCDN_47 (CDN_108 CDN_121) resistor r=4.16253
    rCDN_46 (CDN_108 CDN_129) resistor r=4.16253
    rCDN_45 (CDN_108 CDN_143) resistor r=6.30933
    rCDN_44 (CDN_108 CDN_118) resistor r=6.30933
    rCDN_43 (CDN_108 CDN_134) resistor r=1.63969
    rCDN_42 (CDN_108 CDN_140) resistor r=4.16253
    rCDN_41 (CDN_108 CDN_148) resistor r=4.16253
    rCDN_40 (CDN_108 CDN_126) resistor r=4.16253
    rCDN_39 (CDN_108 CDN_151) resistor r=4.16253
    rCDN_38 (CDN_113 MM13_ELT_g) resistor r=50.9083
    rCDN_37 (CDN_151 MM8_ELT_g) resistor r=50.9083
    rCDN_36 (CDN CDN_214) resistor r=10
    rCDN_35 (CDN_214 CDN_310) resistor r=11.5136
    rCDN_34 (CDN_263 CDN_311) resistor r=4.38767
    rCDN_33 (CDN_265 CDN_266) resistor r=27.0909
    rCDN_32 (CDN_265 CDN_314) resistor r=3.71511
    rCDN_31 (CDN_266 CDN_311) resistor r=3.71511
    rCDN_30 (CDN_271 CDN_314) resistor r=4.38767
    rCDN_29 (CDN_279 CDN_280) resistor r=38.6045
    rCDN_28 (CDN_279 CDN_295) resistor r=9.29775
    rCDN_27 (CDN_280 CDN_314) resistor r=3.71511
    rCDN_26 (CDN_310 CDN_311) resistor r=3.71511
    rD_102 (D_22 D_28) resistor r=58.3583
    rD_101 (D_22 D_28) resistor r=4.16253
    rD_100 (D_22 D_28) resistor r=58.3583
    rD_99 (D_22 D_28) resistor r=4.16253
    rD_98 (D_25 D_28) resistor r=58.3583
    rD_97 (D_25 D_28) resistor r=4.16253
    rD_96 (D_25 D_28) resistor r=58.3583
    rD_95 (D_25 D_28) resistor r=4.16253
    rD_94 (D_28 D_33) resistor r=24.8333
    rD_93 (D_28 D_30) resistor r=24.8333
    rD_92 (D_28 D_41) resistor r=24.8333
    rD_91 (D_28 D_38) resistor r=24.8333
    rD_90 (D_28 D_46) resistor r=14.9
    rD_89 (D_28 D_52) resistor r=58.3583
    rD_88 (D_28 D_55) resistor r=58.3583
    rD_87 (D_28 D_33) resistor r=4.16253
    rD_86 (D_28 D_41) resistor r=4.16253
    rD_85 (D_28 D_52) resistor r=6.30933
    rD_84 (D_28 D_46) resistor r=6.30933
    rD_83 (D_28 D_30) resistor r=1.63969
    rD_82 (D_28 D_38) resistor r=4.16253
    rD_81 (D_28 D_55) resistor r=4.16253
    rD_80 (D_28 D_33) resistor r=24.8333
    rD_79 (D_28 D_30) resistor r=24.8333
    rD_78 (D_28 D_41) resistor r=24.8333
    rD_77 (D_28 D_38) resistor r=24.8333
    rD_76 (D_28 D_166) resistor r=47.1833
    rD_75 (D_28 D_46) resistor r=14.9
    rD_74 (D_28 D_52) resistor r=58.3583
    rD_73 (D_28 MM14_ELT_g) resistor r=7.45
    rD_72 (D_28 D_33) resistor r=4.16253
    rD_71 (D_28 D_41) resistor r=4.16253
    rD_70 (D_28 D_52) resistor r=6.30933
    rD_69 (D_28 D_46) resistor r=6.30933
    rD_68 (D_28 D_30) resistor r=1.63969
    rD_67 (D_28 D_38) resistor r=4.16253
    rD_66 (D_28 D_55) resistor r=4.16253
    rD_65 (D_55 MM14_ELT_g) resistor r=50.9083
    rD_64 (D_60 D_66) resistor r=58.3583
    rD_63 (D_60 D_66) resistor r=4.16253
    rD_62 (D_60 D_66) resistor r=58.3583
    rD_61 (D_60 D_66) resistor r=4.16253
    rD_60 (D_63 D_66) resistor r=58.3583
    rD_59 (D_63 D_66) resistor r=6.30933
    rD_58 (D_63 D_66) resistor r=58.3583
    rD_57 (D_63 D_66) resistor r=6.30933
    rD_56 (D_66 D_68) resistor r=14.9
    rD_55 (D_66 D_77) resistor r=24.8333
    rD_54 (D_66 D_74) resistor r=24.8333
    rD_53 (D_66 D_85) resistor r=24.8333
    rD_52 (D_66 D_82) resistor r=24.8333
    rD_51 (D_66 D_90) resistor r=58.3583
    rD_50 (D_66 D_93) resistor r=58.3583
    rD_49 (D_66 D_77) resistor r=4.16253
    rD_48 (D_66 D_68) resistor r=6.30933
    rD_47 (D_66 D_85) resistor r=1.63969
    rD_46 (D_66 D_74) resistor r=4.16253
    rD_45 (D_66 D_90) resistor r=4.16253
    rD_44 (D_66 D_82) resistor r=4.16253
    rD_43 (D_66 D_93) resistor r=4.16253
    rD_42 (D_66 D_68) resistor r=14.9
    rD_41 (D_66 D_180) resistor r=39.7333
    rD_40 (D_66 D_77) resistor r=24.8333
    rD_39 (D_66 D_74) resistor r=24.8333
    rD_38 (D_66 D_85) resistor r=24.8333
    rD_37 (D_66 D_82) resistor r=24.8333
    rD_36 (D_66 D_90) resistor r=58.3583
    rD_35 (D_66 MM17_ELT_g) resistor r=7.45
    rD_34 (D_66 D_77) resistor r=4.16253
    rD_33 (D_66 D_68) resistor r=6.30933
    rD_32 (D_66 D_85) resistor r=1.63969
    rD_31 (D_66 D_74) resistor r=4.16253
    rD_30 (D_66 D_90) resistor r=4.16253
    rD_29 (D_66 D_82) resistor r=4.16253
    rD_28 (D_66 D_93) resistor r=4.16253
    rD_27 (D_93 MM17_ELT_g) resistor r=50.9083
    rD_26 (D D_135) resistor r=10
    rD_25 (D_135 D_201) resistor r=16.9318
    rD_24 (D_166 D_175) resistor r=9.29775
    rD_23 (D_174 D_175) resistor r=22.35
    rD_22 (D_174 D_183) resistor r=9.29775
    rD_21 (D_180 D_202) resistor r=10.0997
    rD_20 (D_182 D_183) resistor r=255.783
    rD_19 (D_182 D_202) resistor r=10.0997
    rD_18 (D_201 D_202) resistor r=0.877078
    rnet49_20 (MM14_ELT_d net49) resistor r=0.01
    rnet49_19 (net49_1 net49_3) resistor r=0.458635
    rnet49_18 (net49_1 net49_13) resistor r=0.0100984
    rnet49_17 (net49_3 net49_4) resistor r=13
    rnet49_16 (net49_4 MM15_ELT_s) resistor r=8.09035
    rnet49_15 (net49_6 net49_8) resistor r=0.266412
    rnet49_14 (net49_6 net49_17) resistor r=0.0100984
    rnet49_13 (net49_8 net49_9) resistor r=13
    rnet49_12 (net49_9 net49) resistor r=8.09035
    rnet49_11 (net49_11 net49_12) resistor r=0.402044
    rnet49_10 (net49_11 net49_15) resistor r=0.0100984
    rnet49_9 (net49_12 net49_19) resistor r=0.0100984
    rnet49_8 (net49_13 net49_15) resistor r=0.0926968
    rnet49_7 (net49_17 net49_19) resistor r=0.0926968
    rnet67_190 (MM8_ELT_d net67) resistor r=0.01
    rnet67_189 (net67_22 net67_28) resistor r=58.3583
    rnet67_188 (net67_22 net67_28) resistor r=4.16253
    rnet67_187 (net67_22 net67_28) resistor r=58.3583
    rnet67_186 (net67_22 net67_28) resistor r=4.16253
    rnet67_185 (net67_25 net67_28) resistor r=58.3583
    rnet67_184 (net67_25 net67_28) resistor r=5.53947
    rnet67_183 (net67_25 net67_28) resistor r=58.3583
    rnet67_182 (net67_25 net67_28) resistor r=5.53947
    rnet67_181 (net67_28 net67_30) resistor r=11.175
    rnet67_180 (net67_28 net67_53) resistor r=24.8333
    rnet67_179 (net67_28 net67_50) resistor r=24.8333
    rnet67_178 (net67_28 net67_69) resistor r=22.35
    rnet67_177 (net67_28 net67_66) resistor r=22.35
    rnet67_176 (net67_28 net67_82) resistor r=58.3583
    rnet67_175 (net67_28 net67_85) resistor r=58.3583
    rnet67_174 (net67_28 net67_53) resistor r=4.16253
    rnet67_173 (net67_28 net67_30) resistor r=5.53947
    rnet67_172 (net67_28 net67_69) resistor r=2.32428
    rnet67_171 (net67_28 net67_50) resistor r=4.16253
    rnet67_170 (net67_28 net67_82) resistor r=4.16253
    rnet67_169 (net67_28 net67_66) resistor r=4.16253
    rnet67_168 (net67_28 net67_85) resistor r=4.16253
    rnet67_167 (net67_28 net67_30) resistor r=11.175
    rnet67_166 (net67_28 net67_218) resistor r=29.8
    rnet67_165 (net67_28 net67_53) resistor r=24.8333
    rnet67_164 (net67_28 net67_50) resistor r=24.8333
    rnet67_163 (net67_28 net67_69) resistor r=22.35
    rnet67_162 (net67_28 net67_66) resistor r=22.35
    rnet67_161 (net67_28 net67_82) resistor r=58.3583
    rnet67_160 (net67_28 MM7_ELT_g) resistor r=7.45
    rnet67_159 (net67_28 net67_53) resistor r=4.16253
    rnet67_158 (net67_28 net67_30) resistor r=5.53947
    rnet67_157 (net67_28 net67_69) resistor r=2.32428
    rnet67_156 (net67_28 net67_50) resistor r=4.16253
    rnet67_155 (net67_28 net67_82) resistor r=4.16253
    rnet67_154 (net67_28 net67_66) resistor r=4.16253
    rnet67_153 (net67_28 net67_85) resistor r=4.16253
    rnet67_152 (net67_36 net67_39) resistor r=11.175
    rnet67_151 (net67_36 net67_39) resistor r=5.53947
    rnet67_150 (net67_36 net67_39) resistor r=11.175
    rnet67_149 (net67_36 net67_39) resistor r=5.53947
    rnet67_148 (net67_39 net67_42) resistor r=58.3583
    rnet67_147 (net67_39 net67_45) resistor r=58.3583
    rnet67_146 (net67_39 net67_61) resistor r=24.8333
    rnet67_145 (net67_39 net67_58) resistor r=24.8333
    rnet67_144 (net67_39 net67_77) resistor r=22.35
    rnet67_143 (net67_39 net67_74) resistor r=22.35
    rnet67_142 (net67_39 net67_90) resistor r=58.3583
    rnet67_141 (net67_39 net67_93) resistor r=58.3583
    rnet67_140 (net67_39 net67_42) resistor r=5.53947
    rnet67_139 (net67_39 net67_77) resistor r=2.32428
    rnet67_138 (net67_39 net67_61) resistor r=4.16253
    rnet67_137 (net67_39 net67_45) resistor r=4.16253
    rnet67_136 (net67_39 net67_74) resistor r=4.16253
    rnet67_135 (net67_39 net67_90) resistor r=4.16253
    rnet67_134 (net67_39 net67_58) resistor r=4.16253
    rnet67_133 (net67_39 net67_93) resistor r=4.16253
    rnet67_132 (net67_39 net67_220) resistor r=247.712
    rnet67_131 (net67_39 net67_42) resistor r=58.3583
    rnet67_130 (net67_39 net67_45) resistor r=58.3583
    rnet67_129 (net67_39 net67_61) resistor r=24.8333
    rnet67_128 (net67_39 net67_58) resistor r=24.8333
    rnet67_127 (net67_39 net67_77) resistor r=22.35
    rnet67_126 (net67_39 net67_74) resistor r=22.35
    rnet67_125 (net67_39 net67_90) resistor r=58.3583
    rnet67_124 (net67_39 MM6_ELT_g) resistor r=7.45
    rnet67_123 (net67_39 net67_42) resistor r=5.53947
    rnet67_122 (net67_39 net67_77) resistor r=2.32428
    rnet67_121 (net67_39 net67_61) resistor r=4.16253
    rnet67_120 (net67_39 net67_45) resistor r=4.16253
    rnet67_119 (net67_39 net67_74) resistor r=4.16253
    rnet67_118 (net67_39 net67_90) resistor r=4.16253
    rnet67_117 (net67_39 net67_58) resistor r=4.16253
    rnet67_116 (net67_39 net67_93) resistor r=4.16253
    rnet67_115 (net67_85 MM7_ELT_g) resistor r=50.9083
    rnet67_114 (net67_93 MM6_ELT_g) resistor r=50.9083
    rnet67_113 (net67_133 net67_134) resistor r=1.02114
    rnet67_112 (net67_133 net67_135) resistor r=0.0960733
    rnet67_111 (net67_134 net67_183) resistor r=0.0964199
    rnet67_110 (net67_135 net67_136) resistor r=0.580575
    rnet67_109 (net67_136 net67_138) resistor r=0.0960733
    rnet67_108 (net67_137 net67_138) resistor r=0.389652
    rnet67_107 (net67_137 net67_177) resistor r=0.0728113
    rnet67_106 (net67_139 net67_141) resistor r=0.209788
    rnet67_105 (net67_139 net67_145) resistor r=0.0960733
    rnet67_104 (net67_141 net67_142) resistor r=13
    rnet67_103 (net67_142 MM10_ELT_d) resistor r=8.09035
    rnet67_102 (net67_144 net67_145) resistor r=0.385529
    rnet67_101 (net67_144 net67_179) resistor r=0.0728113
    rnet67_100 (net67_146 net67_148) resistor r=0.414696
    rnet67_99 (net67_146 net67_177) resistor r=0.0189224
    rnet67_98 (net67_148 net67_149) resistor r=13
    rnet67_97 (net67_149 MM11_ELT_d) resistor r=8.44
    rnet67_96 (net67_151 net67_152) resistor r=0.166994
    rnet67_95 (net67_151 net67_178) resistor r=0.0728113
    rnet67_94 (net67_152 net67_177) resistor r=0.0728113
    rnet67_93 (net67_153 net67_154) resistor r=0.617256
    rnet67_92 (net67_153 net67_178) resistor r=0.0189224
    rnet67_91 (net67_154 net67_179) resistor r=0.0189224
    rnet67_90 (net67_155 net67_156) resistor r=0.864786
    rnet67_89 (net67_155 net67_160) resistor r=0.0960733
    rnet67_88 (net67_156 net67_178) resistor r=0.0728113
    rnet67_87 (net67_157 net67_158) resistor r=0.980094
    rnet67_86 (net67_157 net67_166) resistor r=0.0960733
    rnet67_85 (net67_158 net67_179) resistor r=0.0728113
    rnet67_84 (net67_159 net67_160) resistor r=1.40044
    rnet67_83 (net67_159 net67_161) resistor r=0.101296
    rnet67_82 (net67_161 net67_163) resistor r=0.33006
    rnet67_81 (net67_163 net67_164) resistor r=10
    rnet67_80 (net67_164 net67_250) resistor r=12.8682
    rnet67_79 (net67_166 net67_168) resistor r=0.229114
    rnet67_78 (net67_168 net67_169) resistor r=13
    rnet67_77 (net67_169 net67) resistor r=8.09035
    rnet67_76 (net67_172 net67_174) resistor r=0.0370998
    rnet67_75 (net67_172 net67_183) resistor r=0.318139
    rnet67_74 (net67_174 net67_175) resistor r=8.66667
    rnet67_73 (net67_175 MM15_ELT_d) resistor r=2.78649
    rnet67_72 (net67_175 net67_267) resistor r=11.6377
    rnet67_71 (net67_180 net67_182) resistor r=0.646478
    rnet67_70 (net67_180 net67_190) resistor r=0.00804152
    rnet67_69 (net67_182 net67_183) resistor r=0.75
    rnet67_68 (net67_185 net67_187) resistor r=0.166964
    rnet67_67 (net67_185 net67_192) resistor r=0.00804152
    rnet67_66 (net67_187 net67_272) resistor r=0.75
    rnet67_65 (net67_190 net67_192) resistor r=0.155751
    rnet67_64 (net67_218 net67_251) resistor r=8.1518
    rnet67_63 (net67_220 net67_251) resistor r=8.1518
    rnet67_62 (net67_250 net67_251) resistor r=0.275023
    rnet67_61 (MM15_ELT_d net67_261) resistor r=2.55965
    rnet67_60 (MM15_ELT_d net67_263) resistor r=12.3172
    rnet67_59 (MM15_ELT_d net67_263) resistor r=1.62887
    rnet67_58 (MM15_ELT_d net67_266) resistor r=4.36821
    rnet67_57 (net67_259 net67_261) resistor r=14.4784
    rnet67_56 (net67_259 net67_264) resistor r=9.04062
    rnet67_55 (net67_260 net67_261) resistor r=14.4784
    rnet67_54 (net67_260 net67_267) resistor r=9.48555
    rnet67_53 (net67_262 net67_263) resistor r=12.3172
    rnet67_52 (net67_262 net67_265) resistor r=9.04595
    rnet67_51 (net67_264 net67_266) resistor r=20.2547
    rnet67_50 (net67_265 net67_266) resistor r=20.2547
    rnet67_49 (net67_271 net67_272) resistor r=13
    rnet67_48 (net67_271 MM16_ELT_d) resistor r=8.44
    rENN_144 (MM28_ELT_d ENN) resistor r=0.01
    rENN_143 (ENN_22 ENN_28) resistor r=58.3583
    rENN_142 (ENN_22 ENN_28) resistor r=4.16253
    rENN_141 (ENN_22 ENN_28) resistor r=58.3583
    rENN_140 (ENN_22 ENN_28) resistor r=4.16253
    rENN_139 (ENN_25 ENN_28) resistor r=58.3583
    rENN_138 (ENN_25 ENN_28) resistor r=6.30933
    rENN_137 (ENN_25 ENN_28) resistor r=58.3583
    rENN_136 (ENN_25 ENN_28) resistor r=6.30933
    rENN_135 (ENN_28 ENN_30) resistor r=14.9
    rENN_134 (ENN_28 ENN_39) resistor r=24.8333
    rENN_133 (ENN_28 ENN_36) resistor r=24.8333
    rENN_132 (ENN_28 ENN_47) resistor r=24.8333
    rENN_131 (ENN_28 ENN_44) resistor r=24.8333
    rENN_130 (ENN_28 ENN_52) resistor r=58.3583
    rENN_129 (ENN_28 ENN_55) resistor r=58.3583
    rENN_128 (ENN_28 ENN_39) resistor r=4.16253
    rENN_127 (ENN_28 ENN_30) resistor r=6.30933
    rENN_126 (ENN_28 ENN_47) resistor r=1.63969
    rENN_125 (ENN_28 ENN_36) resistor r=4.16253
    rENN_124 (ENN_28 ENN_52) resistor r=4.16253
    rENN_123 (ENN_28 ENN_44) resistor r=4.16253
    rENN_122 (ENN_28 ENN_55) resistor r=4.16253
    rENN_121 (ENN_28 ENN_30) resistor r=14.9
    rENN_120 (ENN_28 ENN_195) resistor r=40.975
    rENN_119 (ENN_28 ENN_39) resistor r=24.8333
    rENN_118 (ENN_28 ENN_36) resistor r=24.8333
    rENN_117 (ENN_28 ENN_47) resistor r=24.8333
    rENN_116 (ENN_28 ENN_44) resistor r=24.8333
    rENN_115 (ENN_28 ENN_52) resistor r=58.3583
    rENN_114 (ENN_28 MM16_ELT_g) resistor r=7.45
    rENN_113 (ENN_28 ENN_39) resistor r=4.16253
    rENN_112 (ENN_28 ENN_30) resistor r=6.30933
    rENN_111 (ENN_28 ENN_47) resistor r=1.63969
    rENN_110 (ENN_28 ENN_36) resistor r=4.16253
    rENN_109 (ENN_28 ENN_52) resistor r=4.16253
    rENN_108 (ENN_28 ENN_44) resistor r=4.16253
    rENN_107 (ENN_28 ENN_55) resistor r=4.16253
    rENN_106 (ENN_55 MM16_ELT_g) resistor r=50.9083
    rENN_105 (ENN_60 ENN_66) resistor r=58.3583
    rENN_104 (ENN_60 ENN_66) resistor r=4.16253
    rENN_103 (ENN_60 ENN_66) resistor r=58.3583
    rENN_102 (ENN_60 ENN_66) resistor r=4.16253
    rENN_101 (ENN_63 ENN_66) resistor r=58.3583
    rENN_100 (ENN_63 ENN_66) resistor r=4.16253
    rENN_99 (ENN_63 ENN_66) resistor r=58.3583
    rENN_98 (ENN_63 ENN_66) resistor r=4.16253
    rENN_97 (ENN_66 ENN_71) resistor r=24.8333
    rENN_96 (ENN_66 ENN_68) resistor r=24.8333
    rENN_95 (ENN_66 ENN_79) resistor r=24.8333
    rENN_94 (ENN_66 ENN_76) resistor r=24.8333
    rENN_93 (ENN_66 ENN_84) resistor r=14.9
    rENN_92 (ENN_66 ENN_90) resistor r=58.3583
    rENN_91 (ENN_66 ENN_93) resistor r=58.3583
    rENN_90 (ENN_66 ENN_71) resistor r=4.16253
    rENN_89 (ENN_66 ENN_79) resistor r=4.16253
    rENN_88 (ENN_66 ENN_90) resistor r=6.30933
    rENN_87 (ENN_66 ENN_84) resistor r=6.30933
    rENN_86 (ENN_66 ENN_68) resistor r=1.63969
    rENN_85 (ENN_66 ENN_76) resistor r=4.16253
    rENN_84 (ENN_66 ENN_93) resistor r=4.16253
    rENN_83 (ENN_66 ENN_71) resistor r=24.8333
    rENN_82 (ENN_66 ENN_68) resistor r=24.8333
    rENN_81 (ENN_66 ENN_79) resistor r=24.8333
    rENN_80 (ENN_66 ENN_76) resistor r=24.8333
    rENN_79 (ENN_66 ENN_217) resistor r=47.1833
    rENN_78 (ENN_66 ENN_84) resistor r=14.9
    rENN_77 (ENN_66 ENN_90) resistor r=58.3583
    rENN_76 (ENN_66 MM10_ELT_g) resistor r=7.45
    rENN_75 (ENN_66 ENN_71) resistor r=4.16253
    rENN_74 (ENN_66 ENN_79) resistor r=4.16253
    rENN_73 (ENN_66 ENN_90) resistor r=6.30933
    rENN_72 (ENN_66 ENN_84) resistor r=6.30933
    rENN_71 (ENN_66 ENN_68) resistor r=1.63969
    rENN_70 (ENN_66 ENN_76) resistor r=4.16253
    rENN_69 (ENN_66 ENN_93) resistor r=4.16253
    rENN_68 (ENN_93 MM10_ELT_g) resistor r=50.9083
    rENN_67 (ENN_131 ENN_133) resistor r=0.399618
    rENN_66 (ENN_131 ENN_148) resistor r=0.0960733
    rENN_65 (ENN_133 ENN_134) resistor r=13
    rENN_64 (ENN_134 MM29_ELT_d) resistor r=8.44
    rENN_63 (ENN_136 ENN_138) resistor r=0.399618
    rENN_62 (ENN_136 ENN_150) resistor r=0.0960733
    rENN_61 (ENN_138 ENN_139) resistor r=8.66667
    rENN_60 (ENN_138 ENN_141) resistor r=0.693007
    rENN_59 (ENN_139 ENN) resistor r=32.3614
    rENN_58 (ENN_141 ENN_142) resistor r=8.66667
    rENN_57 (ENN_141 ENN_144) resistor r=0.462004
    rENN_56 (ENN_142 ENN) resistor r=16.1807
    rENN_55 (ENN_142 ENN_145) resistor r=32.3614
    rENN_54 (ENN_144 ENN_145) resistor r=26
    rENN_53 (ENN_147 ENN_148) resistor r=0.207592
    rENN_52 (ENN_147 ENN_158) resistor r=0.0964199
    rENN_51 (ENN_149 ENN_150) resistor r=0.178788
    rENN_50 (ENN_149 ENN_152) resistor r=0.0964199
    rENN_49 (ENN_151 ENN_152) resistor r=0.242023
    rENN_48 (ENN_151 ENN_160) resistor r=0.110215
    rENN_47 (ENN_153 ENN_155) resistor r=0.0126968
    rENN_46 (ENN_153 ENN_160) resistor r=0.0072126
    rENN_45 (ENN_155 ENN_156) resistor r=10
    rENN_44 (ENN_156 ENN_229) resistor r=25.0591
    rENN_43 (ENN_158 ENN_164) resistor r=0.105403
    rENN_42 (ENN_159 ENN_160) resistor r=0.110215
    rENN_41 (ENN_159 ENN_164) resistor r=0.0143732
    rENN_40 (ENN_161 ENN_163) resistor r=1.16072
    rENN_39 (ENN_161 ENN_166) resistor r=0.0765047
    rENN_38 (ENN_163 ENN_164) resistor r=0.75
    rENN_37 (ENN_166 ENN_168) resistor r=0.844949
    rENN_36 (ENN_168 ENN_169) resistor r=0.75
    rENN_35 (ENN_169 ENN_241) resistor r=10
    rENN_34 (ENN_195 ENN_229) resistor r=9.29775
    rENN_33 (ENN_217 ENN_235) resistor r=4.38767
    rENN_32 (ENN_234 ENN_235) resistor r=3.71511
    rENN_31 (ENN_234 ENN_241) resistor r=14.9
    rEN_266 (MM1_ELT_d EN) resistor r=0.01
    rEN_265 (EN_42 EN_48) resistor r=58.3583
    rEN_264 (EN_42 EN_48) resistor r=4.16253
    rEN_263 (EN_42 EN_48) resistor r=58.3583
    rEN_262 (EN_42 EN_48) resistor r=4.16253
    rEN_261 (EN_45 EN_48) resistor r=58.3583
    rEN_260 (EN_45 EN_48) resistor r=6.30933
    rEN_259 (EN_45 EN_48) resistor r=58.3583
    rEN_258 (EN_45 EN_48) resistor r=6.30933
    rEN_257 (EN_48 EN_50) resistor r=14.9
    rEN_256 (EN_48 EN_73) resistor r=24.8333
    rEN_255 (EN_48 EN_70) resistor r=24.8333
    rEN_254 (EN_48 EN_81) resistor r=24.8333
    rEN_253 (EN_48 EN_78) resistor r=24.8333
    rEN_252 (EN_48 EN_102) resistor r=58.3583
    rEN_251 (EN_48 EN_105) resistor r=58.3583
    rEN_250 (EN_48 EN_73) resistor r=4.16253
    rEN_249 (EN_48 EN_50) resistor r=6.30933
    rEN_248 (EN_48 EN_81) resistor r=1.63969
    rEN_247 (EN_48 EN_70) resistor r=4.16253
    rEN_246 (EN_48 EN_102) resistor r=4.16253
    rEN_245 (EN_48 EN_78) resistor r=4.16253
    rEN_244 (EN_48 EN_105) resistor r=4.16253
    rEN_243 (EN_48 EN_50) resistor r=14.9
    rEN_242 (EN_48 EN_373) resistor r=40.975
    rEN_241 (EN_48 EN_73) resistor r=24.8333
    rEN_240 (EN_48 EN_70) resistor r=24.8333
    rEN_239 (EN_48 EN_81) resistor r=24.8333
    rEN_238 (EN_48 EN_78) resistor r=24.8333
    rEN_237 (EN_48 EN_102) resistor r=58.3583
    rEN_236 (EN_48 MM29_ELT_g) resistor r=7.45
    rEN_235 (EN_48 EN_73) resistor r=4.16253
    rEN_234 (EN_48 EN_50) resistor r=6.30933
    rEN_233 (EN_48 EN_81) resistor r=1.63969
    rEN_232 (EN_48 EN_70) resistor r=4.16253
    rEN_231 (EN_48 EN_102) resistor r=4.16253
    rEN_230 (EN_48 EN_78) resistor r=4.16253
    rEN_229 (EN_48 EN_105) resistor r=4.16253
    rEN_228 (EN_56 EN_59) resistor r=14.9
    rEN_227 (EN_56 EN_59) resistor r=6.30933
    rEN_226 (EN_56 EN_59) resistor r=14.9
    rEN_225 (EN_56 EN_59) resistor r=6.30933
    rEN_224 (EN_59 EN_62) resistor r=202.392
    rEN_223 (EN_59 EN_65) resistor r=202.392
    rEN_222 (EN_59 EN_89) resistor r=24.8333
    rEN_221 (EN_59 EN_86) resistor r=24.8333
    rEN_220 (EN_59 EN_97) resistor r=24.8333
    rEN_219 (EN_59 EN_94) resistor r=24.8333
    rEN_218 (EN_59 EN_110) resistor r=202.392
    rEN_217 (EN_59 EN_113) resistor r=202.392
    rEN_216 (EN_59 EN_62) resistor r=6.30933
    rEN_215 (EN_59 EN_89) resistor r=1.63969
    rEN_214 (EN_59 EN_97) resistor r=4.16253
    rEN_213 (EN_59 EN_65) resistor r=4.16253
    rEN_212 (EN_59 EN_86) resistor r=4.16253
    rEN_211 (EN_59 EN_110) resistor r=4.16253
    rEN_210 (EN_59 EN_94) resistor r=4.16253
    rEN_209 (EN_59 EN_113) resistor r=4.16253
    rEN_208 (EN_59 EN_375) resistor r=40.975
    rEN_207 (EN_59 EN_62) resistor r=202.392
    rEN_206 (EN_59 EN_65) resistor r=202.392
    rEN_205 (EN_59 EN_89) resistor r=24.8333
    rEN_204 (EN_59 EN_86) resistor r=24.8333
    rEN_203 (EN_59 EN_97) resistor r=24.8333
    rEN_202 (EN_59 EN_94) resistor r=24.8333
    rEN_201 (EN_59 EN_110) resistor r=202.392
    rEN_200 (EN_59 MM28_ELT_g) resistor r=7.45
    rEN_199 (EN_59 EN_62) resistor r=6.30933
    rEN_198 (EN_59 EN_89) resistor r=1.63969
    rEN_197 (EN_59 EN_97) resistor r=4.16253
    rEN_196 (EN_59 EN_65) resistor r=4.16253
    rEN_195 (EN_59 EN_86) resistor r=4.16253
    rEN_194 (EN_59 EN_110) resistor r=4.16253
    rEN_193 (EN_59 EN_94) resistor r=4.16253
    rEN_192 (EN_59 EN_113) resistor r=4.16253
    rEN_191 (EN_105 MM29_ELT_g) resistor r=50.9083
    rEN_190 (EN_113 MM28_ELT_g) resistor r=194.942
    rEN_189 (EN_118 EN_124) resistor r=58.3583
    rEN_188 (EN_118 EN_124) resistor r=4.16253
    rEN_187 (EN_118 EN_124) resistor r=58.3583
    rEN_186 (EN_118 EN_124) resistor r=4.16253
    rEN_185 (EN_121 EN_124) resistor r=58.3583
    rEN_184 (EN_121 EN_124) resistor r=6.30933
    rEN_183 (EN_121 EN_124) resistor r=58.3583
    rEN_182 (EN_121 EN_124) resistor r=6.30933
    rEN_181 (EN_124 EN_126) resistor r=14.9
    rEN_180 (EN_124 EN_135) resistor r=24.8333
    rEN_179 (EN_124 EN_132) resistor r=24.8333
    rEN_178 (EN_124 EN_143) resistor r=24.8333
    rEN_177 (EN_124 EN_140) resistor r=24.8333
    rEN_176 (EN_124 EN_148) resistor r=58.3583
    rEN_175 (EN_124 EN_151) resistor r=58.3583
    rEN_174 (EN_124 EN_135) resistor r=4.16253
    rEN_173 (EN_124 EN_126) resistor r=6.30933
    rEN_172 (EN_124 EN_143) resistor r=1.63969
    rEN_171 (EN_124 EN_132) resistor r=4.16253
    rEN_170 (EN_124 EN_148) resistor r=4.16253
    rEN_169 (EN_124 EN_140) resistor r=4.16253
    rEN_168 (EN_124 EN_151) resistor r=4.16253
    rEN_167 (EN_124 EN_126) resistor r=14.9
    rEN_166 (EN_124 EN_407) resistor r=39.7333
    rEN_165 (EN_124 EN_135) resistor r=24.8333
    rEN_164 (EN_124 EN_132) resistor r=24.8333
    rEN_163 (EN_124 EN_143) resistor r=24.8333
    rEN_162 (EN_124 EN_140) resistor r=24.8333
    rEN_161 (EN_124 EN_148) resistor r=58.3583
    rEN_160 (EN_124 MM15_ELT_g) resistor r=7.45
    rEN_159 (EN_124 EN_135) resistor r=4.16253
    rEN_158 (EN_124 EN_126) resistor r=6.30933
    rEN_157 (EN_124 EN_143) resistor r=1.63969
    rEN_156 (EN_124 EN_132) resistor r=4.16253
    rEN_155 (EN_124 EN_148) resistor r=4.16253
    rEN_154 (EN_124 EN_140) resistor r=4.16253
    rEN_153 (EN_124 EN_151) resistor r=4.16253
    rEN_152 (EN_151 MM15_ELT_g) resistor r=50.9083
    rEN_151 (EN_156 EN_159) resistor r=14.9
    rEN_150 (EN_156 EN_159) resistor r=6.30933
    rEN_149 (EN_156 EN_159) resistor r=14.9
    rEN_148 (EN_156 EN_159) resistor r=6.30933
    rEN_147 (EN_159 EN_162) resistor r=58.3583
    rEN_146 (EN_159 EN_165) resistor r=58.3583
    rEN_145 (EN_159 EN_173) resistor r=24.8333
    rEN_144 (EN_159 EN_170) resistor r=24.8333
    rEN_143 (EN_159 EN_181) resistor r=24.8333
    rEN_142 (EN_159 EN_178) resistor r=24.8333
    rEN_141 (EN_159 EN_186) resistor r=58.3583
    rEN_140 (EN_159 EN_189) resistor r=58.3583
    rEN_139 (EN_159 EN_162) resistor r=6.30933
    rEN_138 (EN_159 EN_173) resistor r=1.63969
    rEN_137 (EN_159 EN_181) resistor r=4.16253
    rEN_136 (EN_159 EN_165) resistor r=4.16253
    rEN_135 (EN_159 EN_170) resistor r=4.16253
    rEN_134 (EN_159 EN_186) resistor r=4.16253
    rEN_133 (EN_159 EN_178) resistor r=4.16253
    rEN_132 (EN_159 EN_189) resistor r=4.16253
    rEN_131 (EN_159 EN_420) resistor r=39.7333
    rEN_130 (EN_159 EN_162) resistor r=58.3583
    rEN_129 (EN_159 EN_165) resistor r=58.3583
    rEN_128 (EN_159 EN_173) resistor r=24.8333
    rEN_127 (EN_159 EN_170) resistor r=24.8333
    rEN_126 (EN_159 EN_181) resistor r=24.8333
    rEN_125 (EN_159 EN_178) resistor r=24.8333
    rEN_124 (EN_159 EN_186) resistor r=58.3583
    rEN_123 (EN_159 MM11_ELT_g) resistor r=7.45
    rEN_122 (EN_159 EN_162) resistor r=6.30933
    rEN_121 (EN_159 EN_173) resistor r=1.63969
    rEN_120 (EN_159 EN_181) resistor r=4.16253
    rEN_119 (EN_159 EN_165) resistor r=4.16253
    rEN_118 (EN_159 EN_170) resistor r=4.16253
    rEN_117 (EN_159 EN_186) resistor r=4.16253
    rEN_116 (EN_159 EN_178) resistor r=4.16253
    rEN_115 (EN_159 EN_189) resistor r=4.16253
    rEN_114 (EN_189 MM11_ELT_g) resistor r=50.9083
    rEN_113 (EN_261 EN_263) resistor r=0.399618
    rEN_112 (EN_261 EN_278) resistor r=0.0960733
    rEN_111 (EN_263 EN_264) resistor r=13
    rEN_110 (EN_264 MM0_ELT_d) resistor r=8.44
    rEN_109 (EN_266 EN_268) resistor r=0.399618
    rEN_108 (EN_266 EN_280) resistor r=0.0960733
    rEN_107 (EN_268 EN_269) resistor r=8.66667
    rEN_106 (EN_268 EN_271) resistor r=0.639388
    rEN_105 (EN_269 EN) resistor r=32.3614
    rEN_104 (EN_271 EN_272) resistor r=8.66667
    rEN_103 (EN_271 EN_274) resistor r=0.426259
    rEN_102 (EN_272 EN) resistor r=16.1807
    rEN_101 (EN_272 EN_275) resistor r=32.3614
    rEN_100 (EN_274 EN_275) resistor r=26
    rEN_99 (EN_277 EN_278) resistor r=0.342666
    rEN_98 (EN_277 EN_299) resistor r=0.0964199
    rEN_97 (EN_279 EN_280) resistor r=0.289836
    rEN_96 (EN_279 EN_282) resistor r=0.0964199
    rEN_95 (EN_281 EN_282) resistor r=0.196434
    rEN_94 (EN_281 EN_301) resistor r=0.110215
    rEN_93 (EN_283 EN_285) resistor r=0.00423228
    rEN_92 (EN_283 EN_301) resistor r=0.0072126
    rEN_91 (EN_285 EN_286) resistor r=10
    rEN_90 (EN_286 EN_464) resistor r=3.38636
    rEN_89 (EN_288 EN_290) resistor r=0.087818
    rEN_88 (EN_288 EN_302) resistor r=0.0964199
    rEN_87 (EN_290 EN_291) resistor r=10
    rEN_86 (EN_291 EN_449) resistor r=22.35
    rEN_85 (EN_293 EN_294) resistor r=0.539163
    rEN_84 (EN_293 EN_295) resistor r=0.0960733
    rEN_83 (EN_294 EN_303) resistor r=0.0964199
    rEN_82 (EN_295 EN_296) resistor r=0.191796
    rEN_81 (EN_296 EN_305) resistor r=0.0480367
    rEN_80 (EN_299 EN_311) resistor r=0.105403
    rEN_79 (EN_300 EN_301) resistor r=0.110215
    rEN_78 (EN_300 EN_311) resistor r=0.0143732
    rEN_77 (EN_302 EN_319) resistor r=0.23074
    rEN_76 (EN_303 EN_328) resistor r=0.72639
    rEN_75 (EN_305 EN_306) resistor r=10
    rEN_74 (EN_306 EN_452) resistor r=5.41818
    rEN_73 (EN_307 EN_310) resistor r=0.580172
    rEN_72 (EN_307 EN_313) resistor r=0.0765047
    rEN_71 (EN_308 EN_310) resistor r=1.21486
    rEN_70 (EN_308 EN_315) resistor r=0.0765047
    rEN_69 (EN_310 EN_311) resistor r=0.75
    rEN_68 (EN_312 EN_313) resistor r=1.04707
    rEN_67 (EN_312 EN_327) resistor r=0.0382523
    rEN_66 (EN_314 EN_315) resistor r=0.295927
    rEN_65 (EN_314 EN_325) resistor r=0.0150682
    rEN_64 (EN_316 EN_318) resistor r=0.0389377
    rEN_63 (EN_316 EN_325) resistor r=0.0579808
    rEN_62 (EN_318 EN_319) resistor r=0.75
    rEN_61 (EN_327 EN_328) resistor r=0.75
    rEN_60 (EN_373 EN_464) resistor r=5.23411
    rEN_59 (EN_375 EN_464) resistor r=5.23411
    rEN_58 (EN_407 EN_449) resistor r=9.29775
    rEN_57 (EN_420 EN_453) resistor r=4.38767
    rEN_56 (EN_452 EN_453) resistor r=3.71511
    rE_93 (E_22 E_28) resistor r=58.3583
    rE_92 (E_22 E_28) resistor r=4.16253
    rE_91 (E_22 E_28) resistor r=58.3583
    rE_90 (E_22 E_28) resistor r=4.16253
    rE_89 (E_25 E_28) resistor r=58.3583
    rE_88 (E_25 E_28) resistor r=6.30933
    rE_87 (E_25 E_28) resistor r=58.3583
    rE_86 (E_25 E_28) resistor r=6.30933
    rE_85 (E_28 E_30) resistor r=14.9
    rE_84 (E_28 E_53) resistor r=24.8333
    rE_83 (E_28 E_50) resistor r=24.8333
    rE_82 (E_28 E_61) resistor r=24.8333
    rE_81 (E_28 E_58) resistor r=24.8333
    rE_80 (E_28 E_82) resistor r=58.3583
    rE_79 (E_28 E_85) resistor r=58.3583
    rE_78 (E_28 E_53) resistor r=4.16253
    rE_77 (E_28 E_30) resistor r=6.30933
    rE_76 (E_28 E_61) resistor r=1.63969
    rE_75 (E_28 E_50) resistor r=4.16253
    rE_74 (E_28 E_82) resistor r=4.16253
    rE_73 (E_28 E_58) resistor r=4.16253
    rE_72 (E_28 E_85) resistor r=4.16253
    rE_71 (E_28 E_30) resistor r=14.9
    rE_70 (E_28 E_161) resistor r=40.975
    rE_69 (E_28 E_53) resistor r=24.8333
    rE_68 (E_28 E_50) resistor r=24.8333
    rE_67 (E_28 E_61) resistor r=24.8333
    rE_66 (E_28 E_58) resistor r=24.8333
    rE_65 (E_28 E_82) resistor r=58.3583
    rE_64 (E_28 MM0_ELT_g) resistor r=7.45
    rE_63 (E_28 E_53) resistor r=4.16253
    rE_62 (E_28 E_30) resistor r=6.30933
    rE_61 (E_28 E_61) resistor r=1.63969
    rE_60 (E_28 E_50) resistor r=4.16253
    rE_59 (E_28 E_82) resistor r=4.16253
    rE_58 (E_28 E_58) resistor r=4.16253
    rE_57 (E_28 E_85) resistor r=4.16253
    rE_56 (E_36 E_39) resistor r=14.9
    rE_55 (E_36 E_39) resistor r=6.30933
    rE_54 (E_36 E_39) resistor r=14.9
    rE_53 (E_36 E_39) resistor r=6.30933
    rE_52 (E_39 E_42) resistor r=202.392
    rE_51 (E_39 E_45) resistor r=202.392
    rE_50 (E_39 E_69) resistor r=24.8333
    rE_49 (E_39 E_66) resistor r=24.8333
    rE_48 (E_39 E_77) resistor r=24.8333
    rE_47 (E_39 E_74) resistor r=24.8333
    rE_46 (E_39 E_90) resistor r=202.392
    rE_45 (E_39 E_93) resistor r=202.392
    rE_44 (E_39 E_42) resistor r=6.30933
    rE_43 (E_39 E_69) resistor r=1.63969
    rE_42 (E_39 E_77) resistor r=4.16253
    rE_41 (E_39 E_45) resistor r=4.16253
    rE_40 (E_39 E_66) resistor r=4.16253
    rE_39 (E_39 E_90) resistor r=4.16253
    rE_38 (E_39 E_74) resistor r=4.16253
    rE_37 (E_39 E_93) resistor r=4.16253
    rE_36 (E_39 E_163) resistor r=40.975
    rE_35 (E_39 E_42) resistor r=202.392
    rE_34 (E_39 E_45) resistor r=202.392
    rE_33 (E_39 E_69) resistor r=24.8333
    rE_32 (E_39 E_66) resistor r=24.8333
    rE_31 (E_39 E_77) resistor r=24.8333
    rE_30 (E_39 E_74) resistor r=24.8333
    rE_29 (E_39 E_90) resistor r=202.392
    rE_28 (E_39 MM1_ELT_g) resistor r=7.45
    rE_27 (E_39 E_42) resistor r=6.30933
    rE_26 (E_39 E_69) resistor r=1.63969
    rE_25 (E_39 E_77) resistor r=4.16253
    rE_24 (E_39 E_45) resistor r=4.16253
    rE_23 (E_39 E_66) resistor r=4.16253
    rE_22 (E_39 E_90) resistor r=4.16253
    rE_21 (E_39 E_74) resistor r=4.16253
    rE_20 (E_39 E_93) resistor r=4.16253
    rE_19 (E_85 MM0_ELT_g) resistor r=50.9083
    rE_18 (E_93 MM1_ELT_g) resistor r=194.942
    rE_17 (E_133 E) resistor r=10
    rE_16 (E_133 E_201) resistor r=0.677273
    rE_15 (E_161 E_201) resistor r=5.23411
    rE_14 (E_163 E_201) resistor r=5.23411
ends LHCNQD2_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: MAOI222D1_LVT_ELT
// View name: calibre
subckt MAOI222D1_LVT_ELT A B C ZN VDD VSS
    MMU6_ELT (MMU6_ELT_d MMU6_ELT_g MMU6_ELT_s MMU6_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MMI1_ELT (MMI1_ELT_d MMI1_ELT_g MMI1_ELT_s MMI1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MMI4_ELT (MMI4_ELT_d MMI4_ELT_g MMI4_ELT_s MMI4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.4125e-13 pd=1.34e-06 \
        ps=3.55e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MMI5_ELT (MMI5_ELT_d MMI5_ELT_g MMI5_ELT_s MMI5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.4125e-13 pd=1.34e-06 \
        ps=3.55e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MMU9_ELT (MMU9_ELT_d MMU9_ELT_g MMU9_ELT_s MMU9_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.4125e-13 pd=1.34e-06 \
        ps=3.55e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MMI2_ELT (MMI2_ELT_d MMI2_ELT_g MMI2_ELT_s MMI2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MMU5_ELT (MMU5_ELT_d MMU5_ELT_g MMU5_ELT_s MMU5_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MMU2_ELT (MMU2_ELT_d MMU2_ELT_g MMU2_ELT_s MMU2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.8485e-13 pd=3.66e-06 \
        ps=6.64333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MMU4_ELT (MMU4_ELT_d MMU4_ELT_g MMU4_ELT_s MMU4_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.8485e-13 pd=3.66e-06 \
        ps=6.64333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MMI3_ELT (MMI3_ELT_d MMI3_ELT_g MMI3_ELT_s MMI3_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.8485e-13 pd=3.66e-06 \
        ps=6.64333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    cinet28_5 (net28_3 VSS) capacitor c=1.73684e-16
    cinet28_4 (net28_4 VSS) capacitor c=3.34234e-16
    cinet28_3 (net28_12 VSS) capacitor c=2.09296e-16
    cinet28_2 (net28_13 VSS) capacitor c=1.82895e-17
    cinet28_1 (net28_16 VSS) capacitor c=1.89336e-16
    cinet28_0 (net28_17 VSS) capacitor c=3.30142e-16
    cinet13_5 (net13_3 VSS) capacitor c=5.79843e-17
    cinet13_4 (net13_4 VSS) capacitor c=1.13729e-16
    cinet13_3 (net13_6 VSS) capacitor c=2.14583e-16
    cinet13_2 (net13_7 VSS) capacitor c=1.82091e-17
    cinet13_1 (net13_10 VSS) capacitor c=5.76742e-17
    cinet13_0 (net13_11 VSS) capacitor c=1.1255e-16
    ciZN_22 (ZN_3 VSS) capacitor c=7.81992e-17
    ciZN_21 (ZN_4 VSS) capacitor c=1.01145e-16
    ciZN_20 (ZN_8 VSS) capacitor c=2.49604e-16
    ciZN_19 (ZN_15 VSS) capacitor c=3.87643e-16
    ciZN_18 (ZN_17 VSS) capacitor c=4.42021e-17
    ciZN_17 (ZN_18 VSS) capacitor c=1.53111e-17
    ciZN_16 (ZN_19 VSS) capacitor c=4.24355e-17
    ciZN_15 (ZN_20 VSS) capacitor c=1.51059e-17
    ciZN_14 (ZN VSS) capacitor c=2.59231e-17
    ciZN_13 (MMI1_ELT_d VSS) capacitor c=9.78436e-18
    ciZN_12 (ZN_28 VSS) capacitor c=1.44525e-18
    ciZN_11 (ZN_29 VSS) capacitor c=3.6241e-18
    ciZN_10 (ZN_31 VSS) capacitor c=4.40141e-18
    ciZN_9 (ZN_35 VSS) capacitor c=5.6876e-18
    ciZN_8 (ZN_42 VSS) capacitor c=2.27931e-18
    ciZN_7 (MMU5_ELT_d VSS) capacitor c=2.96082e-17
    ciZN_6 (ZN_48 VSS) capacitor c=1.41789e-18
    ciZN_5 (ZN_49 VSS) capacitor c=4.63285e-18
    ciZN_4 (ZN_51 VSS) capacitor c=5.96593e-18
    ciZN_3 (ZN_55 VSS) capacitor c=7.01981e-18
    ciZN_2 (ZN_57 VSS) capacitor c=1.07074e-18
    ciZN_1 (ZN_60 VSS) capacitor c=1.32762e-17
    ciZN_0 (ZN_64 VSS) capacitor c=2.21501e-18
    cinet33_9 (net33_3 VSS) capacitor c=1.90954e-16
    cinet33_8 (net33_4 VSS) capacitor c=3.2986e-16
    cinet33_7 (net33_12 VSS) capacitor c=8.61332e-17
    cinet33_6 (net33_13 VSS) capacitor c=1.48788e-17
    cinet33_5 (net33_16 VSS) capacitor c=2.46275e-16
    cinet33_4 (net33_17 VSS) capacitor c=3.53834e-16
    cinet33_3 (net33_25 VSS) capacitor c=2.34398e-16
    cinet33_2 (net33_29 VSS) capacitor c=1.86076e-16
    cinet33_1 (net33_30 VSS) capacitor c=3.3418e-16
    cinet33_0 (net33_38 VSS) capacitor c=1.36186e-17
    cinet5_9 (net5_3 VSS) capacitor c=5.74036e-17
    cinet5_8 (net5_4 VSS) capacitor c=1.11612e-16
    cinet5_7 (net5_6 VSS) capacitor c=7.37834e-17
    cinet5_6 (net5_7 VSS) capacitor c=1.18321e-17
    cinet5_5 (net5_10 VSS) capacitor c=7.14755e-17
    cinet5_4 (net5_11 VSS) capacitor c=1.17382e-16
    cinet5_3 (net5_13 VSS) capacitor c=1.91453e-16
    cinet5_2 (net5_17 VSS) capacitor c=6.69153e-17
    cinet5_1 (net5_18 VSS) capacitor c=1.14315e-16
    cinet5_0 (net5_20 VSS) capacitor c=1.06633e-17
    ciC_14 (C_22 VSS) capacitor c=9.26871e-18
    ciC_13 (C_28 VSS) capacitor c=1.9624e-16
    ciC_12 (C_39 VSS) capacitor c=6.19724e-16
    ciC_11 (C_45 VSS) capacitor c=9.82345e-18
    ciC_10 (C_50 VSS) capacitor c=3.33152e-17
    ciC_9 (C_58 VSS) capacitor c=2.50765e-17
    ciC_8 (C_66 VSS) capacitor c=2.21303e-17
    ciC_7 (C_74 VSS) capacitor c=2.70433e-17
    ciC_6 (C_82 VSS) capacitor c=1.08232e-17
    ciC_5 (C_85 VSS) capacitor c=6.85158e-18
    ciC_4 (C_90 VSS) capacitor c=7.91452e-18
    ciC_3 (C_93 VSS) capacitor c=1.14125e-17
    ciC_2 (C VSS) capacitor c=1.05728e-16
    ciC_1 (C_194 VSS) capacitor c=6.15225e-17
    ciC_0 (C_195 VSS) capacitor c=1.18482e-17
    ciVDD_21 (VDD_2 VSS) capacitor c=6.33969e-17
    ciVDD_20 (VDD_11 VSS) capacitor c=2.45244e-16
    ciVDD_19 (VDD_19 VSS) capacitor c=2.68682e-17
    ciVDD_18 (VDD_20 VSS) capacitor c=2.9925e-17
    ciVDD_17 (VDD_27 VSS) capacitor c=2.52875e-16
    ciVDD_16 (VDD_35 VSS) capacitor c=1.91462e-17
    ciVDD_15 (VDD_44 VSS) capacitor c=2.35584e-16
    ciVDD_14 (VDD_47 VSS) capacitor c=3.58509e-18
    ciVDD_13 (VDD_48 VSS) capacitor c=3.58509e-18
    ciVDD_12 (VDD_54 VSS) capacitor c=1.32762e-17
    ciVDD_11 (VDD_56 VSS) capacitor c=7.90066e-18
    ciVDD_10 (VDD_59 VSS) capacitor c=1.11099e-18
    ciVDD_9 (VDD_63 VSS) capacitor c=1.11099e-18
    ciVDD_8 (VDD_65 VSS) capacitor c=4.95791e-18
    ciVDD_7 (VDD_67 VSS) capacitor c=1.41789e-18
    ciVDD_6 (VDD_69 VSS) capacitor c=4.62042e-18
    ciVDD_5 (VDD_70 VSS) capacitor c=5.67553e-18
    ciVDD_4 (VDD_71 VSS) capacitor c=1.44293e-17
    ciVDD_3 (VDD_74 VSS) capacitor c=2.5171e-17
    ciVDD_2 (VDD_76 VSS) capacitor c=3.74891e-16
    ciVDD_1 (VDD_78 VSS) capacitor c=8.5955e-18
    ciVDD_0 (VDD_80 VSS) capacitor c=3.76449e-16
    ciVSS_16 (VSS_2 VSS) capacitor c=6.27333e-17
    ciVSS_15 (VSS_11 VSS) capacitor c=7.40156e-17
    ciVSS_14 (VSS_12 VSS) capacitor c=1.26367e-16
    ciVSS_13 (VSS_14 VSS) capacitor c=2.92755e-17
    ciVSS_12 (VSS_21 VSS) capacitor c=8.23987e-17
    ciVSS_11 (VSS_22 VSS) capacitor c=1.18032e-16
    ciVSS_10 (VSS_32 VSS) capacitor c=2.31139e-16
    ciVSS_9 (VSS_35 VSS) capacitor c=3.58509e-18
    ciVSS_8 (VSS_36 VSS) capacitor c=3.58509e-18
    ciVSS_7 (VSS_45 VSS) capacitor c=2.87852e-18
    ciVSS_6 (VSS_51 VSS) capacitor c=3.13335e-18
    ciVSS_5 (VSS_53 VSS) capacitor c=1.44525e-18
    ciVSS_4 (VSS_55 VSS) capacitor c=3.44817e-18
    ciVSS_3 (VSS_56 VSS) capacitor c=6.12102e-18
    ciVSS_2 (VSS_57 VSS) capacitor c=1.09207e-17
    ciVSS_1 (VSS_60 VSS) capacitor c=4.90162e-18
    ciVSS_0 (VSS_66 VSS) capacitor c=1.06225e-17
    ciB_27 (B_42 VSS) capacitor c=3.00043e-18
    ciB_26 (B_48 VSS) capacitor c=2.56578e-16
    ciB_25 (B_59 VSS) capacitor c=7.81976e-16
    ciB_24 (B_65 VSS) capacitor c=3.00043e-18
    ciB_23 (B_70 VSS) capacitor c=2.2416e-17
    ciB_22 (B_78 VSS) capacitor c=1.96617e-17
    ciB_21 (B_86 VSS) capacitor c=1.69752e-17
    ciB_20 (B_94 VSS) capacitor c=1.51948e-17
    ciB_19 (B_102 VSS) capacitor c=3.00043e-18
    ciB_18 (B_105 VSS) capacitor c=3.51232e-19
    ciB_17 (B_110 VSS) capacitor c=2.57604e-18
    ciB_16 (B_113 VSS) capacitor c=3.00043e-18
    ciB_15 (B_118 VSS) capacitor c=4.21073e-18
    ciB_14 (B_124 VSS) capacitor c=1.98219e-16
    ciB_13 (B_135 VSS) capacitor c=6.17596e-16
    ciB_12 (B_141 VSS) capacitor c=4.28147e-18
    ciB_11 (B_146 VSS) capacitor c=2.87568e-17
    ciB_10 (B_154 VSS) capacitor c=2.07846e-17
    ciB_9 (B_162 VSS) capacitor c=1.53114e-17
    ciB_8 (B_170 VSS) capacitor c=2.15046e-17
    ciB_7 (B_178 VSS) capacitor c=7.44991e-18
    ciB_6 (B_181 VSS) capacitor c=4.66637e-18
    ciB_5 (B_186 VSS) capacitor c=6.3781e-18
    ciB_4 (B_189 VSS) capacitor c=7.66167e-18
    ciB_3 (B VSS) capacitor c=9.93297e-17
    ciB_2 (B_378 VSS) capacitor c=7.13823e-18
    ciB_1 (B_387 VSS) capacitor c=4.02919e-17
    ciB_0 (B_388 VSS) capacitor c=8.15261e-18
    ciA_34 (A_42 VSS) capacitor c=2.22299e-18
    ciA_33 (A_48 VSS) capacitor c=1.94762e-16
    ciA_32 (A_53 VSS) capacitor c=2.22299e-18
    ciA_31 (A_56 VSS) capacitor c=5.76791e-16
    ciA_30 (A_58 VSS) capacitor c=2.2416e-17
    ciA_29 (A_66 VSS) capacitor c=1.99422e-17
    ciA_28 (A_74 VSS) capacitor c=1.35398e-17
    ciA_27 (A_82 VSS) capacitor c=1.51948e-17
    ciA_26 (A_90 VSS) capacitor c=4.2527e-18
    ciA_25 (A_113 VSS) capacitor c=4.28147e-18
    ciA_24 (A_118 VSS) capacitor c=8.85144e-18
    ciA_23 (A_124 VSS) capacitor c=1.84653e-16
    ciA_22 (A_135 VSS) capacitor c=5.72871e-16
    ciA_21 (A_141 VSS) capacitor c=9.09614e-18
    ciA_20 (A_146 VSS) capacitor c=3.03067e-17
    ciA_19 (A_154 VSS) capacitor c=2.07846e-17
    ciA_18 (A_162 VSS) capacitor c=1.35583e-17
    ciA_17 (A_170 VSS) capacitor c=2.29923e-17
    ciA_16 (A_178 VSS) capacitor c=2.15225e-18
    ciA_15 (A_181 VSS) capacitor c=1.72402e-18
    ciA_14 (A_186 VSS) capacitor c=1.72402e-18
    ciA_13 (A_189 VSS) capacitor c=2.22299e-18
    ciA_12 (A_261 VSS) capacitor c=1.75785e-17
    ciA_11 (A_267 VSS) capacitor c=7.70652e-18
    ciA_10 (A_268 VSS) capacitor c=1.92058e-16
    ciA_9 (A_269 VSS) capacitor c=6.37569e-18
    ciA_8 (A_270 VSS) capacitor c=4.05287e-18
    ciA_7 (A_271 VSS) capacitor c=7.19785e-18
    ciA_6 (A_275 VSS) capacitor c=2.13221e-17
    ciA_5 (A_276 VSS) capacitor c=9.27805e-17
    ciA_4 (A_391 VSS) capacitor c=2.6337e-17
    ciA_3 (A_392 VSS) capacitor c=8.75884e-18
    ciA_2 (A_397 VSS) capacitor c=5.19829e-17
    ciA_1 (A_398 VSS) capacitor c=6.10891e-18
    ciA_0 (A VSS) capacitor c=6.64705e-17
    rnet28_27 (MMI2_ELT_s net28) resistor r=0.01
    rnet28_26 (net28_1 net28_10) resistor r=0.277193
    rnet28_25 (net28_1 net28_13) resistor r=0.0961165
    rnet28_24 (net28_3 net28_4) resistor r=8.66667
    rnet28_23 (net28_3 net28_7) resistor r=0.639676
    rnet28_22 (net28_4 MMU2_ELT_d) resistor r=32.3614
    rnet28_21 (net28_7 net28_8) resistor r=8.66667
    rnet28_20 (net28_7 net28_10) resistor r=0.42645
    rnet28_19 (net28_8 MMU2_ELT_d) resistor r=16.1807
    rnet28_18 (net28_8 net28_11) resistor r=32.3614
    rnet28_17 (net28_10 net28_11) resistor r=26
    rnet28_16 (net28_12 net28_13) resistor r=1.86144
    rnet28_15 (net28_12 net28_14) resistor r=0.0961165
    rnet28_14 (net28_14 net28_23) resistor r=0.277193
    rnet28_13 (net28_16 net28_17) resistor r=8.66667
    rnet28_12 (net28_16 net28_20) resistor r=0.639676
    rnet28_11 (net28_17 net28) resistor r=32.3614
    rnet28_10 (net28_20 net28_21) resistor r=8.66667
    rnet28_9 (net28_20 net28_23) resistor r=0.42645
    rnet28_8 (net28_21 net28) resistor r=16.1807
    rnet28_7 (net28_21 net28_24) resistor r=32.3614
    rnet28_6 (net28_23 net28_24) resistor r=26
    rnet13_15 (MMU6_ELT_s net13) resistor r=0.01
    rnet13_14 (net13_1 net13_3) resistor r=0.186572
    rnet13_13 (net13_1 net13_7) resistor r=0.0961165
    rnet13_12 (net13_3 net13_4) resistor r=13
    rnet13_11 (net13_4 MMI4_ELT_d) resistor r=8.44
    rnet13_10 (net13_6 net13_7) resistor r=1.83769
    rnet13_9 (net13_6 net13_8) resistor r=0.0961165
    rnet13_8 (net13_8 net13_10) resistor r=0.186572
    rnet13_7 (net13_10 net13_11) resistor r=13
    rnet13_6 (net13_11 net13) resistor r=8.44
    rZN_96 (ZN_1 ZN_3) resistor r=0.47405
    rZN_95 (ZN_1 ZN_18) resistor r=0.0961165
    rZN_94 (ZN_3 ZN_4) resistor r=13
    rZN_93 (ZN_4 MMU6_ELT_d) resistor r=4.22001
    rZN_92 (ZN_4 ZN_43) resistor r=4.22001
    rZN_91 (ZN_4 MMI1_ELT_d) resistor r=4.22001
    rZN_90 (ZN_4 ZN_41) resistor r=4.22001
    rZN_89 (ZN_6 ZN_8) resistor r=0.438935
    rZN_88 (ZN_6 ZN_20) resistor r=0.0961165
    rZN_87 (ZN_8 ZN_15) resistor r=8.66667
    rZN_86 (ZN_8 ZN_11) resistor r=0.702296
    rZN_85 (ZN_11 ZN_15) resistor r=8.66667
    rZN_84 (ZN_11 ZN_14) resistor r=0.468198
    rZN_83 (ZN_14 ZN_15) resistor r=13
    rZN_82 (ZN_15 MMI2_ELT_d) resistor r=4.04518
    rZN_81 (ZN_15 ZN_63) resistor r=4.04518
    rZN_80 (ZN_15 MMU5_ELT_d) resistor r=4.04518
    rZN_79 (ZN_15 ZN_61) resistor r=4.04518
    rZN_78 (ZN_17 ZN_18) resistor r=0.597153
    rZN_77 (ZN_17 ZN_21) resistor r=0.0961165
    rZN_76 (ZN_19 ZN_20) resistor r=0.524775
    rZN_75 (ZN_19 ZN_22) resistor r=0.0961165
    rZN_74 (ZN_21 ZN) resistor r=0.174477
    rZN_73 (ZN_22 ZN) resistor r=0.174477
    rZN_72 (MMI1_ELT_d ZN_26) resistor r=18.0507
    rZN_71 (MMI1_ELT_d ZN_29) resistor r=2.67027
    rZN_70 (MMI1_ELT_d ZN_31) resistor r=12.8495
    rZN_69 (MMI1_ELT_d ZN_31) resistor r=1.69926
    rZN_68 (ZN_26 ZN_28) resistor r=9.43134
    rZN_67 (ZN_27 ZN_29) resistor r=15.1041
    rZN_66 (ZN_27 ZN_42) resistor r=11.0157
    rZN_65 (ZN_28 ZN_29) resistor r=15.1041
    rZN_64 (ZN_30 ZN_31) resistor r=12.8495
    rZN_63 (ZN_30 ZN_44) resistor r=10.6787
    rZN_62 (MMU6_ELT_d ZN_35) resistor r=2.67027
    rZN_61 (MMU6_ELT_d ZN_37) resistor r=12.8495
    rZN_60 (MMU6_ELT_d ZN_37) resistor r=1.69926
    rZN_59 (MMU6_ELT_d ZN_40) resistor r=4.557
    rZN_58 (MMU6_ELT_d ZN_44) resistor r=10.6787
    rZN_57 (ZN_33 ZN_35) resistor r=15.1041
    rZN_56 (ZN_33 ZN_38) resistor r=9.43134
    rZN_55 (ZN_34 ZN_35) resistor r=15.1041
    rZN_54 (ZN_34 ZN_42) resistor r=11.0157
    rZN_53 (ZN_36 ZN_37) resistor r=12.8495
    rZN_52 (ZN_36 ZN_39) resistor r=9.4369
    rZN_51 (ZN_38 ZN_40) resistor r=21.1301
    rZN_50 (ZN_39 ZN_40) resistor r=21.1301
    rZN_49 (ZN_41 ZN_42) resistor r=0.762262
    rZN_48 (ZN_43 ZN_44) resistor r=0.57282
    rZN_47 (MMU5_ELT_d ZN_46) resistor r=25.7298
    rZN_46 (MMU5_ELT_d ZN_49) resistor r=2.55965
    rZN_45 (MMU5_ELT_d ZN_51) resistor r=12.3172
    rZN_44 (MMU5_ELT_d ZN_51) resistor r=1.62887
    rZN_43 (ZN_46 ZN_48) resistor r=9.04062
    rZN_42 (ZN_47 ZN_49) resistor r=14.4784
    rZN_41 (ZN_47 ZN_64) resistor r=10.5593
    rZN_40 (ZN_48 ZN_49) resistor r=14.4784
    rZN_39 (ZN_50 ZN_51) resistor r=12.3172
    rZN_38 (ZN_50 ZN_62) resistor r=10.2363
    rZN_37 (MMI2_ELT_d ZN_55) resistor r=2.55965
    rZN_36 (MMI2_ELT_d ZN_57) resistor r=12.3172
    rZN_35 (MMI2_ELT_d ZN_57) resistor r=1.62887
    rZN_34 (MMI2_ELT_d ZN_60) resistor r=6.12113
    rZN_33 (MMI2_ELT_d ZN_62) resistor r=10.2363
    rZN_32 (ZN_53 ZN_55) resistor r=14.4784
    rZN_31 (ZN_53 ZN_59) resistor r=9.04062
    rZN_30 (ZN_54 ZN_55) resistor r=14.4784
    rZN_29 (ZN_54 ZN_64) resistor r=10.5593
    rZN_28 (ZN_56 ZN_57) resistor r=12.3172
    rZN_27 (ZN_56 ZN_58) resistor r=9.04595
    rZN_26 (ZN_58 ZN_60) resistor r=31.2341
    rZN_25 (ZN_59 ZN_60) resistor r=31.2341
    rZN_24 (ZN_61 ZN_62) resistor r=0.549089
    rZN_23 (ZN_63 ZN_64) resistor r=0.730683
    rnet33_44 (MMU5_ELT_s net33) resistor r=0.01
    rnet33_43 (net33_1 net33_3) resistor r=0.522402
    rnet33_42 (net33_1 net33_13) resistor r=0.0961165
    rnet33_41 (net33_3 net33_4) resistor r=8.66667
    rnet33_40 (net33_3 net33_6) resistor r=0.639676
    rnet33_39 (net33_4 MMI3_ELT_d) resistor r=32.3614
    rnet33_38 (net33_6 net33_7) resistor r=8.66667
    rnet33_37 (net33_6 net33_9) resistor r=0.42645
    rnet33_36 (net33_7 MMI3_ELT_d) resistor r=16.1807
    rnet33_35 (net33_7 net33_10) resistor r=32.3614
    rnet33_34 (net33_9 net33_10) resistor r=26
    rnet33_33 (net33_12 net33_13) resistor r=0.721096
    rnet33_32 (net33_12 net33_38) resistor r=0.0728441
    rnet33_31 (net33_14 net33_16) resistor r=0.573542
    rnet33_30 (net33_14 net33_38) resistor r=0.0189309
    rnet33_29 (net33_16 net33_17) resistor r=8.66667
    rnet33_28 (net33_16 net33_19) resistor r=0.702296
    rnet33_27 (net33_17 MMU4_ELT_d) resistor r=32.3614
    rnet33_26 (net33_19 net33_20) resistor r=8.66667
    rnet33_25 (net33_19 net33_22) resistor r=0.468198
    rnet33_24 (net33_20 MMU4_ELT_d) resistor r=16.1807
    rnet33_23 (net33_20 net33_23) resistor r=32.3614
    rnet33_22 (net33_22 net33_23) resistor r=26
    rnet33_21 (net33_25 net33_26) resistor r=1.86144
    rnet33_20 (net33_25 net33_27) resistor r=0.0961165
    rnet33_19 (net33_26 net33_38) resistor r=0.0728441
    rnet33_18 (net33_27 net33_29) resistor r=0.522402
    rnet33_17 (net33_29 net33_30) resistor r=8.66667
    rnet33_16 (net33_29 net33_32) resistor r=0.639676
    rnet33_15 (net33_30 net33) resistor r=32.3614
    rnet33_14 (net33_32 net33_33) resistor r=8.66667
    rnet33_13 (net33_32 net33_35) resistor r=0.42645
    rnet33_12 (net33_33 net33) resistor r=16.1807
    rnet33_11 (net33_33 net33_36) resistor r=32.3614
    rnet33_10 (net33_35 net33_36) resistor r=26
    rnet5_26 (MMI1_ELT_s net5) resistor r=0.01
    rnet5_25 (net5_1 net5_3) resistor r=0.437112
    rnet5_24 (net5_1 net5_7) resistor r=0.0961165
    rnet5_23 (net5_3 net5_4) resistor r=13
    rnet5_22 (net5_4 MMU9_ELT_d) resistor r=8.44
    rnet5_21 (net5_6 net5_7) resistor r=0.693989
    rnet5_20 (net5_6 net5_20) resistor r=0.0728441
    rnet5_19 (net5_8 net5_10) resistor r=0.479903
    rnet5_18 (net5_8 net5_20) resistor r=0.0189309
    rnet5_17 (net5_10 net5_11) resistor r=13
    rnet5_16 (net5_11 MMI5_ELT_d) resistor r=8.44
    rnet5_15 (net5_13 net5_14) resistor r=1.79146
    rnet5_14 (net5_13 net5_15) resistor r=0.0961165
    rnet5_13 (net5_14 net5_20) resistor r=0.0728441
    rnet5_12 (net5_15 net5_17) resistor r=0.437112
    rnet5_11 (net5_17 net5_18) resistor r=13
    rnet5_10 (net5_18 net5) resistor r=8.44
    rC_96 (C_22 C_28) resistor r=58.3583
    rC_95 (C_22 C_28) resistor r=4.16253
    rC_94 (C_22 C_28) resistor r=58.3583
    rC_93 (C_22 C_28) resistor r=4.16253
    rC_92 (C_25 C_28) resistor r=58.3583
    rC_91 (C_25 C_28) resistor r=6.30933
    rC_90 (C_25 C_28) resistor r=58.3583
    rC_89 (C_25 C_28) resistor r=6.30933
    rC_88 (C_28 C_30) resistor r=14.9
    rC_87 (C_28 C_53) resistor r=24.8333
    rC_86 (C_28 C_50) resistor r=24.8333
    rC_85 (C_28 C_61) resistor r=24.8333
    rC_84 (C_28 C_58) resistor r=24.8333
    rC_83 (C_28 C_82) resistor r=58.3583
    rC_82 (C_28 C_85) resistor r=58.3583
    rC_81 (C_28 C_53) resistor r=4.16253
    rC_80 (C_28 C_30) resistor r=6.30933
    rC_79 (C_28 C_61) resistor r=1.63969
    rC_78 (C_28 C_50) resistor r=4.16253
    rC_77 (C_28 C_82) resistor r=4.16253
    rC_76 (C_28 C_58) resistor r=4.16253
    rC_75 (C_28 C_85) resistor r=4.16253
    rC_74 (C_28 C_30) resistor r=14.9
    rC_73 (C_28 C_162) resistor r=40.975
    rC_72 (C_28 C_53) resistor r=24.8333
    rC_71 (C_28 C_50) resistor r=24.8333
    rC_70 (C_28 C_61) resistor r=24.8333
    rC_69 (C_28 C_58) resistor r=24.8333
    rC_68 (C_28 C_82) resistor r=58.3583
    rC_67 (C_28 MMI1_ELT_g) resistor r=7.45
    rC_66 (C_28 C_53) resistor r=4.16253
    rC_65 (C_28 C_30) resistor r=6.30933
    rC_64 (C_28 C_61) resistor r=1.63969
    rC_63 (C_28 C_50) resistor r=4.16253
    rC_62 (C_28 C_82) resistor r=4.16253
    rC_61 (C_28 C_58) resistor r=4.16253
    rC_60 (C_28 C_85) resistor r=4.16253
    rC_59 (C_36 C_39) resistor r=14.9
    rC_58 (C_36 C_39) resistor r=6.30933
    rC_57 (C_36 C_39) resistor r=14.9
    rC_56 (C_36 C_39) resistor r=6.30933
    rC_55 (C_39 C_42) resistor r=202.392
    rC_54 (C_39 C_45) resistor r=202.392
    rC_53 (C_39 C_69) resistor r=24.8333
    rC_52 (C_39 C_66) resistor r=24.8333
    rC_51 (C_39 C_77) resistor r=24.8333
    rC_50 (C_39 C_74) resistor r=24.8333
    rC_49 (C_39 C_90) resistor r=202.392
    rC_48 (C_39 C_93) resistor r=202.392
    rC_47 (C_39 C_42) resistor r=6.30933
    rC_46 (C_39 C_69) resistor r=1.63969
    rC_45 (C_39 C_77) resistor r=4.16253
    rC_44 (C_39 C_45) resistor r=4.16253
    rC_43 (C_39 C_66) resistor r=4.16253
    rC_42 (C_39 C_90) resistor r=4.16253
    rC_41 (C_39 C_74) resistor r=4.16253
    rC_40 (C_39 C_93) resistor r=4.16253
    rC_39 (C_39 C_164) resistor r=40.975
    rC_38 (C_39 C_42) resistor r=202.392
    rC_37 (C_39 C_45) resistor r=202.392
    rC_36 (C_39 C_69) resistor r=24.8333
    rC_35 (C_39 C_66) resistor r=24.8333
    rC_34 (C_39 C_77) resistor r=24.8333
    rC_33 (C_39 C_74) resistor r=24.8333
    rC_32 (C_39 C_90) resistor r=202.392
    rC_31 (C_39 MMU5_ELT_g) resistor r=7.45
    rC_30 (C_39 C_42) resistor r=6.30933
    rC_29 (C_39 C_69) resistor r=1.63969
    rC_28 (C_39 C_77) resistor r=4.16253
    rC_27 (C_39 C_45) resistor r=4.16253
    rC_26 (C_39 C_66) resistor r=4.16253
    rC_25 (C_39 C_90) resistor r=4.16253
    rC_24 (C_39 C_74) resistor r=4.16253
    rC_23 (C_39 C_93) resistor r=4.16253
    rC_22 (C_85 MMI1_ELT_g) resistor r=50.9083
    rC_21 (C_93 MMU5_ELT_g) resistor r=194.942
    rC_20 (C_132 C_133) resistor r=10
    rC_19 (C_132 C) resistor r=0.0892921
    rC_18 (C_133 C_194) resistor r=41.3136
    rC_17 (C_162 C_195) resistor r=10.0997
    rC_16 (C_164 C_195) resistor r=10.0997
    rC_15 (C_194 C_195) resistor r=0.877078
    rVDD_103 (MMU4_ELT_b MMI3_ELT_b) resistor r=0.01
    rVDD_102 (MMU2_ELT_b MMI3_ELT_b) resistor r=0.01
    rVDD_101 (MMU5_ELT_b MMI3_ELT_b) resistor r=0.01
    rVDD_100 (MMI2_ELT_b MMI3_ELT_b) resistor r=0.01
    rVDD_99 (MMI3_ELT_b VDD_38) resistor r=8.66667
    rVDD_98 (MMI3_ELT_b VDD_24) resistor r=67.52
    rVDD_97 (MMI3_ELT_b VDD_42) resistor r=67.52
    rVDD_96 (VDD_2 VDD_7) resistor r=0.114672
    rVDD_95 (VDD_2 VDD_47) resistor r=0.0221619
    rVDD_94 (VDD VDD_7) resistor r=0.102809
    rVDD_93 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_92 (VDD_8 VDD_24) resistor r=67.52
    rVDD_91 (VDD_9 VDD_18) resistor r=0.415525
    rVDD_90 (VDD_9 VDD_47) resistor r=0.0882581
    rVDD_89 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_88 (VDD_11 VDD_15) resistor r=0.702296
    rVDD_87 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_86 (VDD_15 VDD_18) resistor r=0.702296
    rVDD_85 (VDD_18 VDD_19) resistor r=8.66667
    rVDD_84 (VDD_19 MMU4_ELT_s) resistor r=0.850556
    rVDD_83 (VDD_19 MMI3_ELT_s) resistor r=0.850556
    rVDD_82 (VDD_19 VDD_75) resistor r=13.0961
    rVDD_81 (VDD_20 VDD_23) resistor r=0.0830382
    rVDD_80 (VDD_20 VDD_48) resistor r=0.0221619
    rVDD_79 (VDD_21 VDD_23) resistor r=0.0869924
    rVDD_78 (VDD_21 VDD_47) resistor r=0.0221619
    rVDD_77 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_76 (VDD_25 VDD_34) resistor r=0.415525
    rVDD_75 (VDD_25 VDD_48) resistor r=0.0882581
    rVDD_74 (VDD_27 VDD_35) resistor r=8.66667
    rVDD_73 (VDD_27 VDD_31) resistor r=0.702296
    rVDD_72 (VDD_31 VDD_35) resistor r=8.66667
    rVDD_71 (VDD_31 VDD_34) resistor r=0.702296
    rVDD_70 (VDD_34 VDD_35) resistor r=8.66667
    rVDD_69 (VDD_35 MMU2_ELT_s) resistor r=4.04518
    rVDD_68 (VDD_35 VDD_79) resistor r=4.04518
    rVDD_67 (VDD_35 MMU4_ELT_s) resistor r=4.04518
    rVDD_66 (VDD_35 VDD_77) resistor r=4.04518
    rVDD_65 (VDD_36 VDD_38) resistor r=0.118797
    rVDD_64 (VDD_36 VDD_48) resistor r=0.0221619
    rVDD_63 (VDD_38 VDD_41) resistor r=0.237594
    rVDD_62 (VDD_41 VDD_42) resistor r=8.66667
    rVDD_61 (VDD_41 VDD_44) resistor r=0.237594
    rVDD_60 (VDD_42 VDD_45) resistor r=67.52
    rVDD_59 (VDD_44 VDD_45) resistor r=8.66667
    rVDD_58 (VDD_51 VDD_54) resistor r=31.2341
    rVDD_57 (VDD_51 VDD_55) resistor r=9.04595
    rVDD_56 (VDD_52 VDD_54) resistor r=31.2341
    rVDD_55 (VDD_52 VDD_58) resistor r=9.04062
    rVDD_54 (MMI3_ELT_s VDD_54) resistor r=6.12113
    rVDD_53 (MMI3_ELT_s VDD_56) resistor r=12.3172
    rVDD_52 (MMI3_ELT_s VDD_56) resistor r=1.62887
    rVDD_51 (MMI3_ELT_s VDD_59) resistor r=2.55965
    rVDD_50 (VDD_55 VDD_56) resistor r=12.3172
    rVDD_49 (VDD_57 VDD_59) resistor r=14.4784
    rVDD_48 (VDD_57 VDD_76) resistor r=10.5593
    rVDD_47 (VDD_58 VDD_59) resistor r=14.4784
    rVDD_46 (MMU4_ELT_s VDD_63) resistor r=2.55965
    rVDD_45 (MMU4_ELT_s VDD_65) resistor r=12.3172
    rVDD_44 (MMU4_ELT_s VDD_65) resistor r=1.62887
    rVDD_43 (VDD_61 VDD_63) resistor r=14.4784
    rVDD_42 (VDD_61 VDD_80) resistor r=10.5593
    rVDD_41 (VDD_62 VDD_63) resistor r=14.4784
    rVDD_40 (VDD_62 VDD_76) resistor r=10.5593
    rVDD_39 (VDD_64 VDD_65) resistor r=12.3172
    rVDD_38 (VDD_64 VDD_78) resistor r=10.2363
    rVDD_37 (MMU2_ELT_s VDD_69) resistor r=2.55965
    rVDD_36 (MMU2_ELT_s VDD_71) resistor r=12.3172
    rVDD_35 (MMU2_ELT_s VDD_71) resistor r=1.62887
    rVDD_34 (MMU2_ELT_s VDD_74) resistor r=6.12113
    rVDD_33 (MMU2_ELT_s VDD_78) resistor r=10.2363
    rVDD_32 (VDD_67 VDD_69) resistor r=14.4784
    rVDD_31 (VDD_67 VDD_73) resistor r=9.04062
    rVDD_30 (VDD_68 VDD_69) resistor r=14.4784
    rVDD_29 (VDD_68 VDD_80) resistor r=10.5593
    rVDD_28 (VDD_70 VDD_71) resistor r=12.3172
    rVDD_27 (VDD_70 VDD_72) resistor r=9.04595
    rVDD_26 (VDD_72 VDD_74) resistor r=31.2341
    rVDD_25 (VDD_73 VDD_74) resistor r=31.2341
    rVDD_24 (VDD_75 VDD_76) resistor r=0.730683
    rVDD_23 (VDD_77 VDD_78) resistor r=0.549089
    rVDD_22 (VDD_79 VDD_80) resistor r=0.730683
    rVSS_90 (MMI5_ELT_b MMU9_ELT_b) resistor r=0.01
    rVSS_89 (MMI4_ELT_b MMU9_ELT_b) resistor r=0.01
    rVSS_88 (MMI1_ELT_b MMU9_ELT_b) resistor r=0.01
    rVSS_87 (MMU6_ELT_b MMU9_ELT_b) resistor r=0.01
    rVSS_86 (MMU9_ELT_b VSS_26) resistor r=8.66667
    rVSS_85 (MMU9_ELT_b VSS_18) resistor r=64.7228
    rVSS_84 (MMU9_ELT_b VSS_30) resistor r=64.7228
    rVSS_83 (VSS_2 VSS_7) resistor r=0.114672
    rVSS_82 (VSS_2 VSS_35) resistor r=0.0221619
    rVSS_81 (VSS VSS_7) resistor r=0.100832
    rVSS_80 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_79 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_78 (VSS_9 VSS_11) resistor r=0.444788
    rVSS_77 (VSS_9 VSS_35) resistor r=0.0882581
    rVSS_76 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_75 (VSS_12 MMI5_ELT_s) resistor r=2.27123
    rVSS_74 (VSS_12 MMU9_ELT_s) resistor r=2.27123
    rVSS_73 (VSS_12 VSS_61) resistor r=8.4738
    rVSS_72 (VSS_14 VSS_17) resistor r=0.0830382
    rVSS_71 (VSS_14 VSS_36) resistor r=0.0221619
    rVSS_70 (VSS_15 VSS_17) resistor r=0.0869924
    rVSS_69 (VSS_15 VSS_35) resistor r=0.0221619
    rVSS_68 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_67 (VSS_19 VSS_21) resistor r=0.444788
    rVSS_66 (VSS_19 VSS_36) resistor r=0.0882581
    rVSS_65 (VSS_21 VSS_22) resistor r=8.66667
    rVSS_64 (VSS_22 MMI4_ELT_s) resistor r=4.22001
    rVSS_63 (VSS_22 VSS_65) resistor r=4.22001
    rVSS_62 (VSS_22 MMI5_ELT_s) resistor r=4.22001
    rVSS_61 (VSS_22 VSS_63) resistor r=4.22001
    rVSS_60 (VSS_24 VSS_26) resistor r=0.118797
    rVSS_59 (VSS_24 VSS_36) resistor r=0.0221619
    rVSS_58 (VSS_26 VSS_29) resistor r=0.237594
    rVSS_57 (VSS_29 VSS_30) resistor r=8.66667
    rVSS_56 (VSS_29 VSS_32) resistor r=0.237594
    rVSS_55 (VSS_30 VSS_33) resistor r=64.7228
    rVSS_54 (VSS_32 VSS_33) resistor r=8.66667
    rVSS_53 (VSS_37 VSS_40) resistor r=21.1301
    rVSS_52 (VSS_37 VSS_42) resistor r=9.43134
    rVSS_51 (VSS_38 VSS_40) resistor r=21.1301
    rVSS_50 (VSS_38 VSS_44) resistor r=9.4369
    rVSS_49 (MMU9_ELT_s VSS_40) resistor r=4.557
    rVSS_48 (MMU9_ELT_s VSS_43) resistor r=2.67027
    rVSS_47 (MMU9_ELT_s VSS_45) resistor r=12.8495
    rVSS_46 (MMU9_ELT_s VSS_45) resistor r=1.69926
    rVSS_45 (VSS_41 VSS_43) resistor r=15.1041
    rVSS_44 (VSS_41 VSS_62) resistor r=11.0157
    rVSS_43 (VSS_42 VSS_43) resistor r=15.1041
    rVSS_42 (VSS_44 VSS_45) resistor r=12.8495
    rVSS_41 (MMI5_ELT_s VSS_49) resistor r=2.67027
    rVSS_40 (MMI5_ELT_s VSS_51) resistor r=12.8495
    rVSS_39 (MMI5_ELT_s VSS_51) resistor r=1.69926
    rVSS_38 (VSS_47 VSS_49) resistor r=15.1041
    rVSS_37 (VSS_47 VSS_64) resistor r=11.0157
    rVSS_36 (VSS_48 VSS_49) resistor r=15.1041
    rVSS_35 (VSS_48 VSS_62) resistor r=11.0157
    rVSS_34 (VSS_50 VSS_51) resistor r=12.8495
    rVSS_33 (VSS_50 VSS_66) resistor r=10.6787
    rVSS_32 (MMI4_ELT_s VSS_55) resistor r=2.67027
    rVSS_31 (MMI4_ELT_s VSS_57) resistor r=12.8495
    rVSS_30 (MMI4_ELT_s VSS_57) resistor r=1.69926
    rVSS_29 (MMI4_ELT_s VSS_60) resistor r=4.557
    rVSS_28 (MMI4_ELT_s VSS_66) resistor r=10.6787
    rVSS_27 (VSS_53 VSS_55) resistor r=15.1041
    rVSS_26 (VSS_53 VSS_58) resistor r=9.43134
    rVSS_25 (VSS_54 VSS_55) resistor r=15.1041
    rVSS_24 (VSS_54 VSS_64) resistor r=11.0157
    rVSS_23 (VSS_56 VSS_57) resistor r=12.8495
    rVSS_22 (VSS_56 VSS_59) resistor r=9.4369
    rVSS_21 (VSS_58 VSS_60) resistor r=21.1301
    rVSS_20 (VSS_59 VSS_60) resistor r=21.1301
    rVSS_19 (VSS_61 VSS_62) resistor r=0.762262
    rVSS_18 (VSS_63 VSS_64) resistor r=0.762262
    rVSS_17 (VSS_65 VSS_66) resistor r=0.57282
    rB_188 (B_42 B_48) resistor r=58.3583
    rB_187 (B_42 B_48) resistor r=4.16253
    rB_186 (B_42 B_48) resistor r=58.3583
    rB_185 (B_42 B_48) resistor r=4.16253
    rB_184 (B_45 B_48) resistor r=58.3583
    rB_183 (B_45 B_48) resistor r=6.30933
    rB_182 (B_45 B_48) resistor r=58.3583
    rB_181 (B_45 B_48) resistor r=6.30933
    rB_180 (B_48 B_50) resistor r=14.9
    rB_179 (B_48 B_73) resistor r=24.8333
    rB_178 (B_48 B_70) resistor r=24.8333
    rB_177 (B_48 B_81) resistor r=24.8333
    rB_176 (B_48 B_78) resistor r=24.8333
    rB_175 (B_48 B_102) resistor r=58.3583
    rB_174 (B_48 B_105) resistor r=58.3583
    rB_173 (B_48 B_73) resistor r=4.16253
    rB_172 (B_48 B_50) resistor r=6.30933
    rB_171 (B_48 B_81) resistor r=1.63969
    rB_170 (B_48 B_70) resistor r=4.16253
    rB_169 (B_48 B_102) resistor r=4.16253
    rB_168 (B_48 B_78) resistor r=4.16253
    rB_167 (B_48 B_105) resistor r=4.16253
    rB_166 (B_48 B_50) resistor r=14.9
    rB_165 (B_48 B_311) resistor r=40.975
    rB_164 (B_48 B_73) resistor r=24.8333
    rB_163 (B_48 B_70) resistor r=24.8333
    rB_162 (B_48 B_81) resistor r=24.8333
    rB_161 (B_48 B_78) resistor r=24.8333
    rB_160 (B_48 B_102) resistor r=58.3583
    rB_159 (B_48 MMI5_ELT_g) resistor r=7.45
    rB_158 (B_48 B_73) resistor r=4.16253
    rB_157 (B_48 B_50) resistor r=6.30933
    rB_156 (B_48 B_81) resistor r=1.63969
    rB_155 (B_48 B_70) resistor r=4.16253
    rB_154 (B_48 B_102) resistor r=4.16253
    rB_153 (B_48 B_78) resistor r=4.16253
    rB_152 (B_48 B_105) resistor r=4.16253
    rB_151 (B_56 B_59) resistor r=14.9
    rB_150 (B_56 B_59) resistor r=6.30933
    rB_149 (B_56 B_59) resistor r=14.9
    rB_148 (B_56 B_59) resistor r=6.30933
    rB_147 (B_59 B_62) resistor r=202.392
    rB_146 (B_59 B_65) resistor r=202.392
    rB_145 (B_59 B_89) resistor r=24.8333
    rB_144 (B_59 B_86) resistor r=24.8333
    rB_143 (B_59 B_97) resistor r=24.8333
    rB_142 (B_59 B_94) resistor r=24.8333
    rB_141 (B_59 B_110) resistor r=202.392
    rB_140 (B_59 B_113) resistor r=202.392
    rB_139 (B_59 B_62) resistor r=6.30933
    rB_138 (B_59 B_89) resistor r=1.63969
    rB_137 (B_59 B_97) resistor r=4.16253
    rB_136 (B_59 B_65) resistor r=4.16253
    rB_135 (B_59 B_86) resistor r=4.16253
    rB_134 (B_59 B_110) resistor r=4.16253
    rB_133 (B_59 B_94) resistor r=4.16253
    rB_132 (B_59 B_113) resistor r=4.16253
    rB_131 (B_59 B_313) resistor r=40.975
    rB_130 (B_59 B_62) resistor r=202.392
    rB_129 (B_59 B_65) resistor r=202.392
    rB_128 (B_59 B_89) resistor r=24.8333
    rB_127 (B_59 B_86) resistor r=24.8333
    rB_126 (B_59 B_97) resistor r=24.8333
    rB_125 (B_59 B_94) resistor r=24.8333
    rB_124 (B_59 B_110) resistor r=202.392
    rB_123 (B_59 MMU4_ELT_g) resistor r=7.45
    rB_122 (B_59 B_62) resistor r=6.30933
    rB_121 (B_59 B_89) resistor r=1.63969
    rB_120 (B_59 B_97) resistor r=4.16253
    rB_119 (B_59 B_65) resistor r=4.16253
    rB_118 (B_59 B_86) resistor r=4.16253
    rB_117 (B_59 B_110) resistor r=4.16253
    rB_116 (B_59 B_94) resistor r=4.16253
    rB_115 (B_59 B_113) resistor r=4.16253
    rB_114 (B_105 MMI5_ELT_g) resistor r=50.9083
    rB_113 (B_113 MMU4_ELT_g) resistor r=194.942
    rB_112 (B_118 B_124) resistor r=58.3583
    rB_111 (B_118 B_124) resistor r=4.16253
    rB_110 (B_118 B_124) resistor r=58.3583
    rB_109 (B_118 B_124) resistor r=4.16253
    rB_108 (B_121 B_124) resistor r=58.3583
    rB_107 (B_121 B_124) resistor r=6.30933
    rB_106 (B_121 B_124) resistor r=58.3583
    rB_105 (B_121 B_124) resistor r=6.30933
    rB_104 (B_124 B_126) resistor r=14.9
    rB_103 (B_124 B_149) resistor r=24.8333
    rB_102 (B_124 B_146) resistor r=24.8333
    rB_101 (B_124 B_157) resistor r=24.8333
    rB_100 (B_124 B_154) resistor r=24.8333
    rB_99 (B_124 B_178) resistor r=58.3583
    rB_98 (B_124 B_181) resistor r=58.3583
    rB_97 (B_124 B_149) resistor r=4.16253
    rB_96 (B_124 B_126) resistor r=6.30933
    rB_95 (B_124 B_157) resistor r=1.63969
    rB_94 (B_124 B_146) resistor r=4.16253
    rB_93 (B_124 B_178) resistor r=4.16253
    rB_92 (B_124 B_154) resistor r=4.16253
    rB_91 (B_124 B_181) resistor r=4.16253
    rB_90 (B_124 B_126) resistor r=14.9
    rB_89 (B_124 B_345) resistor r=40.975
    rB_88 (B_124 B_149) resistor r=24.8333
    rB_87 (B_124 B_146) resistor r=24.8333
    rB_86 (B_124 B_157) resistor r=24.8333
    rB_85 (B_124 B_154) resistor r=24.8333
    rB_84 (B_124 B_178) resistor r=58.3583
    rB_83 (B_124 MMI4_ELT_g) resistor r=7.45
    rB_82 (B_124 B_149) resistor r=4.16253
    rB_81 (B_124 B_126) resistor r=6.30933
    rB_80 (B_124 B_157) resistor r=1.63969
    rB_79 (B_124 B_146) resistor r=4.16253
    rB_78 (B_124 B_178) resistor r=4.16253
    rB_77 (B_124 B_154) resistor r=4.16253
    rB_76 (B_124 B_181) resistor r=4.16253
    rB_75 (B_132 B_135) resistor r=14.9
    rB_74 (B_132 B_135) resistor r=6.30933
    rB_73 (B_132 B_135) resistor r=14.9
    rB_72 (B_132 B_135) resistor r=6.30933
    rB_71 (B_135 B_138) resistor r=202.392
    rB_70 (B_135 B_141) resistor r=202.392
    rB_69 (B_135 B_165) resistor r=24.8333
    rB_68 (B_135 B_162) resistor r=24.8333
    rB_67 (B_135 B_173) resistor r=24.8333
    rB_66 (B_135 B_170) resistor r=24.8333
    rB_65 (B_135 B_186) resistor r=202.392
    rB_64 (B_135 B_189) resistor r=202.392
    rB_63 (B_135 B_138) resistor r=6.30933
    rB_62 (B_135 B_165) resistor r=1.63969
    rB_61 (B_135 B_173) resistor r=4.16253
    rB_60 (B_135 B_141) resistor r=4.16253
    rB_59 (B_135 B_162) resistor r=4.16253
    rB_58 (B_135 B_186) resistor r=4.16253
    rB_57 (B_135 B_170) resistor r=4.16253
    rB_56 (B_135 B_189) resistor r=4.16253
    rB_55 (B_135 B_347) resistor r=40.975
    rB_54 (B_135 B_138) resistor r=202.392
    rB_53 (B_135 B_141) resistor r=202.392
    rB_52 (B_135 B_165) resistor r=24.8333
    rB_51 (B_135 B_162) resistor r=24.8333
    rB_50 (B_135 B_173) resistor r=24.8333
    rB_49 (B_135 B_170) resistor r=24.8333
    rB_48 (B_135 B_186) resistor r=202.392
    rB_47 (B_135 MMU2_ELT_g) resistor r=7.45
    rB_46 (B_135 B_138) resistor r=6.30933
    rB_45 (B_135 B_165) resistor r=1.63969
    rB_44 (B_135 B_173) resistor r=4.16253
    rB_43 (B_135 B_141) resistor r=4.16253
    rB_42 (B_135 B_162) resistor r=4.16253
    rB_41 (B_135 B_186) resistor r=4.16253
    rB_40 (B_135 B_170) resistor r=4.16253
    rB_39 (B_135 B_189) resistor r=4.16253
    rB_38 (B_181 MMI4_ELT_g) resistor r=50.9083
    rB_37 (B_189 MMU2_ELT_g) resistor r=194.942
    rB_36 (B_263 B) resistor r=10
    rB_35 (B_263 B_377) resistor r=3.38636
    rB_34 (B_263 B_387) resistor r=58.9227
    rB_33 (B_311 B_378) resistor r=10.0997
    rB_32 (B_313 B_378) resistor r=10.0997
    rB_31 (B_345 B_388) resistor r=10.0997
    rB_30 (B_347 B_388) resistor r=10.0997
    rB_29 (B_377 B_378) resistor r=0.877078
    rB_28 (B_387 B_388) resistor r=0.877078
    rA_206 (A_42 A_48) resistor r=58.3583
    rA_205 (A_42 A_48) resistor r=4.16253
    rA_204 (A_42 A_48) resistor r=58.3583
    rA_203 (A_42 A_48) resistor r=4.16253
    rA_202 (A_45 A_48) resistor r=58.3583
    rA_201 (A_45 A_48) resistor r=4.16253
    rA_200 (A_45 A_48) resistor r=58.3583
    rA_199 (A_45 A_48) resistor r=4.16253
    rA_198 (A_48 A_61) resistor r=24.8333
    rA_197 (A_48 A_58) resistor r=24.8333
    rA_196 (A_48 A_69) resistor r=24.8333
    rA_195 (A_48 A_66) resistor r=24.8333
    rA_194 (A_48 A_90) resistor r=58.3583
    rA_193 (A_48 A_93) resistor r=58.3583
    rA_192 (A_48 A_98) resistor r=14.9
    rA_191 (A_48 A_61) resistor r=4.16253
    rA_190 (A_48 A_69) resistor r=4.16253
    rA_189 (A_48 A_58) resistor r=4.16253
    rA_188 (A_48 A_90) resistor r=4.16253
    rA_187 (A_48 A_98) resistor r=6.30933
    rA_186 (A_48 A_93) resistor r=6.30933
    rA_185 (A_48 A_66) resistor r=1.63969
    rA_184 (A_48 A_61) resistor r=24.8333
    rA_183 (A_48 A_58) resistor r=24.8333
    rA_182 (A_48 A_69) resistor r=24.8333
    rA_181 (A_48 A_66) resistor r=24.8333
    rA_180 (A_48 A_90) resistor r=58.3583
    rA_179 (A_48 MMU9_ELT_g) resistor r=22.35
    rA_178 (A_48 A_98) resistor r=14.9
    rA_177 (A_48 A_341) resistor r=40.975
    rA_176 (A_48 A_61) resistor r=4.16253
    rA_175 (A_48 A_69) resistor r=4.16253
    rA_174 (A_48 A_58) resistor r=4.16253
    rA_173 (A_48 A_90) resistor r=4.16253
    rA_172 (A_48 A_98) resistor r=6.30933
    rA_171 (A_48 A_93) resistor r=6.30933
    rA_170 (A_48 A_66) resistor r=1.63969
    rA_169 (A_50 A_56) resistor r=202.392
    rA_168 (A_50 A_56) resistor r=4.16253
    rA_167 (A_50 A_56) resistor r=202.392
    rA_166 (A_50 A_56) resistor r=4.16253
    rA_165 (A_53 A_56) resistor r=202.392
    rA_164 (A_53 A_56) resistor r=4.16253
    rA_163 (A_53 A_56) resistor r=202.392
    rA_162 (A_53 A_56) resistor r=4.16253
    rA_161 (A_56 A_77) resistor r=24.8333
    rA_160 (A_56 A_74) resistor r=24.8333
    rA_159 (A_56 A_85) resistor r=24.8333
    rA_158 (A_56 A_82) resistor r=24.8333
    rA_157 (A_56 A_104) resistor r=14.9
    rA_156 (A_56 A_110) resistor r=202.392
    rA_155 (A_56 A_113) resistor r=202.392
    rA_154 (A_56 A_77) resistor r=4.16253
    rA_153 (A_56 A_85) resistor r=4.16253
    rA_152 (A_56 A_110) resistor r=6.30933
    rA_151 (A_56 A_104) resistor r=6.30933
    rA_150 (A_56 A_74) resistor r=1.63969
    rA_149 (A_56 A_82) resistor r=4.16253
    rA_148 (A_56 A_113) resistor r=4.16253
    rA_147 (A_56 A_77) resistor r=24.8333
    rA_146 (A_56 A_74) resistor r=24.8333
    rA_145 (A_56 A_85) resistor r=24.8333
    rA_144 (A_56 A_82) resistor r=24.8333
    rA_143 (A_56 A_343) resistor r=40.975
    rA_142 (A_56 A_104) resistor r=14.9
    rA_141 (A_56 A_110) resistor r=202.392
    rA_140 (A_56 MMI3_ELT_g) resistor r=7.45
    rA_139 (A_56 A_77) resistor r=4.16253
    rA_138 (A_56 A_85) resistor r=4.16253
    rA_137 (A_56 A_110) resistor r=6.30933
    rA_136 (A_56 A_104) resistor r=6.30933
    rA_135 (A_56 A_74) resistor r=1.63969
    rA_134 (A_56 A_82) resistor r=4.16253
    rA_133 (A_56 A_113) resistor r=4.16253
    rA_132 (A_93 MMU9_ELT_g) resistor r=36.0083
    rA_131 (A_113 MMI3_ELT_g) resistor r=194.942
    rA_130 (A_118 A_124) resistor r=58.3583
    rA_129 (A_118 A_124) resistor r=4.16253
    rA_128 (A_118 A_124) resistor r=58.3583
    rA_127 (A_118 A_124) resistor r=4.16253
    rA_126 (A_121 A_124) resistor r=58.3583
    rA_125 (A_121 A_124) resistor r=6.30933
    rA_124 (A_121 A_124) resistor r=58.3583
    rA_123 (A_121 A_124) resistor r=6.30933
    rA_122 (A_124 A_126) resistor r=14.9
    rA_121 (A_124 A_149) resistor r=24.8333
    rA_120 (A_124 A_146) resistor r=24.8333
    rA_119 (A_124 A_157) resistor r=24.8333
    rA_118 (A_124 A_154) resistor r=24.8333
    rA_117 (A_124 A_178) resistor r=58.3583
    rA_116 (A_124 A_181) resistor r=58.3583
    rA_115 (A_124 A_149) resistor r=4.16253
    rA_114 (A_124 A_126) resistor r=6.30933
    rA_113 (A_124 A_157) resistor r=1.63969
    rA_112 (A_124 A_146) resistor r=4.16253
    rA_111 (A_124 A_178) resistor r=4.16253
    rA_110 (A_124 A_154) resistor r=4.16253
    rA_109 (A_124 A_181) resistor r=4.16253
    rA_108 (A_124 A_126) resistor r=14.9
    rA_107 (A_124 A_355) resistor r=40.975
    rA_106 (A_124 A_149) resistor r=24.8333
    rA_105 (A_124 A_146) resistor r=24.8333
    rA_104 (A_124 A_157) resistor r=24.8333
    rA_103 (A_124 A_154) resistor r=24.8333
    rA_102 (A_124 A_178) resistor r=58.3583
    rA_101 (A_124 MMU6_ELT_g) resistor r=7.45
    rA_100 (A_124 A_149) resistor r=4.16253
    rA_99 (A_124 A_126) resistor r=6.30933
    rA_98 (A_124 A_157) resistor r=1.63969
    rA_97 (A_124 A_146) resistor r=4.16253
    rA_96 (A_124 A_178) resistor r=4.16253
    rA_95 (A_124 A_154) resistor r=4.16253
    rA_94 (A_124 A_181) resistor r=4.16253
    rA_93 (A_132 A_135) resistor r=14.9
    rA_92 (A_132 A_135) resistor r=6.30933
    rA_91 (A_132 A_135) resistor r=14.9
    rA_90 (A_132 A_135) resistor r=6.30933
    rA_89 (A_135 A_138) resistor r=202.392
    rA_88 (A_135 A_141) resistor r=202.392
    rA_87 (A_135 A_165) resistor r=24.8333
    rA_86 (A_135 A_162) resistor r=24.8333
    rA_85 (A_135 A_173) resistor r=24.8333
    rA_84 (A_135 A_170) resistor r=24.8333
    rA_83 (A_135 A_186) resistor r=202.392
    rA_82 (A_135 A_189) resistor r=202.392
    rA_81 (A_135 A_138) resistor r=6.30933
    rA_80 (A_135 A_165) resistor r=1.63969
    rA_79 (A_135 A_173) resistor r=4.16253
    rA_78 (A_135 A_141) resistor r=4.16253
    rA_77 (A_135 A_162) resistor r=4.16253
    rA_76 (A_135 A_186) resistor r=4.16253
    rA_75 (A_135 A_170) resistor r=4.16253
    rA_74 (A_135 A_189) resistor r=4.16253
    rA_73 (A_135 A_357) resistor r=40.975
    rA_72 (A_135 A_138) resistor r=202.392
    rA_71 (A_135 A_141) resistor r=202.392
    rA_70 (A_135 A_165) resistor r=24.8333
    rA_69 (A_135 A_162) resistor r=24.8333
    rA_68 (A_135 A_173) resistor r=24.8333
    rA_67 (A_135 A_170) resistor r=24.8333
    rA_66 (A_135 A_186) resistor r=202.392
    rA_65 (A_135 MMI2_ELT_g) resistor r=7.45
    rA_64 (A_135 A_138) resistor r=6.30933
    rA_63 (A_135 A_165) resistor r=1.63969
    rA_62 (A_135 A_173) resistor r=4.16253
    rA_61 (A_135 A_141) resistor r=4.16253
    rA_60 (A_135 A_162) resistor r=4.16253
    rA_59 (A_135 A_186) resistor r=4.16253
    rA_58 (A_135 A_170) resistor r=4.16253
    rA_57 (A_135 A_189) resistor r=4.16253
    rA_56 (A_181 MMU6_ELT_g) resistor r=50.9083
    rA_55 (A_189 MMI2_ELT_g) resistor r=194.942
    rA_54 (A_261 A_263) resistor r=0.152304
    rA_53 (A_261 A_266) resistor r=0.078749
    rA_52 (A_263 A) resistor r=0.75
    rA_51 (A_266 A_267) resistor r=0.12024
    rA_50 (A_267 A_269) resistor r=0.078749
    rA_49 (A_268 A_269) resistor r=1.27454
    rA_48 (A_268 A_271) resistor r=0.078749
    rA_47 (A_270 A_271) resistor r=0.12024
    rA_46 (A_270 A_275) resistor r=0.0393745
    rA_45 (A_275 A_276) resistor r=0.75
    rA_44 (A_276 A_410) resistor r=10
    rA_43 (A_341 A_392) resistor r=10.0997
    rA_42 (A_343 A_392) resistor r=10.0997
    rA_41 (A_355 A_398) resistor r=10.0997
    rA_40 (A_357 A_398) resistor r=10.0997
    rA_39 (A_391 A_392) resistor r=0.877078
    rA_38 (A_391 A_406) resistor r=41.3136
    rA_37 (A_397 A_398) resistor r=0.877078
    rA_36 (A_397 A_410) resistor r=33.1864
    rA_35 (A_406 A) resistor r=10
ends MAOI222D1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DDFNCNQD1_LVT_ELT
// View name: calibre
subckt DDFNCNQD1_LVT_ELT CDN CPN D Q VDD VSS
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM19_ELT (MM19_ELT_d MM19_ELT_g MM19_ELT_s MM19_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM22_ELT (MM22_ELT_d MM22_ELT_g MM22_ELT_s MM22_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.93575e-13 pd=3.66e-06 \
        ps=7.295e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.93575e-13 pd=3.66e-06 \
        ps=7.295e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.0485e-13 pd=1.34e-06 \
        ps=4.77e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM20_ELT (MM20_ELT_d MM20_ELT_g MM20_ELT_s MM20_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM21_ELT (MM21_ELT_d MM21_ELT_g MM21_ELT_s MM21_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet031_8 (net031_4 VSS) capacitor c=1.02159e-17
    cinet031_7 (net031_5 VSS) capacitor c=1.63273e-18
    cinet031_6 (net031_6 VSS) capacitor c=1.64973e-18
    cinet031_5 (net031_9 VSS) capacitor c=1.06831e-17
    cinet031_4 (MM20_ELT_s VSS) capacitor c=1.51415e-17
    cinet031_3 (net031_13 VSS) capacitor c=2.49285e-17
    cinet031_2 (net031_15 VSS) capacitor c=4.33274e-18
    cinet031_1 (net031_18 VSS) capacitor c=1.71175e-18
    cinet031_0 (net031_20 VSS) capacitor c=7.66866e-18
    ciQ_8 (Q_3 VSS) capacitor c=4.63962e-17
    ciQ_7 (Q_4 VSS) capacitor c=1.11643e-16
    ciQ_6 (Q_8 VSS) capacitor c=1.74533e-16
    ciQ_5 (Q_9 VSS) capacitor c=3.29382e-16
    ciQ_4 (Q_17 VSS) capacitor c=2.27488e-17
    ciQ_3 (Q_18 VSS) capacitor c=1.51826e-17
    ciQ_2 (Q_19 VSS) capacitor c=2.12404e-17
    ciQ_1 (Q_20 VSS) capacitor c=6.39029e-18
    ciQ_0 (Q VSS) capacitor c=7.06186e-17
    ciU_29 (U_22 VSS) capacitor c=4.28147e-18
    ciU_28 (U_28 VSS) capacitor c=1.94119e-16
    ciU_27 (U_39 VSS) capacitor c=5.68633e-16
