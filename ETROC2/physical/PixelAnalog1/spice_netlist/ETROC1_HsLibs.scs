    rA2_30 (A2_39 A2_42) resistor r=6.30933
    rA2_29 (A2_39 A2_69) resistor r=1.63969
    rA2_28 (A2_39 A2_77) resistor r=4.16253
    rA2_27 (A2_39 A2_45) resistor r=4.16253
    rA2_26 (A2_39 A2_66) resistor r=4.16253
    rA2_25 (A2_39 A2_90) resistor r=4.16253
    rA2_24 (A2_39 A2_74) resistor r=4.16253
    rA2_23 (A2_39 A2_93) resistor r=4.16253
    rA2_22 (A2_85 MM1_ELT_g) resistor r=50.9083
    rA2_21 (A2_93 MM11_ELT_g) resistor r=194.942
    rA2_20 (A2_132 A2_133) resistor r=10
    rA2_19 (A2_132 A2) resistor r=0.0868768
    rA2_18 (A2_133 A2_194) resistor r=19.6409
    rA2_17 (A2_162 A2_195) resistor r=10.0997
    rA2_16 (A2_164 A2_195) resistor r=10.0997
    rA2_15 (A2_194 A2_195) resistor r=0.877078
    rA1_94 (A1_22 A1_28) resistor r=58.3583
    rA1_93 (A1_22 A1_28) resistor r=4.16253
    rA1_92 (A1_22 A1_28) resistor r=58.3583
    rA1_91 (A1_22 A1_28) resistor r=4.16253
    rA1_90 (A1_25 A1_28) resistor r=58.3583
    rA1_89 (A1_25 A1_28) resistor r=4.16253
    rA1_88 (A1_25 A1_28) resistor r=58.3583
    rA1_87 (A1_25 A1_28) resistor r=4.16253
    rA1_86 (A1_28 A1_41) resistor r=24.8333
    rA1_85 (A1_28 A1_38) resistor r=24.8333
    rA1_84 (A1_28 A1_49) resistor r=24.8333
    rA1_83 (A1_28 A1_46) resistor r=24.8333
    rA1_82 (A1_28 A1_70) resistor r=58.3583
    rA1_81 (A1_28 A1_73) resistor r=58.3583
    rA1_80 (A1_28 A1_78) resistor r=14.9
    rA1_79 (A1_28 A1_41) resistor r=4.16253
    rA1_78 (A1_28 A1_49) resistor r=4.16253
    rA1_77 (A1_28 A1_38) resistor r=4.16253
    rA1_76 (A1_28 A1_70) resistor r=4.16253
    rA1_75 (A1_28 A1_78) resistor r=6.30933
    rA1_74 (A1_28 A1_73) resistor r=6.30933
    rA1_73 (A1_28 A1_46) resistor r=1.63969
    rA1_72 (A1_28 A1_41) resistor r=24.8333
    rA1_71 (A1_28 A1_38) resistor r=24.8333
    rA1_70 (A1_28 A1_49) resistor r=24.8333
    rA1_69 (A1_28 A1_46) resistor r=24.8333
    rA1_68 (A1_28 A1_70) resistor r=58.3583
    rA1_67 (A1_28 MM2_ELT_g) resistor r=22.35
    rA1_66 (A1_28 A1_78) resistor r=14.9
    rA1_65 (A1_28 A1_182) resistor r=40.975
    rA1_64 (A1_28 A1_41) resistor r=4.16253
    rA1_63 (A1_28 A1_49) resistor r=4.16253
    rA1_62 (A1_28 A1_38) resistor r=4.16253
    rA1_61 (A1_28 A1_70) resistor r=4.16253
    rA1_60 (A1_28 A1_78) resistor r=6.30933
    rA1_59 (A1_28 A1_73) resistor r=6.30933
    rA1_58 (A1_28 A1_46) resistor r=1.63969
    rA1_57 (A1_30 A1_36) resistor r=202.392
    rA1_56 (A1_30 A1_36) resistor r=4.16253
    rA1_55 (A1_30 A1_36) resistor r=202.392
    rA1_54 (A1_30 A1_36) resistor r=4.16253
    rA1_53 (A1_33 A1_36) resistor r=202.392
    rA1_52 (A1_33 A1_36) resistor r=4.16253
    rA1_51 (A1_33 A1_36) resistor r=202.392
    rA1_50 (A1_33 A1_36) resistor r=4.16253
    rA1_49 (A1_36 A1_57) resistor r=24.8333
    rA1_48 (A1_36 A1_54) resistor r=24.8333
    rA1_47 (A1_36 A1_65) resistor r=24.8333
    rA1_46 (A1_36 A1_62) resistor r=24.8333
    rA1_45 (A1_36 A1_84) resistor r=14.9
    rA1_44 (A1_36 A1_90) resistor r=202.392
    rA1_43 (A1_36 A1_93) resistor r=202.392
    rA1_42 (A1_36 A1_57) resistor r=4.16253
    rA1_41 (A1_36 A1_65) resistor r=4.16253
    rA1_40 (A1_36 A1_90) resistor r=6.30933
    rA1_39 (A1_36 A1_84) resistor r=6.30933
    rA1_38 (A1_36 A1_54) resistor r=1.63969
    rA1_37 (A1_36 A1_62) resistor r=4.16253
    rA1_36 (A1_36 A1_93) resistor r=4.16253
    rA1_35 (A1_36 A1_57) resistor r=24.8333
    rA1_34 (A1_36 A1_54) resistor r=24.8333
    rA1_33 (A1_36 A1_65) resistor r=24.8333
    rA1_32 (A1_36 A1_62) resistor r=24.8333
    rA1_31 (A1_36 A1_184) resistor r=40.975
    rA1_30 (A1_36 A1_84) resistor r=14.9
    rA1_29 (A1_36 A1_90) resistor r=202.392
    rA1_28 (A1_36 MM10_ELT_g) resistor r=7.45
    rA1_27 (A1_36 A1_57) resistor r=4.16253
    rA1_26 (A1_36 A1_65) resistor r=4.16253
    rA1_25 (A1_36 A1_90) resistor r=6.30933
    rA1_24 (A1_36 A1_84) resistor r=6.30933
    rA1_23 (A1_36 A1_54) resistor r=1.63969
    rA1_22 (A1_36 A1_62) resistor r=4.16253
    rA1_21 (A1_36 A1_93) resistor r=4.16253
    rA1_20 (A1_73 MM2_ELT_g) resistor r=36.0083
    rA1_19 (A1_93 MM10_ELT_g) resistor r=194.942
    rA1_18 (A1_132 A1_133) resistor r=10
    rA1_17 (A1_132 A1) resistor r=0.0846191
    rA1_16 (A1_133 A1_198) resistor r=41.3136
    rA1_15 (A1_182 A1_199) resistor r=10.0997
    rA1_14 (A1_184 A1_199) resistor r=10.0997
    rA1_13 (A1_198 A1_199) resistor r=0.877078
ends NR2D1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DCAP_LVT_ELT
// View name: calibre
subckt DCAP_LVT_ELT VDD VSS
    MM4 (MM4_d MM4_g MM4_s MM4_b) nch_lvt l=1.615e-06 w=6.65e-07 m=1 nf=1 \
        ad=1.1305e-13 as=6.65e-14 pd=1.67e-06 ps=8.65e-07 nrd=0.255639 \
        nrs=0.150376 sa=4.3e-07 sb=1.7e-07 sca=10.8076 scb=0.00873822 \
        scc=0.000647475
    MM2 (MM2_d MM2_g MM2_s MM2_b) nch_lvt l=6e-08 w=6.65e-07 m=1 nf=1 \
        ad=1.1305e-13 as=6.65e-14 pd=1.67e-06 ps=8.65e-07 nrd=0.255639 \
        nrs=0.150376 sa=1.7e-07 sb=1.985e-06 sca=13.8538 scb=0.0126924 \
        scc=0.000688722
    MM3 (MM3_d MM3_g MM3_s MM3_b) pch_lvt l=1.615e-06 w=1.535e-06 m=1 nf=1 \
        ad=2.6095e-13 as=1.535e-13 pd=3.41e-06 ps=1.735e-06 nrd=0.110749 \
        nrs=0.0651466 sa=4.3e-07 sb=1.7e-07 sca=3.66844 scb=0.00103737 \
        scc=5.68561e-06
    MM1 (MM1_d MM1_g MM1_s MM1_b) pch_lvt l=6e-08 w=1.535e-06 m=1 nf=1 \
        ad=2.6095e-13 as=1.535e-13 pd=3.41e-06 ps=1.735e-06 nrd=0.110749 \
        nrs=0.0651466 sa=1.7e-07 sb=1.985e-06 sca=6.79458 scb=0.00514846 \
        scc=5.07737e-05
    ciVDD_7 (MM1_b VSS) capacitor c=2.62594e-17
    ciVDD_6 (VDD_2 VSS) capacitor c=4.66522e-17
    ciVDD_5 (VDD_11 VSS) capacitor c=1.77169e-16
    ciVDD_4 (VDD_17 VSS) capacitor c=1.92105e-16
    ciVDD_3 (VDD_30 VSS) capacitor c=9.43911e-17
    ciVDD_2 (VDD_31 VSS) capacitor c=1.40893e-16
    ciVDD_1 (VDD_39 VSS) capacitor c=3.60719e-18
    ciVDD_0 (MM3_d VSS) capacitor c=2.79682e-16
    ciVSS_7 (MM2_b VSS) capacitor c=2.62594e-17
    ciVSS_6 (VSS_2 VSS) capacitor c=4.62221e-17
    ciVSS_5 (VSS_11 VSS) capacitor c=1.04747e-16
    ciVSS_4 (VSS_14 VSS) capacitor c=1.73223e-16
    ciVSS_3 (VSS_27 VSS) capacitor c=5.17722e-17
    ciVSS_2 (VSS_28 VSS) capacitor c=6.26434e-17
    ciVSS_1 (VSS_30 VSS) capacitor c=3.60719e-18
    ciVSS_0 (MM4_d VSS) capacitor c=1.36713e-16
    cinet9_10 (net9_15 VSS) capacitor c=9.60955e-17
    cinet9_9 (net9_24 VSS) capacitor c=3.36627e-16
    cinet9_8 (net9_25 VSS) capacitor c=7.23473e-18
    cinet9_7 (net9_26 VSS) capacitor c=1.81852e-16
    cinet9_6 (net9_36 VSS) capacitor c=3.54723e-16
    cinet9_5 (net9_38 VSS) capacitor c=5.04194e-17
    cinet9_4 (MM2_g VSS) capacitor c=1.76564e-16
    cinet9_3 (net9_48 VSS) capacitor c=1.33049e-17
    cinet9_2 (net9_50 VSS) capacitor c=2.71656e-17
    cinet9_1 (MM4_g VSS) capacitor c=1.68619e-16
    cinet9_0 (net9 VSS) capacitor c=1.74001e-16
    cinet11_8 (net11_15 VSS) capacitor c=9.0877e-17
    cinet11_7 (net11_18 VSS) capacitor c=1.11663e-17
    cinet11_6 (net11_26 VSS) capacitor c=2.71321e-16
    cinet11_5 (MM1_g VSS) capacitor c=3.56805e-16
    cinet11_4 (net11_39 VSS) capacitor c=1.48846e-16
    cinet11_3 (MM3_g VSS) capacitor c=7.66665e-16
    cinet11_2 (net11_44 VSS) capacitor c=3.00706e-17
    cinet11_1 (net11_45 VSS) capacitor c=2.24005e-17
    cinet11_0 (net11 VSS) capacitor c=6.78658e-17
    rVDD_37 (MM3_b MM1_b) resistor r=0.01
    rVDD_36 (MM1_b VDD_23) resistor r=8.66667
    rVDD_35 (MM1_b VDD_26) resistor r=8.66667
    rVDD_34 (MM1_b VDD_21) resistor r=33.76
    rVDD_33 (VDD_2 VDD_7) resistor r=0.0335695
    rVDD_32 (VDD_2 VDD_39) resistor r=0.0221347
    rVDD_31 (VDD VDD_7) resistor r=0.102683
    rVDD_30 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_29 (VDD_8 VDD_21) resistor r=67.52
    rVDD_28 (VDD_9 VDD_15) resistor r=0.623472
    rVDD_27 (VDD_9 VDD_39) resistor r=0.0882381
    rVDD_26 (VDD_11 VDD_12) resistor r=8.66667
    rVDD_25 (VDD_11 VDD_15) resistor r=0.639459
    rVDD_24 (VDD_12 VDD_15) resistor r=8.66667
    rVDD_23 (VDD_12 MM1_s) resistor r=1.05412
    rVDD_22 (VDD_12 MM3_d) resistor r=1.05412
    rVDD_21 (VDD_17 VDD_26) resistor r=0.0394935
    rVDD_20 (VDD_17 VDD_28) resistor r=0.142226
    rVDD_19 (VDD_18 VDD_20) resistor r=0.167847
    rVDD_18 (VDD_18 VDD_39) resistor r=0.0221347
    rVDD_17 (VDD_20 VDD_21) resistor r=8.66667
    rVDD_16 (VDD_20 VDD_23) resistor r=0.236961
    rVDD_15 (VDD_23 VDD_26) resistor r=0.236961
    rVDD_14 (VDD_28 VDD_37) resistor r=0.375708
    rVDD_13 (VDD_30 VDD_31) resistor r=8.66667
    rVDD_12 (VDD_30 VDD_34) resistor r=0.585518
    rVDD_11 (VDD_31 VDD_34) resistor r=8.66667
    rVDD_10 (VDD_31 VDD_37) resistor r=26
    rVDD_9 (VDD_31 MM3_s) resistor r=1.05412
    rVDD_8 (VDD_34 VDD_37) resistor r=0.390346
    rVSS_31 (MM4_b MM2_b) resistor r=0.01
    rVSS_30 (MM2_b VSS_20) resistor r=8.66667
    rVSS_29 (MM2_b VSS_23) resistor r=8.66667
    rVSS_28 (MM2_b VSS_18) resistor r=32.3614
    rVSS_27 (VSS_2 VSS_7) resistor r=0.0335695
    rVSS_26 (VSS_2 VSS_30) resistor r=0.0221347
    rVSS_25 (VSS VSS_7) resistor r=0.100708
    rVSS_24 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_23 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_22 (VSS_9 VSS_11) resistor r=0.618144
    rVSS_21 (VSS_9 VSS_30) resistor r=0.0882381
    rVSS_20 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_19 (VSS_12 MM2_s) resistor r=2.53835
    rVSS_18 (VSS_12 MM4_d) resistor r=2.53835
    rVSS_17 (VSS_14 VSS_23) resistor r=0.0394935
    rVSS_16 (VSS_14 VSS_25) resistor r=0.142226
    rVSS_15 (VSS_15 VSS_17) resistor r=0.167847
    rVSS_14 (VSS_15 VSS_30) resistor r=0.0221347
    rVSS_13 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_12 (VSS_17 VSS_20) resistor r=0.236961
    rVSS_11 (VSS_20 VSS_23) resistor r=0.236961
    rVSS_10 (VSS_25 VSS_27) resistor r=0.566001
    rVSS_9 (VSS_27 VSS_28) resistor r=8.66667
    rVSS_8 (VSS_28 MM4_s) resistor r=2.53835
    rnet9_36 (MM1_d net9) resistor r=0.01
    rnet9_35 (net9_13 net9_15) resistor r=0.186509
    rnet9_34 (net9_13 net9_25) resistor r=0.103029
    rnet9_33 (net9_15 net9_16) resistor r=8.66667
    rnet9_32 (net9_15 net9_18) resistor r=0.639459
    rnet9_31 (net9_16 net9_18) resistor r=8.66667
    rnet9_30 (net9_16 net9_21) resistor r=26
    rnet9_29 (net9_16 net9) resistor r=1.05412
    rnet9_28 (net9_18 net9_21) resistor r=0.426306
    rnet9_27 (net9_24 net9_25) resistor r=1.73249
    rnet9_26 (net9_24 net9_38) resistor r=0.0950881
    rnet9_25 (net9_26 net9_35) resistor r=0.173309
    rnet9_24 (net9_26 net9_37) resistor r=0.095388
    rnet9_23 (net9_28 net9_29) resistor r=6.66667
    rnet9_22 (net9_28 net9_32) resistor r=0.519928
    rnet9_21 (net9_29 net9_50) resistor r=17.936
    rnet9_20 (net9_29 net9_33) resistor r=8.76471
    rnet9_19 (net9_32 net9_33) resistor r=6.66667
    rnet9_18 (net9_32 net9_35) resistor r=0.519928
    rnet9_17 (net9_33 MM4_g) resistor r=2.58559
    rnet9_16 (net9_35 net9_36) resistor r=6.66667
    rnet9_15 (net9_36 MM4_g) resistor r=6.17912
    rnet9_14 (net9_37 net9_38) resistor r=0.390081
    rnet9_13 (net9_43 MM2_g) resistor r=108.77
    rnet9_12 (net9_43 net9_48) resistor r=9.29775
    rnet9_11 (net9_48 net9_50) resistor r=27.0909
    rnet11_27 (MM2_d net11) resistor r=0.01
    rnet11_26 (net11_13 net11_15) resistor r=0.850051
    rnet11_25 (net11_13 net11_18) resistor r=0.107086
    rnet11_24 (net11_15 net11_16) resistor r=8.66667
    rnet11_23 (net11_16 net11) resistor r=2.53835
    rnet11_22 (net11_18 net11_20) resistor r=0.137354
    rnet11_21 (net11_20 net11_21) resistor r=6.66667
    rnet11_20 (net11_20 net11_23) resistor r=0.531694
    rnet11_19 (net11_21 net11_43) resistor r=5.41818
    rnet11_18 (net11_21 net11_45) resistor r=21.6727
    rnet11_17 (net11_23 net11_27) resistor r=6.66667
    rnet11_16 (net11_23 net11_26) resistor r=0.531694
    rnet11_15 (net11_26 net11_27) resistor r=6.66667
    rnet11_14 (net11_27 net11_45) resistor r=21.3641
    rnet11_13 (net11_27 net11_39) resistor r=1.45604
    rnet11_12 (net11_35 MM1_g) resistor r=216.547
    rnet11_11 (net11_35 net11_44) resistor r=4.38767
    rnet11_10 (net11_39 MM3_g) resistor r=8.04508
    rnet11_9 (net11_43 net11_44) resistor r=3.71511
ends DCAP_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: MUX2_LVT_ELT
// View name: calibre
subckt MUX2_LVT_ELT VDD VSS in0 in1 out s
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=4.94775e-13 as=3.26e-13 pd=7.315e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet027_7 (net027_4 VSS) capacitor c=2.14818e-18
    cinet027_6 (net027_7 VSS) capacitor c=8.27465e-18
    cinet027_5 (net027_8 VSS) capacitor c=5.40001e-18
    cinet027_4 (net027_9 VSS) capacitor c=1.06756e-17
    cinet027_3 (MM10_ELT_s VSS) capacitor c=9.67586e-18
    cinet027_2 (net027_13 VSS) capacitor c=1.91958e-18
    cinet027_1 (net027_18 VSS) capacitor c=2.63127e-18
    cinet027_0 (net027 VSS) capacitor c=7.71422e-18
    cinet19_7 (net19_4 VSS) capacitor c=2.35978e-18
    cinet19_6 (net19_8 VSS) capacitor c=1.26338e-20
    cinet19_5 (net19_9 VSS) capacitor c=5.00762e-18
    cinet19_4 (MM3_ELT_d VSS) capacitor c=6.39409e-18
    cinet19_3 (net19_13 VSS) capacitor c=1.80205e-18
    cinet19_2 (net19_16 VSS) capacitor c=9.4339e-18
    cinet19_1 (net19_18 VSS) capacitor c=8.85946e-18
    cinet19_0 (net19 VSS) capacitor c=8.28695e-18
    cinet026_6 (MM8_ELT_d VSS) capacitor c=2.11824e-17
    cinet026_5 (net026_5 VSS) capacitor c=1.05172e-17
    cinet026_4 (net026_7 VSS) capacitor c=1.07074e-18
    cinet026_3 (MM9_ELT_s VSS) capacitor c=2.60672e-17
    cinet026_2 (net026_11 VSS) capacitor c=1.64325e-17
    cinet026_1 (net026_13 VSS) capacitor c=6.69054e-18
    cinet026_0 (net026_16 VSS) capacitor c=1.11099e-18
    cinet20_8 (MM0_ELT_d VSS) capacitor c=2.13783e-17
    cinet20_7 (net20_5 VSS) capacitor c=1.04074e-17
    cinet20_6 (net20_7 VSS) capacitor c=3.43325e-18
    cinet20_5 (net20_11 VSS) capacitor c=2.33177e-17
    cinet20_4 (net20_14 VSS) capacitor c=1.11099e-18
    cinet20_3 (net20_15 VSS) capacitor c=2.52676e-20
    cinet20_2 (net20_16 VSS) capacitor c=8.18953e-18
    cinet20_1 (net20_19 VSS) capacitor c=2.13757e-17
    cinet20_0 (net20_20 VSS) capacitor c=1.50998e-18
    ciout_8 (out_3 VSS) capacitor c=3.45741e-17
    ciout_7 (out_4 VSS) capacitor c=1.2178e-16
    ciout_6 (out_8 VSS) capacitor c=1.89959e-16
    ciout_5 (out_9 VSS) capacitor c=3.31342e-16
    ciout_4 (out_17 VSS) capacitor c=4.51191e-17
    ciout_3 (out_18 VSS) capacitor c=1.1183e-17
    ciout_2 (out_19 VSS) capacitor c=5.15012e-17
    ciout_1 (out_20 VSS) capacitor c=1.38781e-17
    ciout_0 (out VSS) capacitor c=5.35203e-17
    cinet13_28 (net13_22 VSS) capacitor c=4.20803e-18
    cinet13_27 (net13_25 VSS) capacitor c=1.50165e-18
    cinet13_26 (net13_28 VSS) capacitor c=1.91173e-16
    cinet13_25 (net13_30 VSS) capacitor c=1.50165e-18
    cinet13_24 (net13_33 VSS) capacitor c=4.28147e-18
    cinet13_23 (net13_36 VSS) capacitor c=5.69301e-16
    cinet13_22 (net13_38 VSS) capacitor c=2.23278e-17
    cinet13_21 (net13_46 VSS) capacitor c=1.57548e-17
    cinet13_20 (net13_54 VSS) capacitor c=1.36093e-17
    cinet13_19 (net13_62 VSS) capacitor c=1.51948e-17
    cinet13_18 (net13_70 VSS) capacitor c=2.09499e-18
    cinet13_17 (net13_93 VSS) capacitor c=2.22299e-18
    cinet13_16 (net13_133 VSS) capacitor c=4.84756e-17
    cinet13_15 (net13_134 VSS) capacitor c=1.08411e-16
    cinet13_14 (net13_136 VSS) capacitor c=8.61341e-17
    cinet13_13 (net13_137 VSS) capacitor c=1.21993e-17
    cinet13_12 (net13_140 VSS) capacitor c=1.97307e-16
    cinet13_11 (net13_141 VSS) capacitor c=3.1554e-16
    cinet13_10 (net13_149 VSS) capacitor c=2.06564e-16
    cinet13_9 (net13_153 VSS) capacitor c=4.77809e-17
    cinet13_8 (net13_154 VSS) capacitor c=1.08228e-16
    cinet13_7 (net13_158 VSS) capacitor c=1.87935e-16
    cinet13_6 (net13_159 VSS) capacitor c=3.17688e-16
    cinet13_5 (net13_167 VSS) capacitor c=9.64016e-17
    cinet13_4 (net13_170 VSS) capacitor c=2.3861e-17
    cinet13_3 (net13_173 VSS) capacitor c=1.19937e-17
    cinet13_2 (net13_176 VSS) capacitor c=4.16448e-17
    cinet13_1 (net13_240 VSS) capacitor c=1.9366e-17
    cinet13_0 (net13_241 VSS) capacitor c=2.35331e-17
    ciVDD_29 (VDD_2 VSS) capacitor c=6.53444e-17
    ciVDD_28 (VDD_11 VSS) capacitor c=2.5148e-16
    ciVDD_27 (VDD_19 VSS) capacitor c=2.03482e-17
    ciVDD_26 (VDD_20 VSS) capacitor c=6.35877e-17
    ciVDD_25 (VDD_30 VSS) capacitor c=1.24631e-16
    ciVDD_24 (VDD_31 VSS) capacitor c=3.1167e-16
    ciVDD_23 (VDD_39 VSS) capacitor c=8.47983e-17
    ciVDD_22 (VDD_49 VSS) capacitor c=1.22789e-16
    ciVDD_21 (VDD_50 VSS) capacitor c=3.11901e-16
    ciVDD_20 (VDD_58 VSS) capacitor c=6.84387e-17
    ciVDD_19 (VDD_65 VSS) capacitor c=1.82758e-16
    ciVDD_18 (VDD_73 VSS) capacitor c=1.21088e-17
    ciVDD_17 (VDD_79 VSS) capacitor c=7.66272e-17
    ciVDD_16 (VDD_82 VSS) capacitor c=3.58509e-18
    ciVDD_15 (VDD_83 VSS) capacitor c=3.58509e-18
    ciVDD_14 (VDD_84 VSS) capacitor c=3.58509e-18
    ciVDD_13 (VDD_85 VSS) capacitor c=3.58509e-18
    ciVDD_12 (MM4_ELT_s VSS) capacitor c=1.32762e-17
    ciVDD_11 (VDD_92 VSS) capacitor c=1.11099e-18
    ciVDD_10 (VDD_94 VSS) capacitor c=5.61912e-18
    ciVDD_9 (VDD_98 VSS) capacitor c=1.11099e-18
    ciVDD_8 (VDD_99 VSS) capacitor c=6.10083e-18
    ciVDD_7 (VDD_100 VSS) capacitor c=9.28078e-18
    ciVDD_6 (VDD_103 VSS) capacitor c=1.71192e-17
    ciVDD_5 (MM12_ELT_s VSS) capacitor c=1.68117e-17
    ciVDD_4 (VDD_106 VSS) capacitor c=5.13989e-18
    ciVDD_3 (VDD_108 VSS) capacitor c=2.23085e-16
    ciVDD_2 (VDD_109 VSS) capacitor c=1.11099e-18
    ciVDD_1 (VDD_112 VSS) capacitor c=4.50141e-18
    ciVDD_0 (VDD_114 VSS) capacitor c=3.75918e-16
    ciVSS_24 (VSS_2 VSS) capacitor c=6.34276e-17
    ciVSS_23 (VSS_11 VSS) capacitor c=7.6633e-17
    ciVSS_22 (VSS_12 VSS) capacitor c=1.17598e-16
    ciVSS_21 (VSS_14 VSS) capacitor c=1.10338e-16
    ciVSS_20 (VSS_24 VSS) capacitor c=5.67785e-17
    ciVSS_19 (VSS_25 VSS) capacitor c=1.11022e-16
    ciVSS_18 (VSS_27 VSS) capacitor c=4.00824e-17
    ciVSS_17 (VSS_34 VSS) capacitor c=5.27379e-17
    ciVSS_16 (VSS_35 VSS) capacitor c=1.12355e-16
    ciVSS_15 (VSS_37 VSS) capacitor c=6.77593e-17
    ciVSS_14 (VSS_44 VSS) capacitor c=6.23672e-17
    ciVSS_13 (VSS_45 VSS) capacitor c=7.03022e-17
    ciVSS_12 (VSS_52 VSS) capacitor c=7.59781e-17
    ciVSS_11 (VSS_55 VSS) capacitor c=3.58509e-18
    ciVSS_10 (VSS_57 VSS) capacitor c=3.58509e-18
    ciVSS_9 (VSS_59 VSS) capacitor c=3.58509e-18
    ciVSS_8 (VSS_60 VSS) capacitor c=3.58509e-18
    ciVSS_7 (VSS_67 VSS) capacitor c=5.43154e-18
    ciVSS_6 (VSS_72 VSS) capacitor c=5.5009e-18
    ciVSS_5 (VSS_73 VSS) capacitor c=6.22897e-18
    ciVSS_4 (VSS_76 VSS) capacitor c=2.21576e-18
    ciVSS_3 (MM13_ELT_s VSS) capacitor c=6.36182e-18
    ciVSS_2 (VSS_81 VSS) capacitor c=1.05833e-17
    ciVSS_1 (VSS_82 VSS) capacitor c=7.14046e-18
    ciVSS_0 (VSS_87 VSS) capacitor c=4.83912e-18
    ciin1_14 (in1_22 VSS) capacitor c=5.8681e-18
    ciin1_13 (in1_25 VSS) capacitor c=6.83919e-18
    ciin1_12 (in1_28 VSS) capacitor c=1.66504e-16
    ciin1_11 (in1_30 VSS) capacitor c=6.45187e-18
    ciin1_10 (in1_33 VSS) capacitor c=5.89798e-18
    ciin1_9 (in1_36 VSS) capacitor c=4.93494e-16
    ciin1_8 (in1_38 VSS) capacitor c=2.23747e-17
    ciin1_7 (in1_46 VSS) capacitor c=2.40716e-17
    ciin1_6 (in1_54 VSS) capacitor c=1.50033e-17
    ciin1_5 (in1_62 VSS) capacitor c=1.51948e-17
    ciin1_4 (in1_70 VSS) capacitor c=3.2795e-18
    ciin1_3 (in1_93 VSS) capacitor c=3.35294e-18
    ciin1_2 (in1_133 VSS) capacitor c=4.48408e-17
    ciin1_1 (in1 VSS) capacitor c=6.10046e-17
    ciin1_0 (in1_199 VSS) capacitor c=8.24949e-18
    ciin0_14 (in0_22 VSS) capacitor c=4.10217e-18
    ciin0_13 (in0_25 VSS) capacitor c=6.02325e-18
    ciin0_12 (in0_28 VSS) capacitor c=1.67443e-16
    ciin0_11 (in0_30 VSS) capacitor c=2.24378e-17
    ciin0_10 (in0_38 VSS) capacitor c=2.20596e-17
    ciin0_9 (in0_46 VSS) capacitor c=5.83934e-18
    ciin0_8 (in0_63 VSS) capacitor c=5.03259e-16
    ciin0_7 (in0_69 VSS) capacitor c=5.89798e-18
    ciin0_6 (in0_74 VSS) capacitor c=1.8497e-17
    ciin0_5 (in0_82 VSS) capacitor c=1.51948e-17
    ciin0_4 (in0_90 VSS) capacitor c=5.67244e-18
    ciin0_3 (in0_93 VSS) capacitor c=4.22299e-18
    ciin0_2 (in0 VSS) capacitor c=7.39241e-17
    ciin0_1 (in0_173 VSS) capacitor c=1.90965e-17
    ciin0_0 (in0_175 VSS) capacitor c=3.17258e-17
    cis0_30 (s0_25 VSS) capacitor c=4.93242e-16
    cis0_29 (s0_31 VSS) capacitor c=2.83193e-18
    cis0_28 (s0_36 VSS) capacitor c=1.67652e-17
    cis0_27 (s0_44 VSS) capacitor c=1.53905e-17
    cis0_26 (s0_52 VSS) capacitor c=7.38853e-18
    cis0_25 (s0_55 VSS) capacitor c=4.30419e-18
    cis0_24 (s0_60 VSS) capacitor c=2.8744e-18
    cis0_23 (s0_63 VSS) capacitor c=4.3319e-18
    cis0_22 (s0_66 VSS) capacitor c=1.62274e-16
    cis0_21 (s0_68 VSS) capacitor c=2.23652e-17
    cis0_20 (s0_76 VSS) capacitor c=1.809e-17
    cis0_19 (s0_84 VSS) capacitor c=4.27432e-18
    cis0_18 (s0_133 VSS) capacitor c=5.31377e-17
    cis0_17 (s0_134 VSS) capacitor c=1.12744e-16
    cis0_16 (s0_138 VSS) capacitor c=1.80374e-16
    cis0_15 (s0_139 VSS) capacitor c=3.3757e-16
    cis0_14 (s0_147 VSS) capacitor c=1.65072e-17
    cis0_13 (s0_148 VSS) capacitor c=1.26504e-17
    cis0_12 (s0_149 VSS) capacitor c=2.78248e-17
    cis0_11 (s0_150 VSS) capacitor c=1.54815e-17
    cis0_10 (s0_152 VSS) capacitor c=3.01054e-18
    cis0_9 (s0_154 VSS) capacitor c=2.40136e-18
    cis0_8 (s0_156 VSS) capacitor c=1.48787e-17
    cis0_7 (s0_157 VSS) capacitor c=1.35943e-16
    cis0_6 (s0_159 VSS) capacitor c=6.53552e-17
    cis0_5 (s0_163 VSS) capacitor c=2.86608e-17
    cis0_4 (s0_165 VSS) capacitor c=7.19085e-17
    cis0_3 (s0_169 VSS) capacitor c=7.84509e-17
    cis0_2 (s0_223 VSS) capacitor c=1.80782e-17
    cis0_1 (s0_227 VSS) capacitor c=3.98275e-17
    cis0_0 (s0_241 VSS) capacitor c=3.46345e-17
    cis0B_43 (s0B_42 VSS) capacitor c=3.00043e-18
    cis0B_42 (s0B_48 VSS) capacitor c=1.97623e-16
    cis0B_41 (s0B_59 VSS) capacitor c=6.09793e-16
    cis0B_40 (s0B_65 VSS) capacitor c=3.00043e-18
    cis0B_39 (s0B_70 VSS) capacitor c=2.23747e-17
    cis0B_38 (s0B_78 VSS) capacitor c=1.97703e-17
    cis0B_37 (s0B_86 VSS) capacitor c=1.15251e-17
    cis0B_36 (s0B_94 VSS) capacitor c=1.51948e-17
    cis0B_35 (s0B_102 VSS) capacitor c=4.07722e-18
    cis0B_34 (s0B_105 VSS) capacitor c=4.42438e-18
    cis0B_33 (s0B_110 VSS) capacitor c=2.05684e-18
    cis0B_32 (s0B_113 VSS) capacitor c=4.22299e-18
    cis0B_31 (s0B_118 VSS) capacitor c=4.27432e-18
    cis0B_30 (s0B_121 VSS) capacitor c=6.90087e-18
    cis0B_29 (s0B_124 VSS) capacitor c=1.66979e-16
    cis0B_28 (s0B_126 VSS) capacitor c=2.29486e-17
    cis0B_27 (s0B_134 VSS) capacitor c=2.05806e-17
    cis0B_26 (s0B_142 VSS) capacitor c=2.8744e-18
    cis0B_25 (s0B_159 VSS) capacitor c=4.90811e-16
    cis0B_24 (s0B_165 VSS) capacitor c=2.83193e-18
    cis0B_23 (s0B_170 VSS) capacitor c=1.39546e-17
    cis0B_22 (s0B_178 VSS) capacitor c=1.54324e-17
    cis0B_21 (s0B_186 VSS) capacitor c=6.63577e-18
    cis0B_20 (s0B_189 VSS) capacitor c=4.30419e-18
    cis0B_19 (s0B_263 VSS) capacitor c=5.74149e-17
    cis0B_18 (s0B_264 VSS) capacitor c=1.11634e-16
    cis0B_17 (s0B_268 VSS) capacitor c=1.88877e-16
    cis0B_16 (s0B_269 VSS) capacitor c=3.29932e-16
    cis0B_15 (s0B_277 VSS) capacitor c=1.96888e-17
    cis0B_14 (s0B_278 VSS) capacitor c=1.25419e-17
    cis0B_13 (s0B_279 VSS) capacitor c=1.84065e-17
    cis0B_12 (s0B_280 VSS) capacitor c=1.25419e-17
    cis0B_11 (s0B_282 VSS) capacitor c=3.20918e-18
    cis0B_10 (s0B_284 VSS) capacitor c=1.9603e-18
    cis0B_9 (s0B_286 VSS) capacitor c=1.2579e-17
    cis0B_8 (s0B_287 VSS) capacitor c=1.43302e-16
    cis0B_7 (s0B_290 VSS) capacitor c=5.8911e-17
    cis0B_6 (s0B_291 VSS) capacitor c=3.6622e-17
    cis0B_5 (s0B_296 VSS) capacitor c=6.57689e-17
    cis0B_4 (s0B_297 VSS) capacitor c=8.06498e-17
    cis0B_3 (s0B_413 VSS) capacitor c=2.48406e-17
    cis0B_2 (s0B_414 VSS) capacitor c=1.80002e-17
    cis0B_1 (s0B_425 VSS) capacitor c=1.2377e-17
    cis0B_0 (s0B_426 VSS) capacitor c=4.59253e-17
    cis_14 (s_22 VSS) capacitor c=2.22299e-18
    cis_13 (s_28 VSS) capacitor c=1.77988e-16
    cis_12 (s_39 VSS) capacitor c=5.6212e-16
    cis_11 (s_45 VSS) capacitor c=2.22299e-18
    cis_10 (s_50 VSS) capacitor c=2.23747e-17
    cis_9 (s_58 VSS) capacitor c=2.05221e-17
    cis_8 (s_66 VSS) capacitor c=1.40776e-17
    cis_7 (s_74 VSS) capacitor c=1.51948e-17
    cis_6 (s_82 VSS) capacitor c=4.20803e-18
    cis_5 (s_85 VSS) capacitor c=5.46028e-18
    cis_4 (s_90 VSS) capacitor c=5.87675e-18
    cis_3 (s_93 VSS) capacitor c=4.28147e-18
    cis_2 (s VSS) capacitor c=3.64929e-17
    cis_1 (s_196 VSS) capacitor c=1.51805e-17
    cis_0 (s_197 VSS) capacitor c=1.88416e-17
    rnet027_36 (net027_1 net027_4) resistor r=21.1301
    rnet027_35 (net027_1 net027_6) resistor r=9.43134
    rnet027_34 (net027_2 net027_4) resistor r=21.1301
    rnet027_33 (net027_2 net027_8) resistor r=9.4369
    rnet027_32 (MM11_ELT_d net027_4) resistor r=4.557
    rnet027_31 (MM11_ELT_d net027_7) resistor r=2.67027
    rnet027_30 (MM11_ELT_d net027_9) resistor r=12.8495
    rnet027_29 (MM11_ELT_d net027_9) resistor r=1.69926
    rnet027_28 (MM11_ELT_d net027_13) resistor r=4.22001
    rnet027_27 (MM11_ELT_d net027) resistor r=10.6787
    rnet027_26 (net027_5 net027_7) resistor r=15.1041
    rnet027_25 (net027_5 net027_20) resistor r=11.0157
    rnet027_24 (net027_6 net027_7) resistor r=15.1041
    rnet027_23 (net027_8 net027_9) resistor r=12.8495
    rnet027_22 (net027_10 net027_13) resistor r=4.22001
    rnet027_21 (net027_10 net027_20) resistor r=0.762262
    rnet027_20 (net027_11 net027_13) resistor r=4.22001
    rnet027_19 (net027_11 net027) resistor r=0.57282
    rnet027_18 (MM10_ELT_s net027_13) resistor r=4.22001
    rnet027_17 (MM10_ELT_s net027_16) resistor r=2.67027
    rnet027_16 (MM10_ELT_s net027_18) resistor r=12.8495
    rnet027_15 (MM10_ELT_s net027_18) resistor r=1.69926
    rnet027_14 (MM10_ELT_s net027_19) resistor r=18.0507
    rnet027_13 (net027_14 net027_16) resistor r=15.1041
    rnet027_12 (net027_14 net027_19) resistor r=9.43134
    rnet027_11 (net027_15 net027_16) resistor r=15.1041
    rnet027_10 (net027_15 net027_20) resistor r=11.0157
    rnet027_9 (net027_17 net027_18) resistor r=12.8495
    rnet027_8 (net027_17 net027) resistor r=10.6787
    rnet19_36 (net19_1 net19_4) resistor r=21.1301
    rnet19_35 (net19_1 net19_6) resistor r=9.43134
    rnet19_34 (net19_2 net19_4) resistor r=21.1301
    rnet19_33 (net19_2 net19_8) resistor r=9.4369
    rnet19_32 (MM1_ELT_s net19_4) resistor r=4.557
    rnet19_31 (MM1_ELT_s net19_7) resistor r=2.67027
    rnet19_30 (MM1_ELT_s net19_9) resistor r=12.8495
    rnet19_29 (MM1_ELT_s net19_9) resistor r=1.69926
    rnet19_28 (MM1_ELT_s net19_13) resistor r=4.22001
    rnet19_27 (MM1_ELT_s net19) resistor r=10.6787
    rnet19_26 (net19_5 net19_7) resistor r=15.1041
    rnet19_25 (net19_5 net19_20) resistor r=11.0157
    rnet19_24 (net19_6 net19_7) resistor r=15.1041
    rnet19_23 (net19_8 net19_9) resistor r=12.8495
    rnet19_22 (net19_10 net19_13) resistor r=4.22001
    rnet19_21 (net19_10 net19_20) resistor r=0.762262
    rnet19_20 (net19_11 net19_13) resistor r=4.22001
    rnet19_19 (net19_11 net19) resistor r=0.57282
    rnet19_18 (MM3_ELT_d net19_13) resistor r=4.22001
    rnet19_17 (MM3_ELT_d net19_16) resistor r=2.67027
    rnet19_16 (MM3_ELT_d net19_18) resistor r=12.8495
    rnet19_15 (MM3_ELT_d net19_18) resistor r=1.69926
    rnet19_14 (MM3_ELT_d net19_19) resistor r=18.0507
    rnet19_13 (net19_14 net19_16) resistor r=15.1041
    rnet19_12 (net19_14 net19_19) resistor r=9.43134
    rnet19_11 (net19_15 net19_16) resistor r=15.1041
    rnet19_10 (net19_15 net19_20) resistor r=11.0157
    rnet19_9 (net19_17 net19_18) resistor r=12.8495
    rnet19_8 (net19_17 net19) resistor r=10.6787
    rnet026_32 (MM8_ELT_d net026_2) resistor r=25.7298
    rnet026_31 (MM8_ELT_d net026_5) resistor r=2.55965
    rnet026_30 (MM8_ELT_d net026_7) resistor r=12.3172
    rnet026_29 (MM8_ELT_d net026_7) resistor r=1.62887
    rnet026_28 (MM8_ELT_d net026_11) resistor r=4.04518
    rnet026_27 (net026_2 net026_4) resistor r=9.04062
    rnet026_26 (net026_3 net026_5) resistor r=14.4784
    rnet026_25 (net026_3 net026) resistor r=10.5593
    rnet026_24 (net026_4 net026_5) resistor r=14.4784
    rnet026_23 (net026_6 net026_7) resistor r=12.3172
    rnet026_22 (net026_6 net026_18) resistor r=10.2363
    rnet026_21 (net026_8 net026_11) resistor r=4.04518
    rnet026_20 (net026_8 net026_18) resistor r=0.549089
    rnet026_19 (net026_9 net026_11) resistor r=4.04518
    rnet026_18 (net026_9 net026) resistor r=0.730683
    rnet026_17 (MM9_ELT_s net026_11) resistor r=4.04518
    rnet026_16 (MM9_ELT_s net026_13) resistor r=12.3172
    rnet026_15 (MM9_ELT_s net026_13) resistor r=1.62887
    rnet026_14 (MM9_ELT_s net026_16) resistor r=2.55965
    rnet026_13 (MM9_ELT_s net026_17) resistor r=25.7298
    rnet026_12 (net026_12 net026_13) resistor r=12.3172
    rnet026_11 (net026_12 net026_18) resistor r=10.2363
    rnet026_10 (net026_14 net026_16) resistor r=14.4784
    rnet026_9 (net026_14 net026_17) resistor r=9.04062
    rnet026_8 (net026_15 net026_16) resistor r=14.4784
    rnet026_7 (net026_15 net026) resistor r=10.5593
    rnet20_37 (MM0_ELT_d net20_2) resistor r=25.7298
    rnet20_36 (MM0_ELT_d net20_5) resistor r=2.55965
    rnet20_35 (MM0_ELT_d net20_7) resistor r=12.3172
    rnet20_34 (MM0_ELT_d net20_7) resistor r=1.62887
    rnet20_33 (MM0_ELT_d net20_11) resistor r=4.04518
    rnet20_32 (net20_2 net20_4) resistor r=9.04062
    rnet20_31 (net20_3 net20_5) resistor r=14.4784
    rnet20_30 (net20_3 net20) resistor r=10.5593
    rnet20_29 (net20_4 net20_5) resistor r=14.4784
    rnet20_28 (net20_6 net20_7) resistor r=12.3172
    rnet20_27 (net20_6 net20_20) resistor r=10.2363
    rnet20_26 (net20_8 net20_11) resistor r=4.04518
    rnet20_25 (net20_8 net20_20) resistor r=0.549089
    rnet20_24 (net20_9 net20_11) resistor r=4.04518
    rnet20_23 (net20_9 net20) resistor r=0.730683
    rnet20_22 (MM2_ELT_s net20_11) resistor r=4.04518
    rnet20_21 (MM2_ELT_s net20_14) resistor r=2.55965
    rnet20_20 (MM2_ELT_s net20_16) resistor r=12.3172
    rnet20_19 (MM2_ELT_s net20_16) resistor r=1.62887
    rnet20_18 (MM2_ELT_s net20_19) resistor r=6.12113
    rnet20_17 (MM2_ELT_s net20_20) resistor r=10.2363
    rnet20_16 (net20_12 net20_14) resistor r=14.4784
    rnet20_15 (net20_12 net20_18) resistor r=9.04062
    rnet20_14 (net20_13 net20_14) resistor r=14.4784
    rnet20_13 (net20_13 net20) resistor r=10.5593
    rnet20_12 (net20_15 net20_16) resistor r=12.3172
    rnet20_11 (net20_15 net20_17) resistor r=9.04595
    rnet20_10 (net20_17 net20_19) resistor r=31.2341
    rnet20_9 (net20_18 net20_19) resistor r=31.2341
    rout_28 (out_1 out_3) resistor r=0.207561
    rout_27 (out_1 out_18) resistor r=0.0959622
    rout_26 (out_3 out_4) resistor r=13
    rout_25 (out_4 MM13_ELT_d) resistor r=8.44
    rout_24 (out_6 out_8) resistor r=0.510919
    rout_23 (out_6 out_20) resistor r=0.0959622
    rout_22 (out_8 out_9) resistor r=8.66667
    rout_21 (out_8 out_11) resistor r=0.638648
    rout_20 (out_9 MM12_ELT_d) resistor r=32.3614
    rout_19 (out_11 out_12) resistor r=8.66667
    rout_18 (out_11 out_14) resistor r=0.425765
    rout_17 (out_12 MM12_ELT_d) resistor r=16.1807
    rout_16 (out_12 out_15) resistor r=32.3614
    rout_15 (out_14 out_15) resistor r=26
    rout_14 (out_17 out_18) resistor r=0.311881
    rout_13 (out_17 out_21) resistor r=0.0959622
    rout_12 (out_19 out_20) resistor r=0.399517
    rout_11 (out_19 out_22) resistor r=0.0959622
    rout_10 (out_21 out) resistor r=0.457301
    rout_9 (out_22 out) resistor r=0.216925
    rnet13_148 (MM9_ELT_d net13) resistor r=0.01
    rnet13_147 (net13_22 net13_28) resistor r=58.3583
    rnet13_146 (net13_22 net13_28) resistor r=4.16253
    rnet13_145 (net13_22 net13_28) resistor r=58.3583
    rnet13_144 (net13_22 net13_28) resistor r=4.16253
    rnet13_143 (net13_25 net13_28) resistor r=58.3583
    rnet13_142 (net13_25 net13_28) resistor r=4.16253
    rnet13_141 (net13_25 net13_28) resistor r=58.3583
    rnet13_140 (net13_25 net13_28) resistor r=4.16253
    rnet13_139 (net13_28 net13_41) resistor r=24.8333
    rnet13_138 (net13_28 net13_38) resistor r=24.8333
    rnet13_137 (net13_28 net13_49) resistor r=24.8333
    rnet13_136 (net13_28 net13_46) resistor r=24.8333
    rnet13_135 (net13_28 net13_70) resistor r=58.3583
    rnet13_134 (net13_28 net13_73) resistor r=58.3583
    rnet13_133 (net13_28 net13_78) resistor r=14.9
    rnet13_132 (net13_28 net13_41) resistor r=4.16253
    rnet13_131 (net13_28 net13_49) resistor r=4.16253
    rnet13_130 (net13_28 net13_38) resistor r=4.16253
    rnet13_129 (net13_28 net13_70) resistor r=4.16253
    rnet13_128 (net13_28 net13_78) resistor r=6.30933
    rnet13_127 (net13_28 net13_73) resistor r=6.30933
    rnet13_126 (net13_28 net13_46) resistor r=1.63969
    rnet13_125 (net13_28 net13_41) resistor r=24.8333
    rnet13_124 (net13_28 net13_38) resistor r=24.8333
    rnet13_123 (net13_28 net13_49) resistor r=24.8333
    rnet13_122 (net13_28 net13_46) resistor r=24.8333
    rnet13_121 (net13_28 net13_70) resistor r=58.3583
    rnet13_120 (net13_28 MM13_ELT_g) resistor r=22.35
    rnet13_119 (net13_28 net13_78) resistor r=14.9
    rnet13_118 (net13_28 net13_222) resistor r=40.975
    rnet13_117 (net13_28 net13_41) resistor r=4.16253
    rnet13_116 (net13_28 net13_49) resistor r=4.16253
    rnet13_115 (net13_28 net13_38) resistor r=4.16253
    rnet13_114 (net13_28 net13_70) resistor r=4.16253
    rnet13_113 (net13_28 net13_78) resistor r=6.30933
    rnet13_112 (net13_28 net13_73) resistor r=6.30933
    rnet13_111 (net13_28 net13_46) resistor r=1.63969
    rnet13_110 (net13_30 net13_36) resistor r=202.392
    rnet13_109 (net13_30 net13_36) resistor r=4.16253
    rnet13_108 (net13_30 net13_36) resistor r=202.392
    rnet13_107 (net13_30 net13_36) resistor r=4.16253
    rnet13_106 (net13_33 net13_36) resistor r=202.392
    rnet13_105 (net13_33 net13_36) resistor r=4.16253
    rnet13_104 (net13_33 net13_36) resistor r=202.392
    rnet13_103 (net13_33 net13_36) resistor r=4.16253
    rnet13_102 (net13_36 net13_57) resistor r=24.8333
    rnet13_101 (net13_36 net13_54) resistor r=24.8333
    rnet13_100 (net13_36 net13_65) resistor r=24.8333
    rnet13_99 (net13_36 net13_62) resistor r=24.8333
    rnet13_98 (net13_36 net13_84) resistor r=14.9
    rnet13_97 (net13_36 net13_90) resistor r=202.392
    rnet13_96 (net13_36 net13_93) resistor r=202.392
    rnet13_95 (net13_36 net13_57) resistor r=4.16253
    rnet13_94 (net13_36 net13_65) resistor r=4.16253
    rnet13_93 (net13_36 net13_90) resistor r=6.30933
    rnet13_92 (net13_36 net13_84) resistor r=6.30933
    rnet13_91 (net13_36 net13_54) resistor r=1.63969
    rnet13_90 (net13_36 net13_62) resistor r=4.16253
    rnet13_89 (net13_36 net13_93) resistor r=4.16253
    rnet13_88 (net13_36 net13_57) resistor r=24.8333
    rnet13_87 (net13_36 net13_54) resistor r=24.8333
    rnet13_86 (net13_36 net13_65) resistor r=24.8333
    rnet13_85 (net13_36 net13_62) resistor r=24.8333
    rnet13_84 (net13_36 net13_224) resistor r=40.975
    rnet13_83 (net13_36 net13_84) resistor r=14.9
    rnet13_82 (net13_36 net13_90) resistor r=202.392
    rnet13_81 (net13_36 MM12_ELT_g) resistor r=7.45
    rnet13_80 (net13_36 net13_57) resistor r=4.16253
    rnet13_79 (net13_36 net13_65) resistor r=4.16253
    rnet13_78 (net13_36 net13_90) resistor r=6.30933
    rnet13_77 (net13_36 net13_84) resistor r=6.30933
    rnet13_76 (net13_36 net13_54) resistor r=1.63969
    rnet13_75 (net13_36 net13_62) resistor r=4.16253
    rnet13_74 (net13_36 net13_93) resistor r=4.16253
    rnet13_73 (net13_73 MM13_ELT_g) resistor r=36.0083
    rnet13_72 (net13_93 MM12_ELT_g) resistor r=194.942
    rnet13_71 (net13_131 net13_133) resistor r=0.389851
    rnet13_70 (net13_131 net13_137) resistor r=0.0959622
    rnet13_69 (net13_133 net13_134) resistor r=13
    rnet13_68 (net13_134 MM1_ELT_d) resistor r=8.44
    rnet13_67 (net13_136 net13_137) resistor r=0.536851
    rnet13_66 (net13_136 net13_173) resistor r=0.0727271
    rnet13_65 (net13_138 net13_140) resistor r=1.55443
    rnet13_64 (net13_138 net13_173) resistor r=0.0189005
    rnet13_63 (net13_140 net13_141) resistor r=8.66667
    rnet13_62 (net13_140 net13_143) resistor r=0.584776
    rnet13_61 (net13_141 MM2_ELT_d) resistor r=32.3614
    rnet13_60 (net13_143 net13_144) resistor r=8.66667
    rnet13_59 (net13_143 net13_146) resistor r=0.389851
    rnet13_58 (net13_144 MM2_ELT_d) resistor r=16.1807
    rnet13_57 (net13_144 net13_147) resistor r=32.3614
    rnet13_56 (net13_146 net13_147) resistor r=26
    rnet13_55 (net13_149 net13_150) resistor r=1.81231
    rnet13_54 (net13_149 net13_174) resistor r=0.0429378
    rnet13_53 (net13_150 net13_173) resistor r=0.0727271
    rnet13_52 (net13_151 net13_153) resistor r=0.389851
    rnet13_51 (net13_151 net13_174) resistor r=0.0429378
    rnet13_50 (net13_153 net13_154) resistor r=13
    rnet13_49 (net13_154 MM10_ELT_d) resistor r=8.44
    rnet13_48 (net13_156 net13_158) resistor r=1.57408
    rnet13_47 (net13_156 net13_174) resistor r=0.0429378
    rnet13_46 (net13_158 net13_159) resistor r=8.66667
    rnet13_45 (net13_158 net13_161) resistor r=0.584776
    rnet13_44 (net13_159 net13) resistor r=32.3614
    rnet13_43 (net13_161 net13_162) resistor r=8.66667
    rnet13_42 (net13_161 net13_164) resistor r=0.389851
    rnet13_41 (net13_162 net13) resistor r=16.1807
    rnet13_40 (net13_162 net13_165) resistor r=32.3614
    rnet13_39 (net13_164 net13_165) resistor r=26
    rnet13_38 (net13_167 net13_168) resistor r=1.02416
    rnet13_37 (net13_167 net13_169) resistor r=0.0959622
    rnet13_36 (net13_168 net13_174) resistor r=0.0429378
    rnet13_35 (net13_169 net13_170) resistor r=0.0974627
    rnet13_34 (net13_170 net13_176) resistor r=0.0707979
    rnet13_33 (net13_176 net13_177) resistor r=10
    rnet13_32 (net13_177 net13_240) resistor r=14.9
    rnet13_31 (net13_222 net13_241) resistor r=3.725
    rnet13_30 (net13_224 net13_241) resistor r=3.725
    rnet13_29 (net13_240 net13_241) resistor r=3.725
    rVDD_143 (MM6_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_142 (MM0_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_141 (MM2_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_140 (MM8_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_139 (MM9_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_138 (MM12_ELT_b MM4_ELT_b) resistor r=0.01
    rVDD_137 (MM4_ELT_b VDD_45) resistor r=8.66667
    rVDD_136 (MM4_ELT_b VDD_61) resistor r=8.66667
    rVDD_135 (MM4_ELT_b VDD_76) resistor r=8.66667
    rVDD_134 (MM4_ELT_b VDD_79) resistor r=13
    rVDD_133 (MM4_ELT_b VDD_43) resistor r=22.5067
    rVDD_132 (VDD_2 VDD_7) resistor r=0.124369
    rVDD_131 (VDD_2 VDD_82) resistor r=0.0221284
    rVDD_130 (VDD VDD_7) resistor r=0.088835
    rVDD_129 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_128 (VDD_8 VDD_24) resistor r=67.52
    rVDD_127 (VDD_9 VDD_18) resistor r=0.414858
    rVDD_126 (VDD_9 VDD_82) resistor r=0.0881153
    rVDD_125 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_124 (VDD_11 VDD_15) resistor r=0.701169
    rVDD_123 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_122 (VDD_15 VDD_18) resistor r=0.701169
    rVDD_121 (VDD_18 VDD_19) resistor r=8.66667
    rVDD_120 (VDD_19 MM6_ELT_s) resistor r=4.04518
    rVDD_119 (VDD_19 VDD_113) resistor r=4.04518
    rVDD_118 (VDD_19 MM4_ELT_s) resistor r=4.04518
    rVDD_117 (VDD_19 VDD_111) resistor r=4.04518
    rVDD_116 (VDD_20 VDD_26) resistor r=0.0217152
    rVDD_115 (VDD_20 VDD_83) resistor r=0.0221284
    rVDD_114 (VDD_21 VDD_23) resistor r=0.0769904
    rVDD_113 (VDD_21 VDD_82) resistor r=0.0221284
    rVDD_112 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_111 (VDD_23 VDD_26) resistor r=0.236893
    rVDD_110 (VDD_24 VDD_27) resistor r=67.52
    rVDD_109 (VDD_26 VDD_27) resistor r=8.66667
    rVDD_108 (VDD_27 VDD_43) resistor r=67.52
    rVDD_107 (VDD_28 VDD_37) resistor r=0.448328
    rVDD_106 (VDD_28 VDD_83) resistor r=0.0881153
    rVDD_105 (VDD_30 VDD_31) resistor r=8.66667
    rVDD_104 (VDD_30 VDD_34) resistor r=0.584776
    rVDD_103 (VDD_31 MM0_ELT_s) resistor r=32.3614
    rVDD_102 (VDD_34 VDD_35) resistor r=8.66667
    rVDD_101 (VDD_34 VDD_37) resistor r=0.389851
    rVDD_100 (VDD_35 MM0_ELT_s) resistor r=16.1807
    rVDD_99 (VDD_35 VDD_38) resistor r=32.3614
    rVDD_98 (VDD_37 VDD_38) resistor r=26
    rVDD_97 (VDD_39 VDD_45) resistor r=0.0217152
    rVDD_96 (VDD_39 VDD_84) resistor r=0.0221284
    rVDD_95 (VDD_40 VDD_42) resistor r=0.179644
    rVDD_94 (VDD_40 VDD_83) resistor r=0.0221284
    rVDD_93 (VDD_42 VDD_43) resistor r=8.66667
    rVDD_92 (VDD_42 VDD_45) resistor r=0.236893
    rVDD_91 (VDD_47 VDD_56) resistor r=0.448328
    rVDD_90 (VDD_47 VDD_84) resistor r=0.0881153
    rVDD_89 (VDD_49 VDD_50) resistor r=8.66667
    rVDD_88 (VDD_49 VDD_53) resistor r=0.584776
    rVDD_87 (VDD_50 MM8_ELT_s) resistor r=32.3614
    rVDD_86 (VDD_53 VDD_54) resistor r=8.66667
    rVDD_85 (VDD_53 VDD_56) resistor r=0.389851
    rVDD_84 (VDD_54 MM8_ELT_s) resistor r=16.1807
    rVDD_83 (VDD_54 VDD_57) resistor r=32.3614
    rVDD_82 (VDD_56 VDD_57) resistor r=26
    rVDD_81 (VDD_58 VDD_61) resistor r=0.17767
    rVDD_80 (VDD_58 VDD_85) resistor r=0.0221284
    rVDD_79 (VDD_59 VDD_61) resistor r=0.179644
    rVDD_78 (VDD_59 VDD_84) resistor r=0.0221284
    rVDD_77 (VDD_63 VDD_72) resistor r=0.377867
    rVDD_76 (VDD_63 VDD_85) resistor r=0.0881153
    rVDD_75 (VDD_65 VDD_73) resistor r=8.66667
    rVDD_74 (VDD_65 VDD_69) resistor r=0.638648
    rVDD_73 (VDD_69 VDD_73) resistor r=8.66667
    rVDD_72 (VDD_69 VDD_72) resistor r=0.638648
    rVDD_71 (VDD_72 VDD_73) resistor r=8.66667
    rVDD_70 (VDD_73 VDD_116) resistor r=27.2424
    rVDD_69 (VDD_73 VDD_115) resistor r=27.2424
    rVDD_68 (VDD_73 MM12_ELT_s) resistor r=5.66484
    rVDD_67 (VDD_74 VDD_76) resistor r=0.0236893
    rVDD_66 (VDD_74 VDD_85) resistor r=0.0221284
    rVDD_65 (VDD_76 VDD_79) resistor r=0.157929
    rVDD_64 (MM4_ELT_s VDD_89) resistor r=25.7298
    rVDD_63 (MM4_ELT_s VDD_92) resistor r=2.55965
    rVDD_62 (MM4_ELT_s VDD_94) resistor r=12.3172
    rVDD_61 (MM4_ELT_s VDD_94) resistor r=1.62887
    rVDD_60 (VDD_89 VDD_91) resistor r=9.04062
    rVDD_59 (VDD_90 VDD_92) resistor r=14.4784
    rVDD_58 (VDD_90 VDD_114) resistor r=10.5593
    rVDD_57 (VDD_91 VDD_92) resistor r=14.4784
    rVDD_56 (VDD_93 VDD_94) resistor r=12.3172
    rVDD_55 (VDD_93 VDD_112) resistor r=10.2363
    rVDD_54 (MM6_ELT_s VDD_98) resistor r=2.55965
    rVDD_53 (MM6_ELT_s VDD_100) resistor r=12.3172
    rVDD_52 (MM6_ELT_s VDD_100) resistor r=1.62887
    rVDD_51 (MM6_ELT_s VDD_103) resistor r=6.12113
    rVDD_50 (MM6_ELT_s VDD_112) resistor r=10.2363
    rVDD_49 (VDD_96 VDD_98) resistor r=14.4784
    rVDD_48 (VDD_96 VDD_102) resistor r=9.04062
    rVDD_47 (VDD_97 VDD_98) resistor r=14.4784
    rVDD_46 (VDD_97 VDD_114) resistor r=10.5593
    rVDD_45 (VDD_99 VDD_100) resistor r=12.3172
    rVDD_44 (VDD_99 VDD_101) resistor r=9.04595
    rVDD_43 (VDD_101 VDD_103) resistor r=31.2341
    rVDD_42 (VDD_102 VDD_103) resistor r=31.2341
    rVDD_41 (MM12_ELT_s VDD_106) resistor r=12.3172
    rVDD_40 (MM12_ELT_s VDD_106) resistor r=1.62887
    rVDD_39 (MM12_ELT_s VDD_109) resistor r=2.55965
    rVDD_38 (MM12_ELT_s VDD_110) resistor r=25.7298
    rVDD_37 (VDD_105 VDD_106) resistor r=12.3172
    rVDD_36 (VDD_105 VDD_115) resistor r=9.39461
    rVDD_35 (VDD_107 VDD_109) resistor r=14.4784
    rVDD_34 (VDD_107 VDD_110) resistor r=9.04062
    rVDD_33 (VDD_108 VDD_109) resistor r=14.4784
    rVDD_32 (VDD_108 VDD_116) resistor r=9.48555
    rVDD_31 (VDD_111 VDD_112) resistor r=0.549089
    rVDD_30 (VDD_113 VDD_114) resistor r=0.730683
    rVSS_117 (MM7_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_116 (MM1_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_115 (MM3_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_114 (MM11_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_113 (MM10_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_112 (MM13_ELT_b MM5_ELT_b) resistor r=0.01
    rVSS_111 (MM5_ELT_b VSS_30) resistor r=8.66667
    rVSS_110 (MM5_ELT_b VSS_40) resistor r=8.66667
    rVSS_109 (MM5_ELT_b VSS_49) resistor r=8.66667
    rVSS_108 (MM5_ELT_b VSS_52) resistor r=13
    rVSS_107 (MM5_ELT_b VSS_58) resistor r=21.5743
    rVSS_106 (VSS_2 VSS_7) resistor r=0.124369
    rVSS_105 (VSS_2 VSS_55) resistor r=0.0221284
    rVSS_104 (VSS VSS_7) resistor r=0.088835
    rVSS_103 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_102 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_101 (VSS_9 VSS_11) resistor r=0.444073
    rVSS_100 (VSS_9 VSS_55) resistor r=0.0881153
    rVSS_99 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_98 (VSS_12 MM7_ELT_s) resistor r=4.22001
    rVSS_97 (VSS_12 VSS_86) resistor r=4.22001
    rVSS_96 (VSS_12 MM5_ELT_s) resistor r=4.22001
    rVSS_95 (VSS_12 VSS_84) resistor r=4.22001
    rVSS_94 (VSS_14 VSS_20) resistor r=0.227023
    rVSS_93 (VSS_14 VSS_57) resistor r=0.0221284
    rVSS_92 (VSS_15 VSS_17) resistor r=0.0769904
    rVSS_91 (VSS_15 VSS_55) resistor r=0.0221284
    rVSS_90 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_89 (VSS_17 VSS_20) resistor r=0.236893
    rVSS_88 (VSS_18 VSS_21) resistor r=64.7228
    rVSS_87 (VSS_20 VSS_21) resistor r=8.66667
    rVSS_86 (VSS_21 VSS_58) resistor r=64.7228
    rVSS_85 (VSS_22 VSS_24) resistor r=0.370358
    rVSS_84 (VSS_22 VSS_57) resistor r=0.0881153
    rVSS_83 (VSS_24 VSS_25) resistor r=13
    rVSS_82 (VSS_25 MM3_ELT_s) resistor r=8.44
    rVSS_81 (VSS_27 VSS_30) resistor r=0.0217152
    rVSS_80 (VSS_27 VSS_59) resistor r=0.0221284
    rVSS_79 (VSS_28 VSS_30) resistor r=0.21123
    rVSS_78 (VSS_28 VSS_57) resistor r=0.0221284
    rVSS_77 (VSS_32 VSS_34) resistor r=0.370358
    rVSS_76 (VSS_32 VSS_59) resistor r=0.0881153
    rVSS_75 (VSS_34 VSS_35) resistor r=13
    rVSS_74 (VSS_35 MM11_ELT_s) resistor r=8.44
    rVSS_73 (VSS_37 VSS_40) resistor r=0.17767
    rVSS_72 (VSS_37 VSS_60) resistor r=0.0221284
    rVSS_71 (VSS_38 VSS_40) resistor r=0.179644
    rVSS_70 (VSS_38 VSS_59) resistor r=0.0221284
    rVSS_69 (VSS_42 VSS_44) resistor r=0.404477
    rVSS_68 (VSS_42 VSS_60) resistor r=0.0881153
    rVSS_67 (VSS_44 VSS_45) resistor r=8.66667
    rVSS_66 (VSS_45 VSS_89) resistor r=17.2126
    rVSS_65 (VSS_45 VSS_88) resistor r=17.2126
    rVSS_64 (VSS_45 MM13_ELT_s) resistor r=3.43331
    rVSS_63 (VSS_47 VSS_49) resistor r=0.0236893
    rVSS_62 (VSS_47 VSS_60) resistor r=0.0221284
    rVSS_61 (VSS_49 VSS_52) resistor r=0.157929
    rVSS_60 (VSS_57 VSS_58) resistor r=8.66667
    rVSS_59 (MM5_ELT_s VSS_62) resistor r=18.0507
    rVSS_58 (MM5_ELT_s VSS_65) resistor r=2.67027
    rVSS_57 (MM5_ELT_s VSS_67) resistor r=12.8495
    rVSS_56 (MM5_ELT_s VSS_67) resistor r=1.69926
    rVSS_55 (VSS_62 VSS_64) resistor r=9.43134
    rVSS_54 (VSS_63 VSS_65) resistor r=15.1041
    rVSS_53 (VSS_63 VSS_85) resistor r=11.0157
    rVSS_52 (VSS_64 VSS_65) resistor r=15.1041
    rVSS_51 (VSS_66 VSS_67) resistor r=12.8495
    rVSS_50 (VSS_66 VSS_87) resistor r=10.6787
    rVSS_49 (MM7_ELT_s VSS_71) resistor r=2.67027
    rVSS_48 (MM7_ELT_s VSS_73) resistor r=12.8495
    rVSS_47 (MM7_ELT_s VSS_73) resistor r=1.69926
    rVSS_46 (MM7_ELT_s VSS_76) resistor r=4.557
    rVSS_45 (MM7_ELT_s VSS_87) resistor r=10.6787
    rVSS_44 (VSS_69 VSS_71) resistor r=15.1041
    rVSS_43 (VSS_69 VSS_74) resistor r=9.43134
    rVSS_42 (VSS_70 VSS_71) resistor r=15.1041
    rVSS_41 (VSS_70 VSS_85) resistor r=11.0157
    rVSS_40 (VSS_72 VSS_73) resistor r=12.8495
    rVSS_39 (VSS_72 VSS_75) resistor r=9.4369
    rVSS_38 (VSS_74 VSS_76) resistor r=21.1301
    rVSS_37 (VSS_75 VSS_76) resistor r=21.1301
    rVSS_36 (MM13_ELT_s VSS_80) resistor r=2.67027
    rVSS_35 (MM13_ELT_s VSS_82) resistor r=12.8495
    rVSS_34 (MM13_ELT_s VSS_82) resistor r=1.69926
    rVSS_33 (MM13_ELT_s VSS_83) resistor r=18.0507
    rVSS_32 (VSS_78 VSS_80) resistor r=15.1041
    rVSS_31 (VSS_78 VSS_83) resistor r=9.43134
    rVSS_30 (VSS_79 VSS_80) resistor r=15.1041
    rVSS_29 (VSS_79 VSS_88) resistor r=9.89549
    rVSS_28 (VSS_81 VSS_82) resistor r=12.8495
    rVSS_27 (VSS_81 VSS_89) resistor r=9.80063
    rVSS_26 (VSS_84 VSS_85) resistor r=0.762262
    rVSS_25 (VSS_86 VSS_87) resistor r=0.57282
    rin1_96 (in1_22 in1_28) resistor r=58.3583
    rin1_95 (in1_22 in1_28) resistor r=4.16253
    rin1_94 (in1_22 in1_28) resistor r=58.3583
    rin1_93 (in1_22 in1_28) resistor r=4.16253
    rin1_92 (in1_25 in1_28) resistor r=58.3583
    rin1_91 (in1_25 in1_28) resistor r=4.16253
    rin1_90 (in1_25 in1_28) resistor r=58.3583
    rin1_89 (in1_25 in1_28) resistor r=4.16253
    rin1_88 (in1_28 in1_41) resistor r=24.8333
    rin1_87 (in1_28 in1_38) resistor r=24.8333
    rin1_86 (in1_28 in1_49) resistor r=24.8333
    rin1_85 (in1_28 in1_46) resistor r=24.8333
    rin1_84 (in1_28 in1_70) resistor r=58.3583
    rin1_83 (in1_28 in1_73) resistor r=58.3583
    rin1_82 (in1_28 in1_78) resistor r=14.9
    rin1_81 (in1_28 in1_41) resistor r=4.16253
    rin1_80 (in1_28 in1_49) resistor r=4.16253
    rin1_79 (in1_28 in1_38) resistor r=4.16253
    rin1_78 (in1_28 in1_70) resistor r=4.16253
    rin1_77 (in1_28 in1_78) resistor r=6.30933
    rin1_76 (in1_28 in1_73) resistor r=6.30933
    rin1_75 (in1_28 in1_46) resistor r=1.63969
    rin1_74 (in1_28 in1_41) resistor r=24.8333
    rin1_73 (in1_28 in1_38) resistor r=24.8333
    rin1_72 (in1_28 in1_49) resistor r=24.8333
    rin1_71 (in1_28 in1_46) resistor r=24.8333
    rin1_70 (in1_28 in1_70) resistor r=58.3583
    rin1_69 (in1_28 MM10_ELT_g) resistor r=22.35
    rin1_68 (in1_28 in1_78) resistor r=14.9
    rin1_67 (in1_28 in1_182) resistor r=40.975
    rin1_66 (in1_28 in1_41) resistor r=4.16253
    rin1_65 (in1_28 in1_49) resistor r=4.16253
    rin1_64 (in1_28 in1_38) resistor r=4.16253
    rin1_63 (in1_28 in1_70) resistor r=4.16253
    rin1_62 (in1_28 in1_78) resistor r=6.30933
    rin1_61 (in1_28 in1_73) resistor r=6.30933
    rin1_60 (in1_28 in1_46) resistor r=1.63969
    rin1_59 (in1_30 in1_36) resistor r=202.392
    rin1_58 (in1_30 in1_36) resistor r=4.16253
    rin1_57 (in1_30 in1_36) resistor r=202.392
    rin1_56 (in1_30 in1_36) resistor r=4.16253
    rin1_55 (in1_33 in1_36) resistor r=202.392
    rin1_54 (in1_33 in1_36) resistor r=4.16253
    rin1_53 (in1_33 in1_36) resistor r=202.392
    rin1_52 (in1_33 in1_36) resistor r=4.16253
    rin1_51 (in1_36 in1_57) resistor r=24.8333
    rin1_50 (in1_36 in1_54) resistor r=24.8333
    rin1_49 (in1_36 in1_65) resistor r=24.8333
    rin1_48 (in1_36 in1_62) resistor r=24.8333
    rin1_47 (in1_36 in1_84) resistor r=14.9
    rin1_46 (in1_36 in1_90) resistor r=202.392
    rin1_45 (in1_36 in1_93) resistor r=202.392
    rin1_44 (in1_36 in1_57) resistor r=4.16253
    rin1_43 (in1_36 in1_65) resistor r=4.16253
    rin1_42 (in1_36 in1_90) resistor r=6.30933
    rin1_41 (in1_36 in1_84) resistor r=6.30933
    rin1_40 (in1_36 in1_54) resistor r=1.63969
    rin1_39 (in1_36 in1_62) resistor r=4.16253
    rin1_38 (in1_36 in1_93) resistor r=4.16253
    rin1_37 (in1_36 in1_57) resistor r=24.8333
    rin1_36 (in1_36 in1_54) resistor r=24.8333
    rin1_35 (in1_36 in1_65) resistor r=24.8333
    rin1_34 (in1_36 in1_62) resistor r=24.8333
    rin1_33 (in1_36 in1_184) resistor r=40.975
    rin1_32 (in1_36 in1_84) resistor r=14.9
    rin1_31 (in1_36 in1_90) resistor r=202.392
    rin1_30 (in1_36 MM9_ELT_g) resistor r=7.45
    rin1_29 (in1_36 in1_57) resistor r=4.16253
    rin1_28 (in1_36 in1_65) resistor r=4.16253
    rin1_27 (in1_36 in1_90) resistor r=6.30933
    rin1_26 (in1_36 in1_84) resistor r=6.30933
    rin1_25 (in1_36 in1_54) resistor r=1.63969
    rin1_24 (in1_36 in1_62) resistor r=4.16253
    rin1_23 (in1_36 in1_93) resistor r=4.16253
    rin1_22 (in1_73 MM10_ELT_g) resistor r=36.0083
    rin1_21 (in1_93 MM9_ELT_g) resistor r=194.942
    rin1_20 (in1_132 in1_133) resistor r=10
    rin1_19 (in1_132 in1) resistor r=0.0868197
    rin1_18 (in1_133 in1_198) resistor r=4.06364
    rin1_17 (in1_182 in1_199) resistor r=10.0997
    rin1_16 (in1_184 in1_199) resistor r=10.0997
    rin1_15 (in1_198 in1_199) resistor r=0.877078
    rin0_96 (in0_22 in0_28) resistor r=58.3583
    rin0_95 (in0_22 in0_28) resistor r=4.16253
    rin0_94 (in0_22 in0_28) resistor r=58.3583
    rin0_93 (in0_22 in0_28) resistor r=4.16253
    rin0_92 (in0_25 in0_28) resistor r=58.3583
    rin0_91 (in0_25 in0_28) resistor r=4.16253
    rin0_90 (in0_25 in0_28) resistor r=58.3583
    rin0_89 (in0_25 in0_28) resistor r=4.16253
    rin0_88 (in0_28 in0_33) resistor r=24.8333
    rin0_87 (in0_28 in0_30) resistor r=24.8333
    rin0_86 (in0_28 in0_41) resistor r=24.8333
    rin0_85 (in0_28 in0_38) resistor r=24.8333
    rin0_84 (in0_28 in0_46) resistor r=58.3583
    rin0_83 (in0_28 in0_49) resistor r=58.3583
    rin0_82 (in0_28 in0_54) resistor r=14.9
    rin0_81 (in0_28 in0_33) resistor r=4.16253
    rin0_80 (in0_28 in0_41) resistor r=4.16253
    rin0_79 (in0_28 in0_30) resistor r=4.16253
    rin0_78 (in0_28 in0_46) resistor r=4.16253
    rin0_77 (in0_28 in0_54) resistor r=6.30933
    rin0_76 (in0_28 in0_49) resistor r=6.30933
    rin0_75 (in0_28 in0_38) resistor r=1.63969
    rin0_74 (in0_28 in0_33) resistor r=24.8333
    rin0_73 (in0_28 in0_30) resistor r=24.8333
    rin0_72 (in0_28 in0_41) resistor r=24.8333
    rin0_71 (in0_28 in0_38) resistor r=24.8333
    rin0_70 (in0_28 in0_46) resistor r=58.3583
    rin0_69 (in0_28 MM1_ELT_g) resistor r=22.35
    rin0_68 (in0_28 in0_54) resistor r=14.9
    rin0_67 (in0_28 in0_173) resistor r=40.975
    rin0_66 (in0_28 in0_33) resistor r=4.16253
    rin0_65 (in0_28 in0_41) resistor r=4.16253
    rin0_64 (in0_28 in0_30) resistor r=4.16253
    rin0_63 (in0_28 in0_46) resistor r=4.16253
    rin0_62 (in0_28 in0_54) resistor r=6.30933
    rin0_61 (in0_28 in0_49) resistor r=6.30933
    rin0_60 (in0_28 in0_38) resistor r=1.63969
    rin0_59 (in0_49 MM1_ELT_g) resistor r=36.0083
    rin0_58 (in0_60 in0_63) resistor r=14.9
    rin0_57 (in0_60 in0_63) resistor r=6.30933
    rin0_56 (in0_60 in0_63) resistor r=14.9
    rin0_55 (in0_60 in0_63) resistor r=6.30933
    rin0_54 (in0_63 in0_66) resistor r=202.392
    rin0_53 (in0_63 in0_69) resistor r=202.392
    rin0_52 (in0_63 in0_77) resistor r=24.8333
    rin0_51 (in0_63 in0_74) resistor r=24.8333
    rin0_50 (in0_63 in0_85) resistor r=24.8333
    rin0_49 (in0_63 in0_82) resistor r=24.8333
    rin0_48 (in0_63 in0_90) resistor r=202.392
    rin0_47 (in0_63 in0_93) resistor r=202.392
    rin0_46 (in0_63 in0_66) resistor r=6.30933
    rin0_45 (in0_63 in0_77) resistor r=1.63969
    rin0_44 (in0_63 in0_85) resistor r=4.16253
    rin0_43 (in0_63 in0_69) resistor r=4.16253
    rin0_42 (in0_63 in0_74) resistor r=4.16253
    rin0_41 (in0_63 in0_90) resistor r=4.16253
    rin0_40 (in0_63 in0_82) resistor r=4.16253
    rin0_39 (in0_63 in0_93) resistor r=4.16253
    rin0_38 (in0_63 in0_177) resistor r=40.975
    rin0_37 (in0_63 in0_66) resistor r=202.392
    rin0_36 (in0_63 in0_69) resistor r=202.392
    rin0_35 (in0_63 in0_77) resistor r=24.8333
    rin0_34 (in0_63 in0_74) resistor r=24.8333
    rin0_33 (in0_63 in0_85) resistor r=24.8333
    rin0_32 (in0_63 in0_82) resistor r=24.8333
    rin0_31 (in0_63 in0_90) resistor r=202.392
    rin0_30 (in0_63 MM2_ELT_g) resistor r=7.45
    rin0_29 (in0_63 in0_66) resistor r=6.30933
    rin0_28 (in0_63 in0_77) resistor r=1.63969
    rin0_27 (in0_63 in0_85) resistor r=4.16253
    rin0_26 (in0_63 in0_69) resistor r=4.16253
    rin0_25 (in0_63 in0_74) resistor r=4.16253
    rin0_24 (in0_63 in0_90) resistor r=4.16253
    rin0_23 (in0_63 in0_82) resistor r=4.16253
    rin0_22 (in0_63 in0_93) resistor r=4.16253
    rin0_21 (in0_93 MM2_ELT_g) resistor r=194.942
    rin0_20 (in0_132 in0_133) resistor r=10
    rin0_19 (in0_132 in0) resistor r=0.0868197
    rin0_18 (in0_133 in0_176) resistor r=3.82461
    rin0_17 (in0_133 in0_173) resistor r=5.47314
    rin0_16 (in0_175 in0_176) resistor r=27.0909
    rin0_15 (in0_175 in0_177) resistor r=9.29775
    rs0_142 (MM6_ELT_d s0) resistor r=0.01
    rs0_141 (s0_22 s0_25) resistor r=14.9
    rs0_140 (s0_22 s0_25) resistor r=6.30933
    rs0_139 (s0_22 s0_25) resistor r=14.9
    rs0_138 (s0_22 s0_25) resistor r=6.30933
    rs0_137 (s0_25 s0_28) resistor r=202.392
    rs0_136 (s0_25 s0_31) resistor r=202.392
    rs0_135 (s0_25 s0_39) resistor r=24.8333
    rs0_134 (s0_25 s0_36) resistor r=24.8333
    rs0_133 (s0_25 s0_47) resistor r=24.8333
    rs0_132 (s0_25 s0_44) resistor r=24.8333
    rs0_131 (s0_25 s0_52) resistor r=202.392
    rs0_130 (s0_25 s0_55) resistor r=202.392
    rs0_129 (s0_25 s0_28) resistor r=6.30933
    rs0_128 (s0_25 s0_39) resistor r=1.63969
    rs0_127 (s0_25 s0_47) resistor r=4.16253
    rs0_126 (s0_25 s0_31) resistor r=4.16253
    rs0_125 (s0_25 s0_36) resistor r=4.16253
    rs0_124 (s0_25 s0_52) resistor r=4.16253
    rs0_123 (s0_25 s0_44) resistor r=4.16253
    rs0_122 (s0_25 s0_55) resistor r=4.16253
    rs0_121 (s0_25 s0_191) resistor r=40.975
    rs0_120 (s0_25 s0_28) resistor r=202.392
    rs0_119 (s0_25 s0_31) resistor r=202.392
    rs0_118 (s0_25 s0_39) resistor r=24.8333
    rs0_117 (s0_25 s0_36) resistor r=24.8333
    rs0_116 (s0_25 s0_47) resistor r=24.8333
    rs0_115 (s0_25 s0_44) resistor r=24.8333
    rs0_114 (s0_25 s0_52) resistor r=202.392
    rs0_113 (s0_25 MM0_ELT_g) resistor r=7.45
    rs0_112 (s0_25 s0_28) resistor r=6.30933
    rs0_111 (s0_25 s0_39) resistor r=1.63969
    rs0_110 (s0_25 s0_47) resistor r=4.16253
    rs0_109 (s0_25 s0_31) resistor r=4.16253
    rs0_108 (s0_25 s0_36) resistor r=4.16253
    rs0_107 (s0_25 s0_52) resistor r=4.16253
    rs0_106 (s0_25 s0_44) resistor r=4.16253
    rs0_105 (s0_25 s0_55) resistor r=4.16253
    rs0_104 (s0_55 MM0_ELT_g) resistor r=194.942
    rs0_103 (s0_60 s0_66) resistor r=58.3583
    rs0_102 (s0_60 s0_66) resistor r=4.16253
    rs0_101 (s0_60 s0_66) resistor r=58.3583
    rs0_100 (s0_60 s0_66) resistor r=4.16253
    rs0_99 (s0_63 s0_66) resistor r=58.3583
    rs0_98 (s0_63 s0_66) resistor r=4.16253
    rs0_97 (s0_63 s0_66) resistor r=58.3583
    rs0_96 (s0_63 s0_66) resistor r=4.16253
    rs0_95 (s0_66 s0_71) resistor r=24.8333
    rs0_94 (s0_66 s0_68) resistor r=24.8333
    rs0_93 (s0_66 s0_79) resistor r=24.8333
    rs0_92 (s0_66 s0_76) resistor r=24.8333
    rs0_91 (s0_66 s0_84) resistor r=58.3583
    rs0_90 (s0_66 s0_87) resistor r=58.3583
    rs0_89 (s0_66 s0_92) resistor r=14.9
    rs0_88 (s0_66 s0_71) resistor r=4.16253
    rs0_87 (s0_66 s0_79) resistor r=4.16253
    rs0_86 (s0_66 s0_68) resistor r=4.16253
    rs0_85 (s0_66 s0_84) resistor r=4.16253
    rs0_84 (s0_66 s0_92) resistor r=6.30933
    rs0_83 (s0_66 s0_87) resistor r=6.30933
    rs0_82 (s0_66 s0_76) resistor r=1.63969
    rs0_81 (s0_66 s0_71) resistor r=24.8333
    rs0_80 (s0_66 s0_68) resistor r=24.8333
    rs0_79 (s0_66 s0_79) resistor r=24.8333
    rs0_78 (s0_66 s0_76) resistor r=24.8333
    rs0_77 (s0_66 s0_84) resistor r=58.3583
    rs0_76 (s0_66 MM11_ELT_g) resistor r=22.35
    rs0_75 (s0_66 s0_92) resistor r=14.9
    rs0_74 (s0_66 s0_223) resistor r=40.975
    rs0_73 (s0_66 s0_71) resistor r=4.16253
    rs0_72 (s0_66 s0_79) resistor r=4.16253
    rs0_71 (s0_66 s0_68) resistor r=4.16253
    rs0_70 (s0_66 s0_84) resistor r=4.16253
    rs0_69 (s0_66 s0_92) resistor r=6.30933
    rs0_68 (s0_66 s0_87) resistor r=6.30933
    rs0_67 (s0_66 s0_76) resistor r=1.63969
    rs0_66 (s0_87 MM11_ELT_g) resistor r=36.0083
    rs0_65 (s0_131 s0_133) resistor r=0.425765
    rs0_64 (s0_131 s0_148) resistor r=0.0959622
    rs0_63 (s0_133 s0_134) resistor r=13
    rs0_62 (s0_134 MM7_ELT_d) resistor r=8.44
    rs0_61 (s0_136 s0_138) resistor r=0.510919
    rs0_60 (s0_136 s0_150) resistor r=0.0959622
    rs0_59 (s0_138 s0_139) resistor r=8.66667
    rs0_58 (s0_138 s0_141) resistor r=0.638648
    rs0_57 (s0_139 s0) resistor r=32.3614
    rs0_56 (s0_141 s0_142) resistor r=8.66667
    rs0_55 (s0_141 s0_144) resistor r=0.425765
    rs0_54 (s0_142 s0) resistor r=16.1807
    rs0_53 (s0_142 s0_145) resistor r=32.3614
    rs0_52 (s0_144 s0_145) resistor r=26
    rs0_51 (s0_147 s0_148) resistor r=0.112082
    rs0_50 (s0_147 s0_151) resistor r=0.0959622
    rs0_49 (s0_149 s0_150) resistor r=0.112082
    rs0_48 (s0_149 s0_154) resistor r=0.0959622
    rs0_47 (s0_151 s0_152) resistor r=0.0925895
    rs0_46 (s0_152 s0_156) resistor r=0.12377
    rs0_45 (s0_153 s0_154) resistor r=0.0925895
    rs0_44 (s0_153 s0_156) resistor r=0.12377
    rs0_43 (s0_156 s0_163) resistor r=0.0144857
    rs0_42 (s0_157 s0_158) resistor r=0.93592
    rs0_41 (s0_157 s0_165) resistor r=0.0591765
    rs0_40 (s0_158 s0_159) resistor r=0.0591765
    rs0_39 (s0_159 s0_162) resistor r=0.0899925
    rs0_38 (s0_162 s0_163) resistor r=0.75
    rs0_37 (s0_163 s0_237) resistor r=10
    rs0_36 (s0_165 s0_168) resistor r=0.0899925
    rs0_35 (s0_168 s0_169) resistor r=0.75
    rs0_34 (s0_169 s0_241) resistor r=10
    rs0_33 (s0_191 s0_227) resistor r=9.29775
    rs0_32 (s0_223 s0_241) resistor r=5.45041
    rs0_31 (s0_227 s0_237) resistor r=30.4773
    rs0B_236 (MM4_ELT_d s0B) resistor r=0.01
    rs0B_235 (s0B_42 s0B_48) resistor r=58.3583
    rs0B_234 (s0B_42 s0B_48) resistor r=4.16253
    rs0B_233 (s0B_42 s0B_48) resistor r=58.3583
    rs0B_232 (s0B_42 s0B_48) resistor r=4.16253
    rs0B_231 (s0B_45 s0B_48) resistor r=58.3583
    rs0B_230 (s0B_45 s0B_48) resistor r=6.30933
    rs0B_229 (s0B_45 s0B_48) resistor r=58.3583
    rs0B_228 (s0B_45 s0B_48) resistor r=6.30933
    rs0B_227 (s0B_48 s0B_50) resistor r=14.9
    rs0B_226 (s0B_48 s0B_73) resistor r=24.8333
    rs0B_225 (s0B_48 s0B_70) resistor r=24.8333
    rs0B_224 (s0B_48 s0B_81) resistor r=24.8333
    rs0B_223 (s0B_48 s0B_78) resistor r=24.8333
    rs0B_222 (s0B_48 s0B_102) resistor r=58.3583
    rs0B_221 (s0B_48 s0B_105) resistor r=58.3583
    rs0B_220 (s0B_48 s0B_73) resistor r=4.16253
    rs0B_219 (s0B_48 s0B_50) resistor r=6.30933
    rs0B_218 (s0B_48 s0B_81) resistor r=1.63969
    rs0B_217 (s0B_48 s0B_70) resistor r=4.16253
    rs0B_216 (s0B_48 s0B_102) resistor r=4.16253
    rs0B_215 (s0B_48 s0B_78) resistor r=4.16253
    rs0B_214 (s0B_48 s0B_105) resistor r=4.16253
    rs0B_213 (s0B_48 s0B_50) resistor r=14.9
    rs0B_212 (s0B_48 s0B_345) resistor r=40.975
    rs0B_211 (s0B_48 s0B_73) resistor r=24.8333
    rs0B_210 (s0B_48 s0B_70) resistor r=24.8333
    rs0B_209 (s0B_48 s0B_81) resistor r=24.8333
    rs0B_208 (s0B_48 s0B_78) resistor r=24.8333
    rs0B_207 (s0B_48 s0B_102) resistor r=58.3583
    rs0B_206 (s0B_48 MM7_ELT_g) resistor r=7.45
    rs0B_205 (s0B_48 s0B_73) resistor r=4.16253
    rs0B_204 (s0B_48 s0B_50) resistor r=6.30933
    rs0B_203 (s0B_48 s0B_81) resistor r=1.63969
    rs0B_202 (s0B_48 s0B_70) resistor r=4.16253
    rs0B_201 (s0B_48 s0B_102) resistor r=4.16253
    rs0B_200 (s0B_48 s0B_78) resistor r=4.16253
    rs0B_199 (s0B_48 s0B_105) resistor r=4.16253
    rs0B_198 (s0B_56 s0B_59) resistor r=14.9
    rs0B_197 (s0B_56 s0B_59) resistor r=6.30933
    rs0B_196 (s0B_56 s0B_59) resistor r=14.9
    rs0B_195 (s0B_56 s0B_59) resistor r=6.30933
    rs0B_194 (s0B_59 s0B_62) resistor r=202.392
    rs0B_193 (s0B_59 s0B_65) resistor r=202.392
    rs0B_192 (s0B_59 s0B_89) resistor r=24.8333
    rs0B_191 (s0B_59 s0B_86) resistor r=24.8333
    rs0B_190 (s0B_59 s0B_97) resistor r=24.8333
    rs0B_189 (s0B_59 s0B_94) resistor r=24.8333
    rs0B_188 (s0B_59 s0B_110) resistor r=202.392
    rs0B_187 (s0B_59 s0B_113) resistor r=202.392
    rs0B_186 (s0B_59 s0B_62) resistor r=6.30933
    rs0B_185 (s0B_59 s0B_89) resistor r=1.63969
    rs0B_184 (s0B_59 s0B_97) resistor r=4.16253
    rs0B_183 (s0B_59 s0B_65) resistor r=4.16253
    rs0B_182 (s0B_59 s0B_86) resistor r=4.16253
    rs0B_181 (s0B_59 s0B_110) resistor r=4.16253
    rs0B_180 (s0B_59 s0B_94) resistor r=4.16253
    rs0B_179 (s0B_59 s0B_113) resistor r=4.16253
    rs0B_178 (s0B_59 s0B_347) resistor r=40.975
    rs0B_177 (s0B_59 s0B_62) resistor r=202.392
    rs0B_176 (s0B_59 s0B_65) resistor r=202.392
    rs0B_175 (s0B_59 s0B_89) resistor r=24.8333
    rs0B_174 (s0B_59 s0B_86) resistor r=24.8333
    rs0B_173 (s0B_59 s0B_97) resistor r=24.8333
    rs0B_172 (s0B_59 s0B_94) resistor r=24.8333
    rs0B_171 (s0B_59 s0B_110) resistor r=202.392
    rs0B_170 (s0B_59 MM6_ELT_g) resistor r=7.45
    rs0B_169 (s0B_59 s0B_62) resistor r=6.30933
    rs0B_168 (s0B_59 s0B_89) resistor r=1.63969
    rs0B_167 (s0B_59 s0B_97) resistor r=4.16253
    rs0B_166 (s0B_59 s0B_65) resistor r=4.16253
    rs0B_165 (s0B_59 s0B_86) resistor r=4.16253
    rs0B_164 (s0B_59 s0B_110) resistor r=4.16253
    rs0B_163 (s0B_59 s0B_94) resistor r=4.16253
    rs0B_162 (s0B_59 s0B_113) resistor r=4.16253
    rs0B_161 (s0B_105 MM7_ELT_g) resistor r=50.9083
    rs0B_160 (s0B_113 MM6_ELT_g) resistor r=194.942
    rs0B_159 (s0B_118 s0B_124) resistor r=58.3583
    rs0B_158 (s0B_118 s0B_124) resistor r=4.16253
    rs0B_157 (s0B_118 s0B_124) resistor r=58.3583
    rs0B_156 (s0B_118 s0B_124) resistor r=4.16253
    rs0B_155 (s0B_121 s0B_124) resistor r=58.3583
    rs0B_154 (s0B_121 s0B_124) resistor r=4.16253
    rs0B_153 (s0B_121 s0B_124) resistor r=58.3583
    rs0B_152 (s0B_121 s0B_124) resistor r=4.16253
    rs0B_151 (s0B_124 s0B_129) resistor r=24.8333
    rs0B_150 (s0B_124 s0B_126) resistor r=24.8333
    rs0B_149 (s0B_124 s0B_137) resistor r=24.8333
    rs0B_148 (s0B_124 s0B_134) resistor r=24.8333
    rs0B_147 (s0B_124 s0B_142) resistor r=58.3583
    rs0B_146 (s0B_124 s0B_145) resistor r=58.3583
    rs0B_145 (s0B_124 s0B_150) resistor r=14.9
    rs0B_144 (s0B_124 s0B_129) resistor r=4.16253
    rs0B_143 (s0B_124 s0B_137) resistor r=4.16253
    rs0B_142 (s0B_124 s0B_126) resistor r=4.16253
    rs0B_141 (s0B_124 s0B_142) resistor r=4.16253
    rs0B_140 (s0B_124 s0B_150) resistor r=6.30933
    rs0B_139 (s0B_124 s0B_145) resistor r=6.30933
    rs0B_138 (s0B_124 s0B_134) resistor r=1.63969
    rs0B_137 (s0B_124 s0B_129) resistor r=24.8333
    rs0B_136 (s0B_124 s0B_126) resistor r=24.8333
    rs0B_135 (s0B_124 s0B_137) resistor r=24.8333
    rs0B_134 (s0B_124 s0B_134) resistor r=24.8333
    rs0B_133 (s0B_124 s0B_142) resistor r=58.3583
    rs0B_132 (s0B_124 MM3_ELT_g) resistor r=22.35
    rs0B_131 (s0B_124 s0B_150) resistor r=14.9
    rs0B_130 (s0B_124 s0B_392) resistor r=40.975
    rs0B_129 (s0B_124 s0B_129) resistor r=4.16253
    rs0B_128 (s0B_124 s0B_137) resistor r=4.16253
    rs0B_127 (s0B_124 s0B_126) resistor r=4.16253
    rs0B_126 (s0B_124 s0B_142) resistor r=4.16253
    rs0B_125 (s0B_124 s0B_150) resistor r=6.30933
    rs0B_124 (s0B_124 s0B_145) resistor r=6.30933
    rs0B_123 (s0B_124 s0B_134) resistor r=1.63969
    rs0B_122 (s0B_145 MM3_ELT_g) resistor r=36.0083
    rs0B_121 (s0B_156 s0B_159) resistor r=14.9
    rs0B_120 (s0B_156 s0B_159) resistor r=6.30933
    rs0B_119 (s0B_156 s0B_159) resistor r=14.9
    rs0B_118 (s0B_156 s0B_159) resistor r=6.30933
    rs0B_117 (s0B_159 s0B_162) resistor r=202.392
    rs0B_116 (s0B_159 s0B_165) resistor r=202.392
    rs0B_115 (s0B_159 s0B_173) resistor r=24.8333
    rs0B_114 (s0B_159 s0B_170) resistor r=24.8333
    rs0B_113 (s0B_159 s0B_181) resistor r=24.8333
    rs0B_112 (s0B_159 s0B_178) resistor r=24.8333
    rs0B_111 (s0B_159 s0B_186) resistor r=202.392
    rs0B_110 (s0B_159 s0B_189) resistor r=202.392
    rs0B_109 (s0B_159 s0B_162) resistor r=6.30933
    rs0B_108 (s0B_159 s0B_173) resistor r=1.63969
    rs0B_107 (s0B_159 s0B_181) resistor r=4.16253
    rs0B_106 (s0B_159 s0B_165) resistor r=4.16253
    rs0B_105 (s0B_159 s0B_170) resistor r=4.16253
    rs0B_104 (s0B_159 s0B_186) resistor r=4.16253
    rs0B_103 (s0B_159 s0B_178) resistor r=4.16253
    rs0B_102 (s0B_159 s0B_189) resistor r=4.16253
    rs0B_101 (s0B_159 s0B_394) resistor r=40.975
    rs0B_100 (s0B_159 s0B_162) resistor r=202.392
    rs0B_99 (s0B_159 s0B_165) resistor r=202.392
    rs0B_98 (s0B_159 s0B_173) resistor r=24.8333
    rs0B_97 (s0B_159 s0B_170) resistor r=24.8333
    rs0B_96 (s0B_159 s0B_181) resistor r=24.8333
    rs0B_95 (s0B_159 s0B_178) resistor r=24.8333
    rs0B_94 (s0B_159 s0B_186) resistor r=202.392
    rs0B_93 (s0B_159 MM8_ELT_g) resistor r=7.45
    rs0B_92 (s0B_159 s0B_162) resistor r=6.30933
    rs0B_91 (s0B_159 s0B_173) resistor r=1.63969
    rs0B_90 (s0B_159 s0B_181) resistor r=4.16253
    rs0B_89 (s0B_159 s0B_165) resistor r=4.16253
    rs0B_88 (s0B_159 s0B_170) resistor r=4.16253
    rs0B_87 (s0B_159 s0B_186) resistor r=4.16253
    rs0B_86 (s0B_159 s0B_178) resistor r=4.16253
    rs0B_85 (s0B_159 s0B_189) resistor r=4.16253
    rs0B_84 (s0B_189 MM8_ELT_g) resistor r=194.942
    rs0B_83 (s0B_261 s0B_263) resistor r=0.425765
    rs0B_82 (s0B_261 s0B_278) resistor r=0.0959622
    rs0B_81 (s0B_263 s0B_264) resistor r=13
    rs0B_80 (s0B_264 MM5_ELT_d) resistor r=8.44
    rs0B_79 (s0B_266 s0B_268) resistor r=0.510919
    rs0B_78 (s0B_266 s0B_280) resistor r=0.0959622
    rs0B_77 (s0B_268 s0B_269) resistor r=8.66667
    rs0B_76 (s0B_268 s0B_271) resistor r=0.638648
    rs0B_75 (s0B_269 s0B) resistor r=32.3614
    rs0B_74 (s0B_271 s0B_272) resistor r=8.66667
    rs0B_73 (s0B_271 s0B_274) resistor r=0.425765
    rs0B_72 (s0B_272 s0B) resistor r=16.1807
    rs0B_71 (s0B_272 s0B_275) resistor r=32.3614
    rs0B_70 (s0B_274 s0B_275) resistor r=26
    rs0B_69 (s0B_277 s0B_278) resistor r=0.107209
    rs0B_68 (s0B_277 s0B_281) resistor r=0.0959622
    rs0B_67 (s0B_279 s0B_280) resistor r=0.107209
    rs0B_66 (s0B_279 s0B_284) resistor r=0.0959622
    rs0B_65 (s0B_281 s0B_282) resistor r=0.0925895
    rs0B_64 (s0B_282 s0B_286) resistor r=0.12377
    rs0B_63 (s0B_283 s0B_284) resistor r=0.0925895
    rs0B_62 (s0B_283 s0B_286) resistor r=0.12377
    rs0B_61 (s0B_286 s0B_291) resistor r=0.0144857
    rs0B_60 (s0B_287 s0B_288) resistor r=0.939425
    rs0B_59 (s0B_287 s0B_299) resistor r=0.0591765
    rs0B_58 (s0B_288 s0B_293) resistor r=0.0591765
    rs0B_57 (s0B_290 s0B_291) resistor r=0.75
    rs0B_56 (s0B_290 s0B_293) resistor r=0.0899925
    rs0B_55 (s0B_291 s0B_432) resistor r=10
    rs0B_54 (s0B_296 s0B_297) resistor r=0.75
    rs0B_53 (s0B_296 s0B_299) resistor r=0.0899925
    rs0B_52 (s0B_297 s0B_436) resistor r=10
    rs0B_51 (s0B_345 s0B_414) resistor r=3.725
    rs0B_50 (s0B_347 s0B_414) resistor r=3.725
    rs0B_49 (s0B_392 s0B_425) resistor r=9.29775
    rs0B_48 (s0B_394 s0B_426) resistor r=9.29775
    rs0B_47 (s0B_413 s0B_414) resistor r=3.725
    rs0B_46 (s0B_413 s0B_432) resistor r=9.48182
    rs0B_45 (s0B_425 s0B_436) resistor r=11.5136
    rs0B_44 (s0B_426 s0B_436) resistor r=37.25
    rs_96 (s_22 s_28) resistor r=58.3583
    rs_95 (s_22 s_28) resistor r=4.16253
    rs_94 (s_22 s_28) resistor r=58.3583
    rs_93 (s_22 s_28) resistor r=4.16253
    rs_92 (s_25 s_28) resistor r=58.3583
    rs_91 (s_25 s_28) resistor r=6.30933
    rs_90 (s_25 s_28) resistor r=58.3583
    rs_89 (s_25 s_28) resistor r=6.30933
    rs_88 (s_28 s_30) resistor r=14.9
    rs_87 (s_28 s_53) resistor r=24.8333
    rs_86 (s_28 s_50) resistor r=24.8333
    rs_85 (s_28 s_61) resistor r=24.8333
    rs_84 (s_28 s_58) resistor r=24.8333
    rs_83 (s_28 s_82) resistor r=58.3583
    rs_82 (s_28 s_85) resistor r=58.3583
    rs_81 (s_28 s_53) resistor r=4.16253
    rs_80 (s_28 s_30) resistor r=6.30933
    rs_79 (s_28 s_61) resistor r=1.63969
    rs_78 (s_28 s_50) resistor r=4.16253
    rs_77 (s_28 s_82) resistor r=4.16253
    rs_76 (s_28 s_58) resistor r=4.16253
    rs_75 (s_28 s_85) resistor r=4.16253
    rs_74 (s_28 s_30) resistor r=14.9
    rs_73 (s_28 s_162) resistor r=40.975
    rs_72 (s_28 s_53) resistor r=24.8333
    rs_71 (s_28 s_50) resistor r=24.8333
    rs_70 (s_28 s_61) resistor r=24.8333
    rs_69 (s_28 s_58) resistor r=24.8333
    rs_68 (s_28 s_82) resistor r=58.3583
    rs_67 (s_28 MM5_ELT_g) resistor r=7.45
    rs_66 (s_28 s_53) resistor r=4.16253
    rs_65 (s_28 s_30) resistor r=6.30933
    rs_64 (s_28 s_61) resistor r=1.63969
    rs_63 (s_28 s_50) resistor r=4.16253
    rs_62 (s_28 s_82) resistor r=4.16253
    rs_61 (s_28 s_58) resistor r=4.16253
    rs_60 (s_28 s_85) resistor r=4.16253
    rs_59 (s_36 s_39) resistor r=14.9
    rs_58 (s_36 s_39) resistor r=6.30933
    rs_57 (s_36 s_39) resistor r=14.9
    rs_56 (s_36 s_39) resistor r=6.30933
    rs_55 (s_39 s_42) resistor r=202.392
    rs_54 (s_39 s_45) resistor r=202.392
    rs_53 (s_39 s_69) resistor r=24.8333
    rs_52 (s_39 s_66) resistor r=24.8333
    rs_51 (s_39 s_77) resistor r=24.8333
    rs_50 (s_39 s_74) resistor r=24.8333
    rs_49 (s_39 s_90) resistor r=202.392
    rs_48 (s_39 s_93) resistor r=202.392
    rs_47 (s_39 s_42) resistor r=6.30933
    rs_46 (s_39 s_69) resistor r=1.63969
    rs_45 (s_39 s_77) resistor r=4.16253
    rs_44 (s_39 s_45) resistor r=4.16253
    rs_43 (s_39 s_66) resistor r=4.16253
    rs_42 (s_39 s_90) resistor r=4.16253
    rs_41 (s_39 s_74) resistor r=4.16253
    rs_40 (s_39 s_93) resistor r=4.16253
    rs_39 (s_39 s_164) resistor r=40.975
    rs_38 (s_39 s_42) resistor r=202.392
    rs_37 (s_39 s_45) resistor r=202.392
    rs_36 (s_39 s_69) resistor r=24.8333
    rs_35 (s_39 s_66) resistor r=24.8333
    rs_34 (s_39 s_77) resistor r=24.8333
    rs_33 (s_39 s_74) resistor r=24.8333
    rs_32 (s_39 s_90) resistor r=202.392
    rs_31 (s_39 MM4_ELT_g) resistor r=7.45
    rs_30 (s_39 s_42) resistor r=6.30933
    rs_29 (s_39 s_69) resistor r=1.63969
    rs_28 (s_39 s_77) resistor r=4.16253
    rs_27 (s_39 s_45) resistor r=4.16253
    rs_26 (s_39 s_66) resistor r=4.16253
    rs_25 (s_39 s_90) resistor r=4.16253
    rs_24 (s_39 s_74) resistor r=4.16253
    rs_23 (s_39 s_93) resistor r=4.16253
    rs_22 (s_85 MM5_ELT_g) resistor r=50.9083
    rs_21 (s_93 MM4_ELT_g) resistor r=194.942
    rs_20 (s_132 s_133) resistor r=10
    rs_19 (s_132 s) resistor r=0.0845635
    rs_18 (s_133 s_196) resistor r=9.48182
    rs_17 (s_162 s_197) resistor r=3.725
    rs_16 (s_164 s_197) resistor r=3.725
    rs_15 (s_196 s_197) resistor r=3.725
ends MUX2_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: OR2D1_LVT_ELT
// View name: calibre
subckt OR2D1_LVT_ELT A1 A2 VDD VSS Z
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciZ_6 (Z_3 VSS) capacitor c=4.75457e-17
    ciZ_5 (Z_4 VSS) capacitor c=1.11634e-16
    ciZ_4 (Z_8 VSS) capacitor c=1.73913e-16
    ciZ_3 (Z_9 VSS) capacitor c=3.29935e-16
    ciZ_2 (Z VSS) capacitor c=8.84406e-17
    ciZ_1 (Z_23 VSS) capacitor c=2.2102e-17
    ciZ_0 (Z_27 VSS) capacitor c=1.71932e-17
    ciVDD_11 (VDD_2 VSS) capacitor c=1.2761e-16
    ciVDD_10 (VDD_14 VSS) capacitor c=2.44688e-16
    ciVDD_9 (VDD_22 VSS) capacitor c=1.67455e-17
    ciVDD_8 (VDD_28 VSS) capacitor c=6.30088e-17
    ciVDD_7 (VDD_31 VSS) capacitor c=3.58509e-18
    ciVDD_6 (MM11_ELT_s VSS) capacitor c=3.51145e-17
    ciVDD_5 (VDD_38 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_40 VSS) capacitor c=1.07074e-18
    ciVDD_3 (MM7_ELT_s VSS) capacitor c=1.83252e-17
    ciVDD_2 (VDD_43 VSS) capacitor c=5.11928e-18
    ciVDD_1 (VDD_46 VSS) capacitor c=1.11099e-18
    ciVDD_0 (VDD_51 VSS) capacitor c=3.66645e-16
    ciVSS_14 (VSS_2 VSS) capacitor c=6.19147e-17
    ciVSS_13 (VSS_11 VSS) capacitor c=6.11693e-17
    ciVSS_12 (VSS_14 VSS) capacitor c=4.60554e-17
    ciVSS_11 (VSS_21 VSS) capacitor c=7.23191e-17
    ciVSS_10 (VSS_22 VSS) capacitor c=1.19561e-16
    ciVSS_9 (VSS_29 VSS) capacitor c=6.07465e-17
    ciVSS_8 (VSS_32 VSS) capacitor c=3.58509e-18
    ciVSS_7 (VSS_33 VSS) capacitor c=3.58509e-18
    ciVSS_6 (VSS_42 VSS) capacitor c=2.95832e-18
    ciVSS_5 (MM1_ELT_s VSS) capacitor c=5.29847e-18
    ciVSS_4 (VSS_49 VSS) capacitor c=1.54757e-18
    ciVSS_3 (MM4_ELT_s VSS) capacitor c=4.05795e-18
    ciVSS_2 (VSS_55 VSS) capacitor c=3.01246e-18
    ciVSS_1 (VSS_57 VSS) capacitor c=7.27989e-17
    ciVSS_0 (VSS_61 VSS) capacitor c=2.71916e-18
    cinet27_28 (net27_22 VSS) capacitor c=4.28147e-18
    cinet27_27 (net27_25 VSS) capacitor c=3.31101e-18
    cinet27_26 (net27_28 VSS) capacitor c=1.88128e-16
    cinet27_25 (net27_30 VSS) capacitor c=3.39992e-18
    cinet27_24 (net27_33 VSS) capacitor c=4.28147e-18
    cinet27_23 (net27_36 VSS) capacitor c=5.74636e-16
    cinet27_22 (net27_38 VSS) capacitor c=2.23559e-17
    cinet27_21 (net27_46 VSS) capacitor c=2.02494e-17
    cinet27_20 (net27_54 VSS) capacitor c=1.20608e-17
    cinet27_19 (net27_62 VSS) capacitor c=1.51948e-17
    cinet27_18 (net27_70 VSS) capacitor c=2.11871e-18
    cinet27_17 (net27_93 VSS) capacitor c=2.22299e-18
    cinet27_16 (net27_133 VSS) capacitor c=5.37953e-17
    cinet27_15 (net27_134 VSS) capacitor c=1.11612e-16
    cinet27_14 (net27_138 VSS) capacitor c=1.95293e-16
    cinet27_13 (net27_139 VSS) capacitor c=3.22399e-16
    cinet27_12 (net27_147 VSS) capacitor c=2.29277e-17
    cinet27_11 (net27_148 VSS) capacitor c=1.11722e-17
    cinet27_10 (net27_150 VSS) capacitor c=4.69579e-17
    cinet27_9 (net27_151 VSS) capacitor c=7.20254e-17
    cinet27_8 (net27_152 VSS) capacitor c=3.35138e-17
    cinet27_7 (net27_155 VSS) capacitor c=5.19309e-17
    cinet27_6 (net27_156 VSS) capacitor c=1.13024e-16
    cinet27_5 (net27_159 VSS) capacitor c=6.90373e-18
    cinet27_4 (net27_160 VSS) capacitor c=1.92301e-17
    cinet27_3 (net27_162 VSS) capacitor c=3.73588e-17
    cinet27_2 (net27_169 VSS) capacitor c=2.40655e-17
    cinet27_1 (net27_231 VSS) capacitor c=3.89518e-17
    cinet27_0 (net27_232 VSS) capacitor c=6.69133e-18
    cinet29_11 (net29_3 VSS) capacitor c=5.65323e-17
    cinet29_10 (net29_8 VSS) capacitor c=5.78568e-17
    cinet29_9 (net29_14 VSS) capacitor c=3.11727e-17
    cinet29_8 (net29_18 VSS) capacitor c=5.59956e-17
    cinet29_7 (net29_19 VSS) capacitor c=3.45376e-16
    cinet29_6 (net29_23 VSS) capacitor c=5.56197e-17
    cinet29_5 (net29_29 VSS) capacitor c=1.09619e-17
    cinet29_4 (net29_30 VSS) capacitor c=1.09619e-17
    cinet29_3 (net29_34 VSS) capacitor c=1.32762e-17
    cinet29_2 (net29_36 VSS) capacitor c=4.62911e-18
    cinet29_1 (net29_39 VSS) capacitor c=1.11099e-18
    cinet29_0 (net29_40 VSS) capacitor c=2.40044e-16
    ciA2_14 (A2_22 VSS) capacitor c=3.32033e-18
    ciA2_13 (A2_28 VSS) capacitor c=2.09475e-16
    ciA2_12 (A2_39 VSS) capacitor c=6.30865e-16
    ciA2_11 (A2_45 VSS) capacitor c=3.88523e-18
    ciA2_10 (A2_50 VSS) capacitor c=2.23697e-17
    ciA2_9 (A2_58 VSS) capacitor c=2.47143e-17
    ciA2_8 (A2_66 VSS) capacitor c=8.97212e-18
    ciA2_7 (A2_74 VSS) capacitor c=1.51948e-17
    ciA2_6 (A2_82 VSS) capacitor c=2.96645e-18
    ciA2_5 (A2_85 VSS) capacitor c=8.99943e-18
    ciA2_4 (A2_90 VSS) capacitor c=4.53692e-18
    ciA2_3 (A2_93 VSS) capacitor c=4.28147e-18
    ciA2_2 (A2 VSS) capacitor c=6.27868e-17
    ciA2_1 (A2_194 VSS) capacitor c=3.18954e-17
    ciA2_0 (A2_195 VSS) capacitor c=1.47496e-17
    ciA1_12 (A1_22 VSS) capacitor c=2.22299e-18
    ciA1_11 (A1_28 VSS) capacitor c=1.88095e-16
    ciA1_10 (A1_33 VSS) capacitor c=2.22299e-18
    ciA1_9 (A1_36 VSS) capacitor c=5.77724e-16
    ciA1_8 (A1_38 VSS) capacitor c=2.2416e-17
    ciA1_7 (A1_46 VSS) capacitor c=2.16891e-17
    ciA1_6 (A1_54 VSS) capacitor c=1.50847e-17
    ciA1_5 (A1_62 VSS) capacitor c=1.51948e-17
    ciA1_4 (A1_70 VSS) capacitor c=4.24886e-18
    ciA1_3 (A1_93 VSS) capacitor c=3.88523e-18
    ciA1_2 (A1 VSS) capacitor c=4.49651e-17
    ciA1_1 (A1_198 VSS) capacitor c=2.75557e-17
    ciA1_0 (A1_199 VSS) capacitor c=1.1684e-17
    rZ_26 (Z_1 Z_3) resistor r=0.303672
    rZ_25 (Z_1 Z_21) resistor r=0.0100972
    rZ_24 (Z_3 Z_4) resistor r=13
    rZ_23 (Z_4 MM4_ELT_d) resistor r=8.44
    rZ_22 (Z_6 Z_8) resistor r=0.340965
    rZ_21 (Z_6 Z_25) resistor r=0.0100972
    rZ_20 (Z_8 Z_9) resistor r=8.66667
    rZ_19 (Z_8 Z_11) resistor r=0.63931
    rZ_18 (Z_9 MM7_ELT_d) resistor r=32.3614
    rZ_17 (Z_11 Z_12) resistor r=8.66667
    rZ_16 (Z_11 Z_14) resistor r=0.426206
    rZ_15 (Z_12 MM7_ELT_d) resistor r=16.1807
    rZ_14 (Z_12 Z_15) resistor r=32.3614
    rZ_13 (Z_14 Z_15) resistor r=26
    rZ_12 (Z_17 Z) resistor r=0.156102
    rZ_11 (Z_17 Z_23) resistor r=0.0100972
    rZ_10 (Z_18 Z) resistor r=0.618944
    rZ_9 (Z_18 Z_27) resistor r=0.0100972
    rZ_8 (Z_21 Z_23) resistor r=0.126833
    rZ_7 (Z_25 Z_27) resistor r=0.126833
    rVDD_59 (MM11_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_58 (MM7_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_57 (MM10_ELT_b VDD_25) resistor r=8.66667
    rVDD_56 (MM10_ELT_b VDD_28) resistor r=26
    rVDD_55 (MM10_ELT_b VDD_11) resistor r=11.2533
    rVDD_54 (VDD_2 VDD_10) resistor r=0.16794
    rVDD_53 (VDD_2 VDD_31) resistor r=0.0221469
    rVDD_52 (VDD VDD_7) resistor r=0.10274
    rVDD_51 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_50 (VDD_7 VDD_10) resistor r=0.237092
    rVDD_49 (VDD_8 VDD_11) resistor r=67.52
    rVDD_48 (VDD_10 VDD_11) resistor r=8.66667
    rVDD_47 (VDD_12 VDD_21) resistor r=0.415288
    rVDD_46 (VDD_12 VDD_31) resistor r=0.0882088
    rVDD_45 (VDD_14 VDD_22) resistor r=8.66667
    rVDD_44 (VDD_14 VDD_18) resistor r=0.701895
    rVDD_43 (VDD_18 VDD_22) resistor r=8.66667
    rVDD_42 (VDD_18 VDD_21) resistor r=0.701895
    rVDD_41 (VDD_21 VDD_22) resistor r=8.66667
    rVDD_40 (VDD_22 MM7_ELT_s) resistor r=4.04518
    rVDD_39 (VDD_22 VDD_50) resistor r=4.04518
    rVDD_38 (VDD_22 MM11_ELT_s) resistor r=4.04518
    rVDD_37 (VDD_22 VDD_48) resistor r=4.04518
    rVDD_36 (VDD_23 VDD_25) resistor r=0.0335881
    rVDD_35 (VDD_23 VDD_31) resistor r=0.0221469
    rVDD_34 (VDD_25 VDD_28) resistor r=0.158062
    rVDD_33 (MM11_ELT_s VDD_35) resistor r=25.7298
    rVDD_32 (MM11_ELT_s VDD_38) resistor r=2.55965
    rVDD_31 (MM11_ELT_s VDD_40) resistor r=12.3172
    rVDD_30 (MM11_ELT_s VDD_40) resistor r=1.62887
    rVDD_29 (VDD_35 VDD_37) resistor r=9.04062
    rVDD_28 (VDD_36 VDD_38) resistor r=14.4784
    rVDD_27 (VDD_36 VDD_51) resistor r=10.5593
    rVDD_26 (VDD_37 VDD_38) resistor r=14.4784
    rVDD_25 (VDD_39 VDD_40) resistor r=12.3172
    rVDD_24 (VDD_39 VDD_49) resistor r=10.2363
    rVDD_23 (MM7_ELT_s VDD_43) resistor r=12.3172
    rVDD_22 (MM7_ELT_s VDD_43) resistor r=1.62887
    rVDD_21 (MM7_ELT_s VDD_46) resistor r=2.55965
    rVDD_20 (MM7_ELT_s VDD_47) resistor r=25.7298
    rVDD_19 (VDD_42 VDD_43) resistor r=12.3172
    rVDD_18 (VDD_42 VDD_49) resistor r=10.2363
    rVDD_17 (VDD_44 VDD_46) resistor r=14.4784
    rVDD_16 (VDD_44 VDD_47) resistor r=9.04062
    rVDD_15 (VDD_45 VDD_46) resistor r=14.4784
    rVDD_14 (VDD_45 VDD_51) resistor r=10.5593
    rVDD_13 (VDD_48 VDD_49) resistor r=0.549089
    rVDD_12 (VDD_50 VDD_51) resistor r=0.730683
    rVSS_78 (MM1_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_77 (MM4_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_76 (MM2_ELT_b VSS_26) resistor r=8.66667
    rVSS_75 (MM2_ELT_b VSS_29) resistor r=26
    rVSS_74 (MM2_ELT_b VSS_18) resistor r=10.7871
    rVSS_73 (VSS_2 VSS_7) resistor r=0.114595
    rVSS_72 (VSS_2 VSS_32) resistor r=0.0221469
    rVSS_71 (VSS VSS_7) resistor r=0.100764
    rVSS_70 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_69 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_68 (VSS_9 VSS_11) resistor r=0.404896
    rVSS_67 (VSS_9 VSS_32) resistor r=0.0882088
    rVSS_66 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_65 (VSS_12 MM2_ELT_s) resistor r=2.90692
    rVSS_64 (VSS_12 VSS_57) resistor r=12.1406
    rVSS_63 (VSS_14 VSS_17) resistor r=0.16794
    rVSS_62 (VSS_14 VSS_33) resistor r=0.0221469
    rVSS_61 (VSS_15 VSS_17) resistor r=0.0869339
    rVSS_60 (VSS_15 VSS_32) resistor r=0.0221469
    rVSS_59 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_58 (VSS_19 VSS_21) resistor r=0.444533
    rVSS_57 (VSS_19 VSS_33) resistor r=0.0882088
    rVSS_56 (VSS_21 VSS_22) resistor r=8.66667
    rVSS_55 (VSS_22 MM4_ELT_s) resistor r=4.22001
    rVSS_54 (VSS_22 VSS_60) resistor r=4.22001
    rVSS_53 (VSS_22 MM1_ELT_s) resistor r=4.22001
    rVSS_52 (VSS_22 VSS_58) resistor r=4.22001
    rVSS_51 (VSS_24 VSS_26) resistor r=0.0335881
    rVSS_50 (VSS_24 VSS_33) resistor r=0.0221469
    rVSS_49 (VSS_26 VSS_29) resistor r=0.158062
    rVSS_48 (VSS_34 VSS_37) resistor r=21.1301
    rVSS_47 (VSS_34 VSS_39) resistor r=9.43134
    rVSS_46 (VSS_35 VSS_37) resistor r=21.1301
    rVSS_45 (VSS_35 VSS_41) resistor r=9.4369
    rVSS_44 (MM2_ELT_s VSS_37) resistor r=4.557
    rVSS_43 (MM2_ELT_s VSS_40) resistor r=2.67027
    rVSS_42 (MM2_ELT_s VSS_42) resistor r=12.8495
    rVSS_41 (MM2_ELT_s VSS_42) resistor r=1.69926
    rVSS_40 (VSS_38 VSS_40) resistor r=15.1041
    rVSS_39 (VSS_38 VSS_57) resistor r=9.89549
    rVSS_38 (VSS_39 VSS_40) resistor r=15.1041
    rVSS_37 (VSS_41 VSS_42) resistor r=12.8495
    rVSS_36 (MM1_ELT_s VSS_44) resistor r=18.0507
    rVSS_35 (MM1_ELT_s VSS_47) resistor r=2.67027
    rVSS_34 (MM1_ELT_s VSS_49) resistor r=12.8495
    rVSS_33 (MM1_ELT_s VSS_49) resistor r=1.69926
    rVSS_32 (VSS_44 VSS_46) resistor r=9.43134
    rVSS_31 (VSS_45 VSS_47) resistor r=15.1041
    rVSS_30 (VSS_45 VSS_59) resistor r=11.0157
    rVSS_29 (VSS_46 VSS_47) resistor r=15.1041
    rVSS_28 (VSS_48 VSS_49) resistor r=12.8495
    rVSS_27 (VSS_48 VSS_61) resistor r=10.6787
    rVSS_26 (MM4_ELT_s VSS_53) resistor r=2.67027
    rVSS_25 (MM4_ELT_s VSS_55) resistor r=12.8495
    rVSS_24 (MM4_ELT_s VSS_55) resistor r=1.69926
    rVSS_23 (MM4_ELT_s VSS_56) resistor r=18.0507
    rVSS_22 (VSS_51 VSS_53) resistor r=15.1041
    rVSS_21 (VSS_51 VSS_56) resistor r=9.43134
    rVSS_20 (VSS_52 VSS_53) resistor r=15.1041
    rVSS_19 (VSS_52 VSS_59) resistor r=11.0157
    rVSS_18 (VSS_54 VSS_55) resistor r=12.8495
    rVSS_17 (VSS_54 VSS_61) resistor r=10.6787
    rVSS_16 (VSS_58 VSS_59) resistor r=0.762262
    rVSS_15 (VSS_60 VSS_61) resistor r=0.57282
    rnet27_139 (MM10_ELT_d net27) resistor r=0.01
    rnet27_138 (net27_22 net27_28) resistor r=58.3583
    rnet27_137 (net27_22 net27_28) resistor r=4.16253
    rnet27_136 (net27_22 net27_28) resistor r=58.3583
    rnet27_135 (net27_22 net27_28) resistor r=4.16253
    rnet27_134 (net27_25 net27_28) resistor r=58.3583
    rnet27_133 (net27_25 net27_28) resistor r=4.16253
    rnet27_132 (net27_25 net27_28) resistor r=58.3583
    rnet27_131 (net27_25 net27_28) resistor r=4.16253
    rnet27_130 (net27_28 net27_41) resistor r=24.8333
    rnet27_129 (net27_28 net27_38) resistor r=24.8333
    rnet27_128 (net27_28 net27_49) resistor r=24.8333
    rnet27_127 (net27_28 net27_46) resistor r=24.8333
    rnet27_126 (net27_28 net27_70) resistor r=58.3583
    rnet27_125 (net27_28 net27_73) resistor r=58.3583
    rnet27_124 (net27_28 net27_78) resistor r=14.9
    rnet27_123 (net27_28 net27_41) resistor r=4.16253
    rnet27_122 (net27_28 net27_49) resistor r=4.16253
    rnet27_121 (net27_28 net27_38) resistor r=4.16253
    rnet27_120 (net27_28 net27_70) resistor r=4.16253
    rnet27_119 (net27_28 net27_78) resistor r=6.30933
    rnet27_118 (net27_28 net27_73) resistor r=6.30933
    rnet27_117 (net27_28 net27_46) resistor r=1.63969
    rnet27_116 (net27_28 net27_41) resistor r=24.8333
    rnet27_115 (net27_28 net27_38) resistor r=24.8333
    rnet27_114 (net27_28 net27_49) resistor r=24.8333
    rnet27_113 (net27_28 net27_46) resistor r=24.8333
    rnet27_112 (net27_28 net27_70) resistor r=58.3583
    rnet27_111 (net27_28 MM4_ELT_g) resistor r=22.35
    rnet27_110 (net27_28 net27_78) resistor r=14.9
    rnet27_109 (net27_28 net27_215) resistor r=40.975
    rnet27_108 (net27_28 net27_41) resistor r=4.16253
    rnet27_107 (net27_28 net27_49) resistor r=4.16253
    rnet27_106 (net27_28 net27_38) resistor r=4.16253
    rnet27_105 (net27_28 net27_70) resistor r=4.16253
    rnet27_104 (net27_28 net27_78) resistor r=6.30933
    rnet27_103 (net27_28 net27_73) resistor r=6.30933
    rnet27_102 (net27_28 net27_46) resistor r=1.63969
    rnet27_101 (net27_30 net27_36) resistor r=202.392
    rnet27_100 (net27_30 net27_36) resistor r=4.16253
    rnet27_99 (net27_30 net27_36) resistor r=202.392
    rnet27_98 (net27_30 net27_36) resistor r=4.16253
    rnet27_97 (net27_33 net27_36) resistor r=202.392
    rnet27_96 (net27_33 net27_36) resistor r=4.16253
    rnet27_95 (net27_33 net27_36) resistor r=202.392
    rnet27_94 (net27_33 net27_36) resistor r=4.16253
    rnet27_93 (net27_36 net27_57) resistor r=24.8333
    rnet27_92 (net27_36 net27_54) resistor r=24.8333
    rnet27_91 (net27_36 net27_65) resistor r=24.8333
    rnet27_90 (net27_36 net27_62) resistor r=24.8333
    rnet27_89 (net27_36 net27_84) resistor r=14.9
    rnet27_88 (net27_36 net27_90) resistor r=202.392
    rnet27_87 (net27_36 net27_93) resistor r=202.392
    rnet27_86 (net27_36 net27_57) resistor r=4.16253
    rnet27_85 (net27_36 net27_65) resistor r=4.16253
    rnet27_84 (net27_36 net27_90) resistor r=6.30933
    rnet27_83 (net27_36 net27_84) resistor r=6.30933
    rnet27_82 (net27_36 net27_54) resistor r=1.63969
    rnet27_81 (net27_36 net27_62) resistor r=4.16253
    rnet27_80 (net27_36 net27_93) resistor r=4.16253
    rnet27_79 (net27_36 net27_57) resistor r=24.8333
    rnet27_78 (net27_36 net27_54) resistor r=24.8333
    rnet27_77 (net27_36 net27_65) resistor r=24.8333
    rnet27_76 (net27_36 net27_62) resistor r=24.8333
    rnet27_75 (net27_36 net27_217) resistor r=40.975
    rnet27_74 (net27_36 net27_84) resistor r=14.9
    rnet27_73 (net27_36 net27_90) resistor r=202.392
    rnet27_72 (net27_36 MM7_ELT_g) resistor r=7.45
    rnet27_71 (net27_36 net27_57) resistor r=4.16253
    rnet27_70 (net27_36 net27_65) resistor r=4.16253
    rnet27_69 (net27_36 net27_90) resistor r=6.30933
    rnet27_68 (net27_36 net27_84) resistor r=6.30933
    rnet27_67 (net27_36 net27_54) resistor r=1.63969
    rnet27_66 (net27_36 net27_62) resistor r=4.16253
    rnet27_65 (net27_36 net27_93) resistor r=4.16253
    rnet27_64 (net27_73 MM4_ELT_g) resistor r=36.0083
    rnet27_63 (net27_93 MM7_ELT_g) resistor r=194.942
    rnet27_62 (net27_131 net27_133) resistor r=0.399569
    rnet27_61 (net27_131 net27_167) resistor r=0.192933
    rnet27_60 (net27_133 net27_134) resistor r=13
    rnet27_59 (net27_134 MM2_ELT_d) resistor r=8.44
    rnet27_58 (net27_136 net27_138) resistor r=0.522103
    rnet27_57 (net27_136 net27_148) resistor r=0.0960616
    rnet27_56 (net27_138 net27_139) resistor r=8.66667
    rnet27_55 (net27_138 net27_141) resistor r=0.63931
    rnet27_54 (net27_139 net27) resistor r=32.3614
    rnet27_53 (net27_141 net27_142) resistor r=8.66667
    rnet27_52 (net27_141 net27_144) resistor r=0.426206
    rnet27_51 (net27_142 net27) resistor r=16.1807
    rnet27_50 (net27_142 net27_145) resistor r=32.3614
    rnet27_49 (net27_144 net27_145) resistor r=26
    rnet27_48 (net27_147 net27_148) resistor r=0.0926854
    rnet27_47 (net27_147 net27_150) resistor r=0.0960616
    rnet27_46 (net27_149 net27_150) resistor r=0.506688
    rnet27_45 (net27_149 net27_167) resistor r=0.0372887
    rnet27_44 (net27_151 net27_152) resistor r=0.565556
    rnet27_43 (net27_151 net27_153) resistor r=0.0404345
    rnet27_42 (net27_152 net27_167) resistor r=0.0469298
    rnet27_41 (net27_153 net27_155) resistor r=0.399569
    rnet27_40 (net27_153 net27_169) resistor r=0.139274
    rnet27_39 (net27_155 net27_156) resistor r=13
    rnet27_38 (net27_156 MM1_ELT_d) resistor r=8.44
    rnet27_37 (net27_158 net27_159) resistor r=0.0781642
    rnet27_36 (net27_158 net27_169) resistor r=0.000181217
    rnet27_35 (net27_159 net27_160) resistor r=0.0961114
    rnet27_34 (net27_160 net27_162) resistor r=0.0380806
    rnet27_33 (net27_162 net27_163) resistor r=10
    rnet27_32 (net27_163 net27_231) resistor r=47.4091
    rnet27_31 (net27_215 net27_232) resistor r=10.0997
    rnet27_30 (net27_217 net27_232) resistor r=10.0997
    rnet27_29 (net27_231 net27_232) resistor r=0.877078
    rnet29_48 (MM11_ELT_d net29) resistor r=0.01
    rnet29_47 (net29_1 net29_3) resistor r=0.415551
    rnet29_46 (net29_1 net29_29) resistor r=0.135333
    rnet29_45 (net29_3 net29_12) resistor r=8.66667
    rnet29_44 (net29_6 net29_8) resistor r=0.00532758
    rnet29_43 (net29_6 net29_29) resistor r=0.135333
    rnet29_42 (net29_8 net29_12) resistor r=8.66667
    rnet29_41 (net29_8 net29_11) resistor r=0.426206
    rnet29_40 (net29_11 net29_12) resistor r=13
    rnet29_39 (net29_12 MM10_ELT_s) resistor r=1.847
    rnet29_38 (net29_12 net29_40) resistor r=20.317
    rnet29_37 (net29_14 net29_15) resistor r=0.274706
    rnet29_36 (net29_14 net29_30) resistor r=0.0200605
    rnet29_35 (net29_15 net29_29) resistor r=0.0200605
    rnet29_34 (net29_16 net29_18) resistor r=0.314327
    rnet29_33 (net29_16 net29_30) resistor r=0.135333
    rnet29_32 (net29_18 net29_19) resistor r=8.66667
    rnet29_31 (net29_19 net29) resistor r=32.3614
    rnet29_30 (net29_21 net29_23) resistor r=0.106552
    rnet29_29 (net29_21 net29_30) resistor r=0.135333
    rnet29_28 (net29_23 net29_24) resistor r=8.66667
    rnet29_27 (net29_23 net29_26) resistor r=0.426206
    rnet29_26 (net29_24 net29) resistor r=16.1807
    rnet29_25 (net29_24 net29_27) resistor r=32.3614
    rnet29_24 (net29_26 net29_27) resistor r=26
    rnet29_23 (net29_31 net29_34) resistor r=31.2341
    rnet29_22 (net29_31 net29_35) resistor r=9.04595
    rnet29_21 (net29_32 net29_34) resistor r=31.2341
    rnet29_20 (net29_32 net29_38) resistor r=9.04062
    rnet29_19 (MM10_ELT_s net29_34) resistor r=6.12113
    rnet29_18 (MM10_ELT_s net29_36) resistor r=12.3172
    rnet29_17 (MM10_ELT_s net29_36) resistor r=1.62887
    rnet29_16 (MM10_ELT_s net29_39) resistor r=2.55965
    rnet29_15 (net29_35 net29_36) resistor r=12.3172
    rnet29_14 (net29_37 net29_39) resistor r=14.4784
    rnet29_13 (net29_37 net29_40) resistor r=9.48555
    rnet29_12 (net29_38 net29_39) resistor r=14.4784
    rA2_96 (A2_22 A2_28) resistor r=58.3583
    rA2_95 (A2_22 A2_28) resistor r=4.16253
    rA2_94 (A2_22 A2_28) resistor r=58.3583
    rA2_93 (A2_22 A2_28) resistor r=4.16253
    rA2_92 (A2_25 A2_28) resistor r=58.3583
    rA2_91 (A2_25 A2_28) resistor r=6.30933
    rA2_90 (A2_25 A2_28) resistor r=58.3583
    rA2_89 (A2_25 A2_28) resistor r=6.30933
    rA2_88 (A2_28 A2_30) resistor r=14.9
    rA2_87 (A2_28 A2_53) resistor r=24.8333
    rA2_86 (A2_28 A2_50) resistor r=24.8333
    rA2_85 (A2_28 A2_61) resistor r=24.8333
    rA2_84 (A2_28 A2_58) resistor r=24.8333
    rA2_83 (A2_28 A2_82) resistor r=58.3583
    rA2_82 (A2_28 A2_85) resistor r=58.3583
    rA2_81 (A2_28 A2_53) resistor r=4.16253
    rA2_80 (A2_28 A2_30) resistor r=6.30933
    rA2_79 (A2_28 A2_61) resistor r=1.63969
    rA2_78 (A2_28 A2_50) resistor r=4.16253
    rA2_77 (A2_28 A2_82) resistor r=4.16253
    rA2_76 (A2_28 A2_58) resistor r=4.16253
    rA2_75 (A2_28 A2_85) resistor r=4.16253
    rA2_74 (A2_28 A2_30) resistor r=14.9
    rA2_73 (A2_28 A2_162) resistor r=40.975
    rA2_72 (A2_28 A2_53) resistor r=24.8333
    rA2_71 (A2_28 A2_50) resistor r=24.8333
    rA2_70 (A2_28 A2_61) resistor r=24.8333
    rA2_69 (A2_28 A2_58) resistor r=24.8333
    rA2_68 (A2_28 A2_82) resistor r=58.3583
    rA2_67 (A2_28 MM1_ELT_g) resistor r=7.45
    rA2_66 (A2_28 A2_53) resistor r=4.16253
    rA2_65 (A2_28 A2_30) resistor r=6.30933
    rA2_64 (A2_28 A2_61) resistor r=1.63969
    rA2_63 (A2_28 A2_50) resistor r=4.16253
    rA2_62 (A2_28 A2_82) resistor r=4.16253
    rA2_61 (A2_28 A2_58) resistor r=4.16253
    rA2_60 (A2_28 A2_85) resistor r=4.16253
    rA2_59 (A2_36 A2_39) resistor r=14.9
    rA2_58 (A2_36 A2_39) resistor r=6.30933
    rA2_57 (A2_36 A2_39) resistor r=14.9
    rA2_56 (A2_36 A2_39) resistor r=6.30933
    rA2_55 (A2_39 A2_42) resistor r=202.392
    rA2_54 (A2_39 A2_45) resistor r=202.392
    rA2_53 (A2_39 A2_69) resistor r=24.8333
    rA2_52 (A2_39 A2_66) resistor r=24.8333
    rA2_51 (A2_39 A2_77) resistor r=24.8333
    rA2_50 (A2_39 A2_74) resistor r=24.8333
    rA2_49 (A2_39 A2_90) resistor r=202.392
    rA2_48 (A2_39 A2_93) resistor r=202.392
    rA2_47 (A2_39 A2_42) resistor r=6.30933
    rA2_46 (A2_39 A2_69) resistor r=1.63969
    rA2_45 (A2_39 A2_77) resistor r=4.16253
    rA2_44 (A2_39 A2_45) resistor r=4.16253
    rA2_43 (A2_39 A2_66) resistor r=4.16253
    rA2_42 (A2_39 A2_90) resistor r=4.16253
    rA2_41 (A2_39 A2_74) resistor r=4.16253
    rA2_40 (A2_39 A2_93) resistor r=4.16253
    rA2_39 (A2_39 A2_164) resistor r=40.975
    rA2_38 (A2_39 A2_42) resistor r=202.392
    rA2_37 (A2_39 A2_45) resistor r=202.392
    rA2_36 (A2_39 A2_69) resistor r=24.8333
    rA2_35 (A2_39 A2_66) resistor r=24.8333
    rA2_34 (A2_39 A2_77) resistor r=24.8333
    rA2_33 (A2_39 A2_74) resistor r=24.8333
    rA2_32 (A2_39 A2_90) resistor r=202.392
    rA2_31 (A2_39 MM11_ELT_g) resistor r=7.45
    rA2_30 (A2_39 A2_42) resistor r=6.30933
    rA2_29 (A2_39 A2_69) resistor r=1.63969
    rA2_28 (A2_39 A2_77) resistor r=4.16253
    rA2_27 (A2_39 A2_45) resistor r=4.16253
    rA2_26 (A2_39 A2_66) resistor r=4.16253
    rA2_25 (A2_39 A2_90) resistor r=4.16253
    rA2_24 (A2_39 A2_74) resistor r=4.16253
    rA2_23 (A2_39 A2_93) resistor r=4.16253
    rA2_22 (A2_85 MM1_ELT_g) resistor r=50.9083
    rA2_21 (A2_93 MM11_ELT_g) resistor r=194.942
    rA2_20 (A2_132 A2_133) resistor r=10
    rA2_19 (A2_132 A2) resistor r=0.0868813
    rA2_18 (A2_133 A2_194) resistor r=19.6409
    rA2_17 (A2_162 A2_195) resistor r=10.0997
    rA2_16 (A2_164 A2_195) resistor r=10.0997
    rA2_15 (A2_194 A2_195) resistor r=0.877078
    rA1_94 (A1_22 A1_28) resistor r=58.3583
    rA1_93 (A1_22 A1_28) resistor r=4.16253
    rA1_92 (A1_22 A1_28) resistor r=58.3583
    rA1_91 (A1_22 A1_28) resistor r=4.16253
    rA1_90 (A1_25 A1_28) resistor r=58.3583
    rA1_89 (A1_25 A1_28) resistor r=4.16253
    rA1_88 (A1_25 A1_28) resistor r=58.3583
    rA1_87 (A1_25 A1_28) resistor r=4.16253
    rA1_86 (A1_28 A1_41) resistor r=24.8333
    rA1_85 (A1_28 A1_38) resistor r=24.8333
    rA1_84 (A1_28 A1_49) resistor r=24.8333
    rA1_83 (A1_28 A1_46) resistor r=24.8333
    rA1_82 (A1_28 A1_70) resistor r=58.3583
    rA1_81 (A1_28 A1_73) resistor r=58.3583
    rA1_80 (A1_28 A1_78) resistor r=14.9
    rA1_79 (A1_28 A1_41) resistor r=4.16253
    rA1_78 (A1_28 A1_49) resistor r=4.16253
    rA1_77 (A1_28 A1_38) resistor r=4.16253
    rA1_76 (A1_28 A1_70) resistor r=4.16253
    rA1_75 (A1_28 A1_78) resistor r=6.30933
    rA1_74 (A1_28 A1_73) resistor r=6.30933
    rA1_73 (A1_28 A1_46) resistor r=1.63969
    rA1_72 (A1_28 A1_41) resistor r=24.8333
    rA1_71 (A1_28 A1_38) resistor r=24.8333
    rA1_70 (A1_28 A1_49) resistor r=24.8333
    rA1_69 (A1_28 A1_46) resistor r=24.8333
    rA1_68 (A1_28 A1_70) resistor r=58.3583
    rA1_67 (A1_28 MM2_ELT_g) resistor r=22.35
    rA1_66 (A1_28 A1_78) resistor r=14.9
    rA1_65 (A1_28 A1_182) resistor r=40.975
    rA1_64 (A1_28 A1_41) resistor r=4.16253
    rA1_63 (A1_28 A1_49) resistor r=4.16253
    rA1_62 (A1_28 A1_38) resistor r=4.16253
    rA1_61 (A1_28 A1_70) resistor r=4.16253
    rA1_60 (A1_28 A1_78) resistor r=6.30933
    rA1_59 (A1_28 A1_73) resistor r=6.30933
    rA1_58 (A1_28 A1_46) resistor r=1.63969
    rA1_57 (A1_30 A1_36) resistor r=202.392
    rA1_56 (A1_30 A1_36) resistor r=4.16253
    rA1_55 (A1_30 A1_36) resistor r=202.392
    rA1_54 (A1_30 A1_36) resistor r=4.16253
    rA1_53 (A1_33 A1_36) resistor r=202.392
    rA1_52 (A1_33 A1_36) resistor r=4.16253
    rA1_51 (A1_33 A1_36) resistor r=202.392
    rA1_50 (A1_33 A1_36) resistor r=4.16253
    rA1_49 (A1_36 A1_57) resistor r=24.8333
    rA1_48 (A1_36 A1_54) resistor r=24.8333
    rA1_47 (A1_36 A1_65) resistor r=24.8333
    rA1_46 (A1_36 A1_62) resistor r=24.8333
    rA1_45 (A1_36 A1_84) resistor r=14.9
    rA1_44 (A1_36 A1_90) resistor r=202.392
    rA1_43 (A1_36 A1_93) resistor r=202.392
    rA1_42 (A1_36 A1_57) resistor r=4.16253
    rA1_41 (A1_36 A1_65) resistor r=4.16253
    rA1_40 (A1_36 A1_90) resistor r=6.30933
    rA1_39 (A1_36 A1_84) resistor r=6.30933
    rA1_38 (A1_36 A1_54) resistor r=1.63969
    rA1_37 (A1_36 A1_62) resistor r=4.16253
    rA1_36 (A1_36 A1_93) resistor r=4.16253
    rA1_35 (A1_36 A1_57) resistor r=24.8333
    rA1_34 (A1_36 A1_54) resistor r=24.8333
    rA1_33 (A1_36 A1_65) resistor r=24.8333
    rA1_32 (A1_36 A1_62) resistor r=24.8333
    rA1_31 (A1_36 A1_184) resistor r=40.975
    rA1_30 (A1_36 A1_84) resistor r=14.9
    rA1_29 (A1_36 A1_90) resistor r=202.392
    rA1_28 (A1_36 MM10_ELT_g) resistor r=7.45
    rA1_27 (A1_36 A1_57) resistor r=4.16253
    rA1_26 (A1_36 A1_65) resistor r=4.16253
    rA1_25 (A1_36 A1_90) resistor r=6.30933
    rA1_24 (A1_36 A1_84) resistor r=6.30933
    rA1_23 (A1_36 A1_54) resistor r=1.63969
    rA1_22 (A1_36 A1_62) resistor r=4.16253
    rA1_21 (A1_36 A1_93) resistor r=4.16253
    rA1_20 (A1_73 MM2_ELT_g) resistor r=36.0083
    rA1_19 (A1_93 MM10_ELT_g) resistor r=194.942
    rA1_18 (A1_132 A1_133) resistor r=10
    rA1_17 (A1_132 A1) resistor r=0.0846235
    rA1_16 (A1_133 A1_198) resistor r=41.3136
    rA1_15 (A1_182 A1_199) resistor r=10.0997
    rA1_14 (A1_184 A1_199) resistor r=10.0997
    rA1_13 (A1_198 A1_199) resistor r=0.877078
ends OR2D1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DFCNQD2_LVT_ELT
// View name: calibre
subckt DFCNQD2_LVT_ELT D CP CDN Q VDD VSS
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.3885e-13 pd=1.34e-06 \
        ps=3.51e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM133_ELT (MM133_ELT_d MM133_ELT_g MM133_ELT_s MM133_ELT_b) nch_lvt \
        l=6e-08 w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.3885e-13 pd=1.34e-06 \
        ps=3.51e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.3885e-13 pd=1.34e-06 \
        ps=3.51e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2 (MM2_d MM2_g MM2_s MM2_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 ps=4.76e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM1 (MM1_d MM1_g MM1_s MM1_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 ps=3.835e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM4 (MM4_d MM4_g MM4_s MM4_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM0 (MM0_d MM0_g MM0_s MM0_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 ps=3.835e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM6 (MM6_d MM6_g MM6_s MM6_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 ps=3.815e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM3 (MM3_d MM3_g MM3_s MM3_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM5 (MM5_d MM5_g MM5_s MM5_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 ps=3.835e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 \
        ps=4.76e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM16_ELT (MM16_ELT_d MM16_ELT_g MM16_ELT_s MM16_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM29_ELT (MM29_ELT_d MM29_ELT_g MM29_ELT_s MM29_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.2165e-13 pd=3.66e-06 \
        ps=6.89333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM144_ELT (MM144_ELT_d MM144_ELT_g MM144_ELT_s MM144_ELT_b) pch_lvt \
        l=6e-08 w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.2165e-13 pd=3.66e-06 \
        ps=6.89333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.2165e-13 pd=3.66e-06 \
        ps=6.89333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9 (MM9_d MM9_g MM9_s MM9_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=3.48575e-13 pd=1.34e-06 ps=4.975e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM11 (MM11_d MM11_g MM11_s MM11_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=3.48575e-13 pd=1.34e-06 ps=4.975e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM12 (MM12_d MM12_g MM12_s MM12_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM8 (MM8_d MM8_g MM8_s MM8_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 ps=3.815e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM10 (MM10_d MM10_g MM10_s MM10_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 ps=4.8e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM7 (MM7_d MM7_g MM7_s MM7_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=3.03125e-13 as=9.4e-14 pd=4.8e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.96387e-13 pd=1.34e-06 \
        ps=5.4e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.96387e-13 pd=1.34e-06 \
        ps=5.4e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=3.03125e-13 as=9.4e-14 pd=4.8e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM28_ELT (MM28_ELT_d MM28_ELT_g MM28_ELT_s MM28_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet299_6 (net299_4 VSS) capacitor c=5.40265e-18
    cinet299_5 (net299_5 VSS) capacitor c=2.82065e-18
    cinet299_4 (MM4_d VSS) capacitor c=7.73015e-18
    cinet299_3 (net299_12 VSS) capacitor c=3.21266e-18
    cinet299_2 (net299_14 VSS) capacitor c=3.85384e-18
    cinet299_1 (net299_16 VSS) capacitor c=4.71508e-18
    cinet299_0 (net299 VSS) capacitor c=1.01211e-17
    cinet177_6 (MM5_s VSS) capacitor c=3.0651e-18
    cinet177_5 (net177_7 VSS) capacitor c=4.33126e-18
    cinet177_4 (net177_11 VSS) capacitor c=7.3818e-18
    cinet177_3 (net177_15 VSS) capacitor c=6.82868e-19
    cinet177_2 (net177_16 VSS) capacitor c=6.04513e-18
    cinet177_1 (net177_19 VSS) capacitor c=8.01451e-18
    cinet177_0 (net177 VSS) capacitor c=2.74499e-18
    cinet29_6 (net29_4 VSS) capacitor c=5.47935e-18
    cinet29_5 (net29_5 VSS) capacitor c=2.81534e-18
    cinet29_4 (MM12_ELT_d VSS) capacitor c=5.49052e-18
    cinet29_3 (net29_12 VSS) capacitor c=1.20107e-18
    cinet29_2 (net29_14 VSS) capacitor c=5.70188e-18
    cinet29_1 (net29_16 VSS) capacitor c=4.71508e-18
    cinet29_0 (net29 VSS) capacitor c=9.46668e-18
    cinet17_9 (MM16_ELT_s VSS) capacitor c=9.50486e-18
    cinet17_8 (net17_4 VSS) capacitor c=1.41789e-18
    cinet17_7 (net17_5 VSS) capacitor c=3.54406e-18
    cinet17_6 (net17_7 VSS) capacitor c=3.89656e-18
    cinet17_5 (net17_11 VSS) capacitor c=2.02832e-17
    cinet17_4 (net17_15 VSS) capacitor c=3.69062e-18
    cinet17_3 (net17_16 VSS) capacitor c=7.11498e-18
    cinet17_2 (net17_19 VSS) capacitor c=8.48874e-18
    cinet17_1 (net17_20 VSS) capacitor c=5.08484e-18
    cinet17_0 (net17 VSS) capacitor c=2.85078e-18
    cinet722_7 (net722_4 VSS) capacitor c=5.08287e-18
    cinet722_6 (net722_6 VSS) capacitor c=6.21964e-18
    cinet722_5 (net722_9 VSS) capacitor c=1.71175e-18
    cinet722_4 (MM12_d VSS) capacitor c=1.08186e-17
    cinet722_3 (net722_13 VSS) capacitor c=4.91492e-18
    cinet722_2 (net722_15 VSS) capacitor c=7.62742e-18
    cinet722_1 (net722_18 VSS) capacitor c=1.18424e-17
    cinet722_0 (net722_20 VSS) capacitor c=1.15496e-17
    cinet72_8 (net72_4 VSS) capacitor c=6.34479e-18
    cinet72_7 (net72_5 VSS) capacitor c=9.45182e-19
    cinet72_6 (net72_6 VSS) capacitor c=6.89942e-18
    cinet72_5 (net72_9 VSS) capacitor c=1.71175e-18
    cinet72_4 (MM9_ELT_d VSS) capacitor c=1.07796e-17
    cinet72_3 (net72_13 VSS) capacitor c=6.96016e-18
    cinet72_2 (net72_15 VSS) capacitor c=1.01076e-17
    cinet72_1 (net72_18 VSS) capacitor c=1.18424e-17
    cinet72_0 (net72_20 VSS) capacitor c=9.4365e-18
    ciQ_14 (Q_3 VSS) capacitor c=7.03686e-17
    ciQ_13 (Q_4 VSS) capacitor c=1.17262e-16
    ciQ_12 (Q_8 VSS) capacitor c=2.20575e-16
    ciQ_11 (Q_9 VSS) capacitor c=3.5231e-16
    ciQ_10 (Q_17 VSS) capacitor c=7.19943e-17
    ciQ_9 (Q_18 VSS) capacitor c=1.39929e-17
    ciQ_8 (Q_19 VSS) capacitor c=6.42359e-17
    ciQ_7 (Q_20 VSS) capacitor c=1.70148e-17
    ciQ_6 (Q_23 VSS) capacitor c=5.59271e-17
    ciQ_5 (Q_24 VSS) capacitor c=1.11559e-16
    ciQ_4 (Q_28 VSS) capacitor c=1.75472e-16
    ciQ_3 (Q_29 VSS) capacitor c=3.28883e-16
    ciQ_2 (Q VSS) capacitor c=3.95117e-17
    ciQ_1 (Q_42 VSS) capacitor c=2.16457e-17
    ciQ_0 (Q_45 VSS) capacitor c=2.83619e-17
    ciVDD_83 (VDD_2 VSS) capacitor c=6.33974e-17
    ciVDD_82 (VDD_11 VSS) capacitor c=2.40291e-16
    ciVDD_81 (VDD_19 VSS) capacitor c=3.76352e-16
    ciVDD_80 (VDD_20 VSS) capacitor c=4.73329e-17
    ciVDD_79 (VDD_27 VSS) capacitor c=7.20396e-17
    ciVDD_78 (VDD_28 VSS) capacitor c=8.72357e-17
    ciVDD_77 (VDD_30 VSS) capacitor c=1.08745e-16
    ciVDD_76 (VDD_43 VSS) capacitor c=5.80549e-17
    ciVDD_75 (VDD_44 VSS) capacitor c=1.18497e-16
    ciVDD_74 (VDD_46 VSS) capacitor c=6.34219e-17
    ciVDD_73 (VDD_53 VSS) capacitor c=9.37062e-17
    ciVDD_72 (VDD_54 VSS) capacitor c=1.4846e-16
    ciVDD_71 (VDD_56 VSS) capacitor c=4.71209e-17
    ciVDD_70 (VDD_63 VSS) capacitor c=6.64078e-17
    ciVDD_69 (VDD_64 VSS) capacitor c=8.56235e-17
    ciVDD_68 (VDD_66 VSS) capacitor c=1.08164e-16
    ciVDD_67 (VDD_76 VSS) capacitor c=5.80651e-17
    ciVDD_66 (VDD_77 VSS) capacitor c=1.18497e-16
    ciVDD_65 (VDD_79 VSS) capacitor c=6.27605e-17
    ciVDD_64 (VDD_86 VSS) capacitor c=8.45697e-17
    ciVDD_63 (VDD_87 VSS) capacitor c=1.43217e-16
    ciVDD_62 (VDD_89 VSS) capacitor c=8.69567e-17
    ciVDD_61 (VDD_96 VSS) capacitor c=2.2559e-16
    ciVDD_60 (VDD_104 VSS) capacitor c=3.74274e-16
    ciVDD_59 (VDD_105 VSS) capacitor c=2.99254e-17
    ciVDD_58 (VDD_109 VSS) capacitor c=2.3212e-16
    ciVDD_57 (VDD_117 VSS) capacitor c=3.79725e-16
    ciVDD_56 (VDD_123 VSS) capacitor c=7.42912e-17
    ciVDD_55 (VDD_126 VSS) capacitor c=3.58509e-18
    ciVDD_54 (VDD_127 VSS) capacitor c=3.58509e-18
    ciVDD_53 (VDD_128 VSS) capacitor c=3.58509e-18
    ciVDD_52 (VDD_129 VSS) capacitor c=3.58509e-18
    ciVDD_51 (VDD_131 VSS) capacitor c=3.58509e-18
    ciVDD_50 (VDD_133 VSS) capacitor c=3.58509e-18
    ciVDD_49 (VDD_135 VSS) capacitor c=3.58509e-18
    ciVDD_48 (VDD_138 VSS) capacitor c=3.58509e-18
    ciVDD_47 (VDD_140 VSS) capacitor c=3.58509e-18
    ciVDD_46 (MM28_ELT_s VSS) capacitor c=1.32762e-17
    ciVDD_45 (VDD_147 VSS) capacitor c=1.11099e-18
    ciVDD_44 (VDD_149 VSS) capacitor c=1.07074e-18
    ciVDD_43 (VDD_153 VSS) capacitor c=1.11099e-18
    ciVDD_42 (VDD_154 VSS) capacitor c=1.23625e-18
    ciVDD_41 (VDD_155 VSS) capacitor c=1.07074e-18
    ciVDD_40 (VDD_158 VSS) capacitor c=3.49723e-17
    ciVDD_39 (MM14_ELT_s VSS) capacitor c=7.23193e-18
    ciVDD_38 (VDD_160 VSS) capacitor c=1.26426e-18
    ciVDD_37 (VDD_161 VSS) capacitor c=8.11848e-18
    ciVDD_36 (VDD_164 VSS) capacitor c=1.71175e-18
    ciVDD_35 (VDD_169 VSS) capacitor c=5.14689e-18
    ciVDD_34 (VDD_170 VSS) capacitor c=5.91271e-18
    ciVDD_33 (VDD_171 VSS) capacitor c=4.67919e-18
    ciVDD_32 (VDD_174 VSS) capacitor c=1.71175e-18
    ciVDD_31 (VDD_175 VSS) capacitor c=4.37347e-17
    ciVDD_30 (MM6_ELT_s VSS) capacitor c=1.04202e-17
    ciVDD_29 (VDD_180 VSS) capacitor c=1.71175e-18
    ciVDD_28 (VDD_181 VSS) capacitor c=1.64542e-17
    ciVDD_27 (VDD_182 VSS) capacitor c=7.38856e-18
    ciVDD_26 (VDD_187 VSS) capacitor c=5.21599e-18
    ciVDD_25 (MM10_s VSS) capacitor c=5.08287e-18
    ciVDD_24 (VDD_190 VSS) capacitor c=7.29904e-18
    ciVDD_23 (VDD_193 VSS) capacitor c=1.71175e-18
    ciVDD_22 (VDD_198 VSS) capacitor c=3.97088e-18
    ciVDD_21 (VDD_199 VSS) capacitor c=7.12773e-18
    ciVDD_20 (VDD_200 VSS) capacitor c=4.39784e-18
    ciVDD_19 (VDD_203 VSS) capacitor c=1.71175e-18
    ciVDD_18 (VDD_204 VSS) capacitor c=4.58961e-17
    ciVDD_17 (MM9_s VSS) capacitor c=4.16593e-18
    ciVDD_16 (VDD_209 VSS) capacitor c=1.71175e-18
    ciVDD_15 (VDD_211 VSS) capacitor c=7.02261e-18
    ciVDD_14 (MM4_ELT_s VSS) capacitor c=3.83186e-17
    ciVDD_13 (VDD_216 VSS) capacitor c=3.97088e-18
    ciVDD_12 (VDD_219 VSS) capacitor c=8.70264e-18
    ciVDD_11 (VDD_222 VSS) capacitor c=1.11099e-18
    ciVDD_10 (VDD_224 VSS) capacitor c=6.22982e-18
    ciVDD_9 (VDD_228 VSS) capacitor c=1.11099e-18
    ciVDD_8 (VDD_230 VSS) capacitor c=4.2035e-18
    ciVDD_7 (VDD_234 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_235 VSS) capacitor c=5.71245e-18
    ciVDD_5 (VDD_236 VSS) capacitor c=4.50558e-18
    ciVDD_4 (VDD_239 VSS) capacitor c=1.57204e-17
    ciVDD_3 (VDD_241 VSS) capacitor c=1.70056e-18
    ciVDD_2 (VDD_266 VSS) capacitor c=9.3318e-18
    ciVDD_1 (VDD_268 VSS) capacitor c=1.2097e-18
    ciVDD_0 (VDD_272 VSS) capacitor c=2.86265e-18
    ciVSS_56 (VSS_2 VSS) capacitor c=6.13488e-17
    ciVSS_55 (VSS_11 VSS) capacitor c=8.86768e-17
    ciVSS_54 (VSS_12 VSS) capacitor c=1.23613e-16
    ciVSS_53 (VSS_14 VSS) capacitor c=2.45787e-16
    ciVSS_52 (VSS_30 VSS) capacitor c=7.22344e-17
    ciVSS_51 (VSS_31 VSS) capacitor c=1.17766e-16
    ciVSS_50 (VSS_33 VSS) capacitor c=4.69308e-17
    ciVSS_49 (VSS_40 VSS) capacitor c=8.80379e-17
    ciVSS_48 (VSS_46 VSS) capacitor c=1.89794e-16
    ciVSS_47 (VSS_62 VSS) capacitor c=7.19562e-17
    ciVSS_46 (VSS_63 VSS) capacitor c=1.13402e-16
    ciVSS_45 (VSS_65 VSS) capacitor c=4.69783e-17
    ciVSS_44 (VSS_72 VSS) capacitor c=7.53854e-17
    ciVSS_43 (VSS_78 VSS) capacitor c=8.40989e-17
    ciVSS_42 (VSS_85 VSS) capacitor c=6.79049e-17
    ciVSS_41 (VSS_86 VSS) capacitor c=1.1594e-16
    ciVSS_40 (VSS_88 VSS) capacitor c=2.87127e-17
    ciVSS_39 (VSS_92 VSS) capacitor c=7.33897e-17
    ciVSS_38 (VSS_93 VSS) capacitor c=1.16919e-16
    ciVSS_37 (VSS_100 VSS) capacitor c=7.22084e-17
    ciVSS_36 (VSS_103 VSS) capacitor c=3.58509e-18
    ciVSS_35 (VSS_104 VSS) capacitor c=3.58509e-18
    ciVSS_34 (VSS_105 VSS) capacitor c=3.58509e-18
    ciVSS_33 (VSS_106 VSS) capacitor c=3.58509e-18
    ciVSS_32 (VSS_108 VSS) capacitor c=3.58509e-18
    ciVSS_31 (VSS_111 VSS) capacitor c=3.58509e-18
    ciVSS_30 (VSS_113 VSS) capacitor c=3.58509e-18
    ciVSS_29 (VSS_120 VSS) capacitor c=2.47056e-18
    ciVSS_28 (VSS_122 VSS) capacitor c=1.41789e-18
    ciVSS_27 (VSS_124 VSS) capacitor c=3.46252e-18
    ciVSS_26 (VSS_125 VSS) capacitor c=1.56128e-18
    ciVSS_25 (VSS_126 VSS) capacitor c=2.86014e-18
    ciVSS_24 (VSS_129 VSS) capacitor c=8.05039e-18
    ciVSS_23 (VSS_133 VSS) capacitor c=8.25279e-18
    ciVSS_22 (VSS_143 VSS) capacitor c=9.95238e-19
    ciVSS_21 (VSS_144 VSS) capacitor c=6.76881e-18
    ciVSS_20 (VSS_147 VSS) capacitor c=1.21888e-18
    ciVSS_19 (VSS_152 VSS) capacitor c=2.68008e-18
    ciVSS_18 (VSS_153 VSS) capacitor c=3.50743e-18
    ciVSS_17 (VSS_156 VSS) capacitor c=5.34552e-18
    ciVSS_16 (VSS_160 VSS) capacitor c=8.07451e-18
    ciVSS_15 (VSS_164 VSS) capacitor c=5.78529e-19
    ciVSS_14 (VSS_165 VSS) capacitor c=1.17882e-18
    ciVSS_13 (VSS_171 VSS) capacitor c=5.0514e-18
    ciVSS_12 (VSS_179 VSS) capacitor c=2.86916e-18
    ciVSS_11 (VSS_180 VSS) capacitor c=2.34935e-18
    ciVSS_10 (VSS_183 VSS) capacitor c=4.55049e-18
    ciVSS_9 (MM5_ELT_s VSS) capacitor c=1.112e-18
    ciVSS_8 (VSS_190 VSS) capacitor c=6.39143e-18
    ciVSS_7 (VSS_196 VSS) capacitor c=3.68047e-18
    ciVSS_6 (VSS_201 VSS) capacitor c=6.87668e-18
    ciVSS_5 (VSS_202 VSS) capacitor c=5.01966e-18
    ciVSS_4 (VSS_209 VSS) capacitor c=4.06582e-18
    ciVSS_3 (VSS_212 VSS) capacitor c=8.11737e-17
    ciVSS_2 (VSS_215 VSS) capacitor c=7.83279e-17
    ciVSS_1 (VSS_219 VSS) capacitor c=2.76296e-18
    ciVSS_0 (VSS_223 VSS) capacitor c=7.13294e-18
    cinet11_36 (net11_42 VSS) capacitor c=3.00043e-18
    cinet11_35 (net11_48 VSS) capacitor c=2.42308e-16
    cinet11_34 (net11_59 VSS) capacitor c=7.47661e-16
    cinet11_33 (net11_65 VSS) capacitor c=3.85496e-18
    cinet11_32 (net11_70 VSS) capacitor c=2.2416e-17
    cinet11_31 (net11_78 VSS) capacitor c=1.51948e-17
    cinet11_30 (net11_86 VSS) capacitor c=1.8249e-17
    cinet11_29 (net11_94 VSS) capacitor c=1.26948e-17
    cinet11_28 (net11_102 VSS) capacitor c=3.00043e-18
    cinet11_27 (net11_105 VSS) capacitor c=6.26439e-19
    cinet11_26 (net11_110 VSS) capacitor c=4.23923e-18
    cinet11_25 (net11_113 VSS) capacitor c=2.31953e-18
    cinet11_24 (net11_118 VSS) capacitor c=4.25215e-18
    cinet11_23 (net11_124 VSS) capacitor c=1.783e-16
    cinet11_22 (net11_135 VSS) capacitor c=5.51361e-16
    cinet11_21 (net11_141 VSS) capacitor c=3.60057e-18
    cinet11_20 (net11_146 VSS) capacitor c=2.23758e-17
    cinet11_19 (net11_154 VSS) capacitor c=1.51948e-17
    cinet11_18 (net11_162 VSS) capacitor c=2.06899e-17
    cinet11_17 (net11_170 VSS) capacitor c=1.62958e-17
    cinet11_16 (net11_178 VSS) capacitor c=2.1509e-18
    cinet11_15 (net11_181 VSS) capacitor c=1.75435e-18
    cinet11_14 (net11_186 VSS) capacitor c=7.5024e-18
    cinet11_13 (net11_189 VSS) capacitor c=2.22299e-18
    cinet11_12 (net11_263 VSS) capacitor c=5.68711e-17
    cinet11_11 (net11_264 VSS) capacitor c=1.12693e-16
    cinet11_10 (net11_268 VSS) capacitor c=1.57237e-16
    cinet11_9 (net11_269 VSS) capacitor c=3.2327e-16
    cinet11_8 (net11_278 VSS) capacitor c=4.25525e-18
    cinet11_7 (net11_280 VSS) capacitor c=1.00185e-17
    cinet11_6 (net11_286 VSS) capacitor c=1.27538e-16
    cinet11_5 (net11_287 VSS) capacitor c=1.6106e-17
    cinet11_4 (net11_291 VSS) capacitor c=2.50856e-17
    cinet11_3 (net11_295 VSS) capacitor c=3.33563e-17
    cinet11_2 (net11_297 VSS) capacitor c=1.50336e-17
    cinet11_1 (net11_411 VSS) capacitor c=2.52621e-17
    cinet11_0 (net11_426 VSS) capacitor c=3.27889e-17
    cinet6_39 (net6_42 VSS) capacitor c=6.89598e-18
    cinet6_38 (net6_45 VSS) capacitor c=4.27597e-18
    cinet6_37 (net6_48 VSS) capacitor c=1.70465e-16
    cinet6_36 (net6_50 VSS) capacitor c=2.08995e-17
    cinet6_35 (net6_58 VSS) capacitor c=2.30316e-17
    cinet6_34 (net6_66 VSS) capacitor c=6.31515e-18
    cinet6_33 (net6_69 VSS) capacitor c=4.47573e-18
    cinet6_32 (net6_72 VSS) capacitor c=1.68021e-16
    cinet6_31 (net6_80 VSS) capacitor c=3.17977e-17
    cinet6_30 (net6_88 VSS) capacitor c=1.77129e-17
    cinet6_29 (net6_99 VSS) capacitor c=2.80371e-18
    cinet6_28 (net6_110 VSS) capacitor c=9.55967e-18
    cinet6_27 (net6_118 VSS) capacitor c=4.15066e-18
    cinet6_26 (net6_124 VSS) capacitor c=1.92535e-16
    cinet6_25 (net6_135 VSS) capacitor c=5.84447e-16
    cinet6_24 (net6_141 VSS) capacitor c=4.15066e-18
    cinet6_23 (net6_146 VSS) capacitor c=2.23788e-17
    cinet6_22 (net6_154 VSS) capacitor c=1.51948e-17
    cinet6_21 (net6_162 VSS) capacitor c=2.08252e-17
    cinet6_20 (net6_170 VSS) capacitor c=1.7111e-17
    cinet6_19 (net6_178 VSS) capacitor c=2.9716e-18
    cinet6_18 (net6_181 VSS) capacitor c=5.3401e-18
    cinet6_17 (net6_186 VSS) capacitor c=1.02747e-17
    cinet6_16 (net6_189 VSS) capacitor c=3.85496e-18
    cinet6_15 (net6_261 VSS) capacitor c=2.12193e-16
    cinet6_14 (net6_268 VSS) capacitor c=3.95451e-17
    cinet6_13 (net6_269 VSS) capacitor c=1.12739e-16
    cinet6_12 (net6_272 VSS) capacitor c=8.36557e-17
    cinet6_11 (net6_275 VSS) capacitor c=8.3097e-17
    cinet6_10 (net6_276 VSS) capacitor c=1.2541e-16
    cinet6_9 (net6_279 VSS) capacitor c=2.20774e-17
    cinet6_8 (net6_281 VSS) capacitor c=1.6063e-17
    cinet6_7 (net6_284 VSS) capacitor c=5.04783e-17
    cinet6_6 (net6_289 VSS) capacitor c=2.769e-17
    cinet6_5 (net6_293 VSS) capacitor c=2.52202e-17
    cinet6_4 (net6_295 VSS) capacitor c=3.56692e-18
    cinet6_3 (net6_296 VSS) capacitor c=1.58965e-17
    cinet6_2 (net6_415 VSS) capacitor c=1.42269e-17
    cinet6_1 (net6_416 VSS) capacitor c=1.60993e-17
    cinet6_0 (net6_428 VSS) capacitor c=5.14318e-17
    cinet68_47 (net68_22 VSS) capacitor c=3.00043e-18
    cinet68_46 (net68_28 VSS) capacitor c=2.07154e-16
    cinet68_45 (net68_39 VSS) capacitor c=3.46522e-16
    cinet68_44 (net68_45 VSS) capacitor c=3.85496e-18
    cinet68_43 (net68_50 VSS) capacitor c=2.23559e-17
    cinet68_42 (net68_58 VSS) capacitor c=2.2416e-17
    cinet68_41 (net68_66 VSS) capacitor c=1.99182e-17
    cinet68_40 (net68_74 VSS) capacitor c=2.17811e-17
    cinet68_39 (net68_82 VSS) capacitor c=4.04637e-18
    cinet68_38 (net68_85 VSS) capacitor c=6.27322e-18
    cinet68_37 (net68_90 VSS) capacitor c=2e-18
    cinet68_36 (net68_93 VSS) capacitor c=4.15066e-18
    cinet68_35 (net68_133 VSS) capacitor c=1.10515e-16
    cinet68_34 (net68_136 VSS) capacitor c=9.43871e-17
    cinet68_33 (net68_137 VSS) capacitor c=1.22446e-17
    cinet68_32 (net68_140 VSS) capacitor c=3.83714e-17
    cinet68_31 (net68_141 VSS) capacitor c=1.07013e-16
    cinet68_30 (net68_143 VSS) capacitor c=1.03728e-16
    cinet68_29 (net68_144 VSS) capacitor c=1.59748e-17
    cinet68_28 (net68_146 VSS) capacitor c=6.06271e-17
    cinet68_27 (net68_148 VSS) capacitor c=4.70944e-17
    cinet68_26 (net68_149 VSS) capacitor c=4.10762e-17
    cinet68_25 (net68_150 VSS) capacitor c=1.36176e-17
    cinet68_24 (net68_153 VSS) capacitor c=4.07339e-17
    cinet68_23 (net68_154 VSS) capacitor c=1.1901e-16
    cinet68_22 (net68_156 VSS) capacitor c=4.53491e-17
    cinet68_21 (net68_157 VSS) capacitor c=1.26629e-17
    cinet68_20 (net68_160 VSS) capacitor c=3.37766e-17
    cinet68_19 (net68_161 VSS) capacitor c=1.0705e-16
    cinet68_18 (net68_163 VSS) capacitor c=8.14657e-18
    cinet68_17 (net68_166 VSS) capacitor c=3.28909e-17
    cinet68_16 (net68_167 VSS) capacitor c=1.66925e-16
    cinet68_15 (net68_169 VSS) capacitor c=1.21518e-16
    cinet68_14 (net68_173 VSS) capacitor c=6.02406e-17
    cinet68_13 (net68_174 VSS) capacitor c=1.52763e-16
    cinet68_12 (net68_177 VSS) capacitor c=9.33246e-17
    cinet68_11 (net68_178 VSS) capacitor c=1.23797e-17
    cinet68_10 (net68_180 VSS) capacitor c=3.79176e-17
    cinet68_9 (net68_183 VSS) capacitor c=4.588e-18
    cinet68_8 (net68_184 VSS) capacitor c=8.49282e-18
    cinet68_7 (net68_185 VSS) capacitor c=5.36196e-18
    cinet68_6 (net68_186 VSS) capacitor c=6.81209e-18
    cinet68_5 (net68_243 VSS) capacitor c=2.69055e-17
    cinet68_4 (net68_244 VSS) capacitor c=1.58055e-17
    cinet68_3 (net68_254 VSS) capacitor c=1.71175e-18
    cinet68_2 (net68_256 VSS) capacitor c=7.91446e-18
    cinet68_1 (net68_259 VSS) capacitor c=3.97088e-18
    cinet68_0 (net68_260 VSS) capacitor c=1.00069e-16
    cinet255_5 (net255_3 VSS) capacitor c=3.74881e-17
    cinet255_4 (net255_4 VSS) capacitor c=1.07856e-16
    cinet255_3 (net255_6 VSS) capacitor c=3.24883e-17
    cinet255_2 (net255_7 VSS) capacitor c=1.34414e-17
    cinet255_1 (net255_10 VSS) capacitor c=1.25697e-16
    cinet255_0 (net255_11 VSS) capacitor c=1.12958e-16
    cinet200_6 (net200_3 VSS) capacitor c=1.07535e-17
    cinet200_5 (net200_4 VSS) capacitor c=1.15779e-16
    cinet200_4 (net200_8 VSS) capacitor c=7.7694e-17
    cinet200_3 (net200_12 VSS) capacitor c=1.5995e-17
    cinet200_2 (net200_13 VSS) capacitor c=1.20847e-16
    cinet200_1 (net200_17 VSS) capacitor c=1.87131e-17
    cinet200_0 (net200_18 VSS) capacitor c=2.14523e-17
    cinet499_6 (net499_3 VSS) capacitor c=6.7402e-17
    cinet499_5 (net499_4 VSS) capacitor c=1.27446e-16
    cinet499_4 (net499_8 VSS) capacitor c=6.55866e-17
    cinet499_3 (net499_9 VSS) capacitor c=1.26315e-16
    cinet499_2 (net499_12 VSS) capacitor c=5.70424e-17
    cinet499_1 (net499_15 VSS) capacitor c=1.97737e-17
    cinet499_0 (net499_19 VSS) capacitor c=2.04686e-17
    cinet5_46 (net5_42 VSS) capacitor c=9.2116e-18
    cinet5_45 (net5_45 VSS) capacitor c=4.27597e-18
    cinet5_44 (net5_48 VSS) capacitor c=1.71472e-16
    cinet5_43 (net5_50 VSS) capacitor c=2.48575e-17
    cinet5_42 (net5_58 VSS) capacitor c=2.31602e-17
    cinet5_41 (net5_66 VSS) capacitor c=6.31515e-18
    cinet5_40 (net5_69 VSS) capacitor c=4.47573e-18
    cinet5_39 (net5_72 VSS) capacitor c=1.68138e-16
    cinet5_38 (net5_80 VSS) capacitor c=3.15386e-17
    cinet5_37 (net5_88 VSS) capacitor c=1.77129e-17
    cinet5_36 (net5_99 VSS) capacitor c=2.80371e-18
    cinet5_35 (net5_110 VSS) capacitor c=9.25558e-18
    cinet5_34 (net5_118 VSS) capacitor c=4.98683e-18
    cinet5_33 (net5_121 VSS) capacitor c=3.25905e-18
    cinet5_32 (net5_124 VSS) capacitor c=2.15606e-16
    cinet5_31 (net5_126 VSS) capacitor c=2.58986e-17
    cinet5_30 (net5_134 VSS) capacitor c=2.23851e-17
    cinet5_29 (net5_151 VSS) capacitor c=4.11003e-18
    cinet5_28 (net5_156 VSS) capacitor c=5.54274e-18
    cinet5_27 (net5_162 VSS) capacitor c=1.76745e-16
    cinet5_26 (net5_170 VSS) capacitor c=2.2354e-17
    cinet5_25 (net5_178 VSS) capacitor c=2.75078e-17
    cinet5_24 (net5_186 VSS) capacitor c=3.98759e-18
    cinet5_23 (net5_189 VSS) capacitor c=5.02878e-18
    cinet5_22 (net5_261 VSS) capacitor c=1.81345e-16
    cinet5_21 (net5_267 VSS) capacitor c=3.98568e-18
    cinet5_20 (net5_269 VSS) capacitor c=1.11979e-16
    cinet5_19 (net5_270 VSS) capacitor c=8.23351e-17
    cinet5_18 (net5_271 VSS) capacitor c=1.32181e-17
    cinet5_17 (net5_272 VSS) capacitor c=5.93336e-17
    cinet5_16 (net5_273 VSS) capacitor c=1.93647e-17
    cinet5_15 (net5_276 VSS) capacitor c=3.95451e-17
    cinet5_14 (net5_277 VSS) capacitor c=1.12739e-16
    cinet5_13 (net5_281 VSS) capacitor c=7.88183e-17
    cinet5_12 (net5_282 VSS) capacitor c=1.28057e-16
    cinet5_11 (net5_285 VSS) capacitor c=3.02522e-17
    cinet5_10 (net5_287 VSS) capacitor c=2.13958e-17
    cinet5_9 (net5_290 VSS) capacitor c=2.06854e-16
    cinet5_8 (net5_293 VSS) capacitor c=1.36977e-17
    cinet5_7 (net5_296 VSS) capacitor c=3.55621e-17
    cinet5_6 (net5_298 VSS) capacitor c=2.09267e-17
    cinet5_5 (net5_390 VSS) capacitor c=3.15579e-17
    cinet5_4 (net5_391 VSS) capacitor c=2.10517e-17
    cinet5_3 (net5_399 VSS) capacitor c=1.26373e-16
    cinet5_2 (net5_425 VSS) capacitor c=5.26645e-17
    cinet5_1 (net5_426 VSS) capacitor c=1.08841e-17
    cinet5_0 (net5_434 VSS) capacitor c=5.10534e-17
    cinet67_46 (net67_22 VSS) capacitor c=2.98735e-18
    cinet67_45 (net67_28 VSS) capacitor c=2.10869e-16
    cinet67_44 (net67_39 VSS) capacitor c=3.71209e-16
    cinet67_43 (net67_45 VSS) capacitor c=3.83244e-18
    cinet67_42 (net67_50 VSS) capacitor c=2.24052e-17
    cinet67_41 (net67_58 VSS) capacitor c=2.24576e-17
    cinet67_40 (net67_66 VSS) capacitor c=2.17791e-17
    cinet67_39 (net67_74 VSS) capacitor c=2.69022e-17
    cinet67_38 (net67_82 VSS) capacitor c=4.04637e-18
    cinet67_37 (net67_85 VSS) capacitor c=6.2992e-18
    cinet67_36 (net67_90 VSS) capacitor c=5.17301e-18
    cinet67_35 (net67_93 VSS) capacitor c=3.8335e-18
    cinet67_34 (net67_132 VSS) capacitor c=6.44021e-17
    cinet67_33 (net67_135 VSS) capacitor c=7.18517e-17
    cinet67_32 (net67_138 VSS) capacitor c=2.61153e-17
    cinet67_31 (net67_139 VSS) capacitor c=1.48677e-17
    cinet67_30 (net67_140 VSS) capacitor c=9.23707e-17
    cinet67_29 (net67_144 VSS) capacitor c=5.73995e-17
    cinet67_28 (net67_145 VSS) capacitor c=1.10806e-16
    cinet67_27 (net67_148 VSS) capacitor c=4.59252e-17
    cinet67_26 (net67_149 VSS) capacitor c=4.07276e-17
    cinet67_25 (net67_150 VSS) capacitor c=1.36318e-17
    cinet67_24 (net67_153 VSS) capacitor c=4.4451e-17
    cinet67_23 (net67_154 VSS) capacitor c=1.1901e-16
    cinet67_22 (net67_156 VSS) capacitor c=4.93684e-17
    cinet67_21 (net67_157 VSS) capacitor c=1.38956e-17
    cinet67_20 (net67_160 VSS) capacitor c=3.28656e-17
    cinet67_19 (net67_161 VSS) capacitor c=1.07086e-16
    cinet67_18 (net67_163 VSS) capacitor c=9.3755e-18
    cinet67_17 (net67_166 VSS) capacitor c=3.77486e-17
    cinet67_16 (net67_167 VSS) capacitor c=1.13228e-16
    cinet67_15 (net67_169 VSS) capacitor c=1.35064e-16
    cinet67_14 (net67_172 VSS) capacitor c=1.12808e-16
    cinet67_13 (net67_173 VSS) capacitor c=2.81499e-17
    cinet67_12 (net67_175 VSS) capacitor c=1.033e-16
    cinet67_11 (net67_180 VSS) capacitor c=6.41028e-17
    cinet67_10 (net67_181 VSS) capacitor c=1.52763e-16
    cinet67_9 (net67_183 VSS) capacitor c=7.65771e-18
    cinet67_8 (net67_184 VSS) capacitor c=8.49282e-18
    cinet67_7 (net67_185 VSS) capacitor c=5.45275e-18
    cinet67_6 (net67_186 VSS) capacitor c=1.19686e-17
    cinet67_5 (net67_243 VSS) capacitor c=3.18092e-17
    cinet67_4 (net67_244 VSS) capacitor c=1.91381e-17
    cinet67_3 (net67_254 VSS) capacitor c=1.71175e-18
    cinet67_2 (net67_256 VSS) capacitor c=8.43533e-18
    cinet67_1 (net67_259 VSS) capacitor c=3.97088e-18
    cinet67_0 (net67_260 VSS) capacitor c=9.3984e-17
    cinet25_7 (net25_3 VSS) capacitor c=4.55942e-17
    cinet25_6 (net25_4 VSS) capacitor c=1.09459e-16
    cinet25_5 (net25_6 VSS) capacitor c=2.95374e-17
    cinet25_4 (net25_7 VSS) capacitor c=1.34187e-17
    cinet25_3 (net25_9 VSS) capacitor c=7.81486e-17
    cinet25_2 (net25_12 VSS) capacitor c=5.53076e-17
    cinet25_1 (net25_13 VSS) capacitor c=1.12958e-16
    cinet25_0 (net25_17 VSS) capacitor c=2.89917e-17
    cinet20_6 (net20_3 VSS) capacitor c=1.5995e-17
    cinet20_5 (net20_4 VSS) capacitor c=1.19112e-16
    cinet20_4 (net20_8 VSS) capacitor c=7.55603e-17
    cinet20_3 (net20_12 VSS) capacitor c=1.5995e-17
    cinet20_2 (net20_13 VSS) capacitor c=1.20843e-16
    cinet20_1 (net20_17 VSS) capacitor c=2.59428e-17
    cinet20_0 (net20_18 VSS) capacitor c=2.11352e-17
    ciCDN_57 (CDN_66 VSS) capacitor c=3.98759e-18
    ciCDN_56 (CDN_69 VSS) capacitor c=2.81125e-18
    ciCDN_55 (CDN_72 VSS) capacitor c=1.95495e-16
    ciCDN_54 (CDN_74 VSS) capacitor c=2.23316e-17
    ciCDN_53 (CDN_82 VSS) capacitor c=1.57811e-17
    ciCDN_52 (CDN_90 VSS) capacitor c=3.00043e-18
    ciCDN_51 (CDN_104 VSS) capacitor c=2.96645e-18
    ciCDN_50 (CDN_110 VSS) capacitor c=1.90519e-16
    ciCDN_49 (CDN_118 VSS) capacitor c=2.23977e-17
    ciCDN_48 (CDN_126 VSS) capacitor c=2.2006e-17
    ciCDN_47 (CDN_134 VSS) capacitor c=5.75798e-18
    ciCDN_46 (CDN_137 VSS) capacitor c=4.17526e-18
    ciCDN_45 (CDN_140 VSS) capacitor c=3.68486e-16
    ciCDN_44 (CDN_142 VSS) capacitor c=3.32208e-18
    ciCDN_43 (CDN_145 VSS) capacitor c=1.74211e-18
    ciCDN_42 (CDN_150 VSS) capacitor c=1.70177e-17
    ciCDN_41 (CDN_158 VSS) capacitor c=2.24618e-17
    ciCDN_40 (CDN_172 VSS) capacitor c=1.63457e-17
    ciCDN_39 (CDN_180 VSS) capacitor c=7.94903e-18
    ciCDN_38 (CDN_183 VSS) capacitor c=3.84103e-18
    ciCDN_37 (CDN_188 VSS) capacitor c=3.98759e-18
    ciCDN_36 (CDN_191 VSS) capacitor c=2.6191e-18
    ciCDN_35 (CDN_194 VSS) capacitor c=1.92042e-16
    ciCDN_34 (CDN_196 VSS) capacitor c=2.23814e-17
    ciCDN_33 (CDN_204 VSS) capacitor c=1.57787e-17
    ciCDN_32 (CDN_212 VSS) capacitor c=3.00043e-18
    ciCDN_31 (CDN_226 VSS) capacitor c=3.00043e-18
    ciCDN_30 (CDN_232 VSS) capacitor c=1.85977e-16
    ciCDN_29 (CDN_240 VSS) capacitor c=2.2416e-17
    ciCDN_28 (CDN_248 VSS) capacitor c=2.04538e-17
    ciCDN_27 (CDN_256 VSS) capacitor c=4.18692e-18
    ciCDN_26 (CDN_259 VSS) capacitor c=4.19476e-18
    ciCDN_25 (CDN_262 VSS) capacitor c=3.65226e-16
    ciCDN_24 (CDN_264 VSS) capacitor c=3.35294e-18
    ciCDN_23 (CDN_267 VSS) capacitor c=1.12995e-18
    ciCDN_22 (CDN_272 VSS) capacitor c=1.62672e-17
    ciCDN_21 (CDN_280 VSS) capacitor c=2.2416e-17
    ciCDN_20 (CDN_294 VSS) capacitor c=1.52943e-17
    ciCDN_19 (CDN_302 VSS) capacitor c=5.52719e-18
    ciCDN_18 (CDN_305 VSS) capacitor c=3.85496e-18
    ciCDN_17 (CDN_419 VSS) capacitor c=1.31569e-17
    ciCDN_16 (CDN_425 VSS) capacitor c=1.03141e-17
    ciCDN_15 (CDN_426 VSS) capacitor c=3.28082e-16
    ciCDN_14 (CDN_427 VSS) capacitor c=7.24841e-18
    ciCDN_13 (CDN_429 VSS) capacitor c=1.81538e-17
    ciCDN_12 (CDN_433 VSS) capacitor c=1.31021e-17
    ciCDN_11 (CDN_516 VSS) capacitor c=2.01853e-17
    ciCDN_10 (CDN_530 VSS) capacitor c=4.65722e-17
    ciCDN_9 (CDN_574 VSS) capacitor c=1.91596e-17
    ciCDN_8 (CDN_588 VSS) capacitor c=4.48288e-17
    ciCDN_7 (CDN_619 VSS) capacitor c=1.89325e-17
    ciCDN_6 (CDN_620 VSS) capacitor c=4.02528e-18
    ciCDN_5 (CDN_623 VSS) capacitor c=6.67042e-18
    ciCDN_4 (CDN_635 VSS) capacitor c=2.00041e-17
    ciCDN_3 (CDN_636 VSS) capacitor c=4.02528e-18
    ciCDN_2 (CDN_639 VSS) capacitor c=4.76546e-18
    ciCDN_1 (CDN_653 VSS) capacitor c=6.3697e-17
    ciCDN_0 (CDN VSS) capacitor c=6.5191e-17
    ciCPN_61 (CPN_42 VSS) capacitor c=6.11821e-18
    ciCPN_60 (CPN_48 VSS) capacitor c=2.2305e-16
    ciCPN_59 (CPN_56 VSS) capacitor c=3.09244e-17
    ciCPN_58 (CPN_64 VSS) capacitor c=2.33696e-17
    ciCPN_57 (CPN_72 VSS) capacitor c=1.12048e-17
    ciCPN_56 (CPN_75 VSS) capacitor c=7.60354e-18
    ciCPN_55 (CPN_83 VSS) capacitor c=1.54514e-16
    ciCPN_54 (CPN_89 VSS) capacitor c=5.55839e-18
    ciCPN_53 (CPN_94 VSS) capacitor c=1.57439e-17
    ciCPN_52 (CPN_102 VSS) capacitor c=2.93691e-17
    ciCPN_51 (CPN_110 VSS) capacitor c=4.57751e-18
    ciCPN_50 (CPN_113 VSS) capacitor c=5.77941e-18
    ciCPN_49 (CPN_118 VSS) capacitor c=4.1198e-18
    ciCPN_48 (CPN_124 VSS) capacitor c=1.61277e-16
    ciCPN_47 (CPN_132 VSS) capacitor c=2.24379e-17
    ciCPN_46 (CPN_140 VSS) capacitor c=2.96071e-17
    ciCPN_45 (CPN_148 VSS) capacitor c=5.54274e-18
    ciCPN_44 (CPN_151 VSS) capacitor c=1.05928e-17
    ciCPN_43 (CPN_156 VSS) capacitor c=2e-18
    ciCPN_42 (CPN_159 VSS) capacitor c=4.15066e-18
    ciCPN_41 (CPN_162 VSS) capacitor c=1.64728e-16
    ciCPN_40 (CPN_164 VSS) capacitor c=1.99757e-17
    ciCPN_39 (CPN_172 VSS) capacitor c=2.2416e-17
    ciCPN_38 (CPN_189 VSS) capacitor c=5.86975e-18
    ciCPN_37 (CPN_264 VSS) capacitor c=5.60691e-17
    ciCPN_36 (CPN_265 VSS) capacitor c=1.12678e-16
    ciCPN_35 (CPN_269 VSS) capacitor c=6.63739e-17
    ciCPN_34 (CPN_270 VSS) capacitor c=3.60133e-16
    ciCPN_33 (CPN_273 VSS) capacitor c=4.45346e-17
    ciCPN_32 (CPN_276 VSS) capacitor c=1.55872e-16
    ciCPN_31 (CPN_277 VSS) capacitor c=1.82907e-17
    ciCPN_30 (CPN_278 VSS) capacitor c=3.61901e-17
    ciCPN_29 (CPN_279 VSS) capacitor c=1.67846e-17
    ciCPN_28 (CPN_280 VSS) capacitor c=3.22337e-17
    ciCPN_27 (CPN_281 VSS) capacitor c=1.83311e-17
    ciCPN_26 (CPN_284 VSS) capacitor c=6.24521e-17
    ciCPN_25 (CPN_288 VSS) capacitor c=9.7098e-17
    ciCPN_24 (CPN_290 VSS) capacitor c=9.11229e-17
    ciCPN_23 (CPN_291 VSS) capacitor c=7.84338e-17
    ciCPN_22 (CPN_292 VSS) capacitor c=1.57596e-17
    ciCPN_21 (CPN_294 VSS) capacitor c=2.35567e-17
    ciCPN_20 (CPN_298 VSS) capacitor c=4.4654e-18
    ciCPN_19 (CPN_300 VSS) capacitor c=4.68263e-18
    ciCPN_18 (CPN_302 VSS) capacitor c=2.17098e-17
    ciCPN_17 (CPN_306 VSS) capacitor c=1.88752e-17
    ciCPN_16 (CPN_309 VSS) capacitor c=3.78528e-16
    ciCPN_15 (CPN_310 VSS) capacitor c=4.56202e-18
    ciCPN_14 (CPN_313 VSS) capacitor c=8.23327e-17
    ciCPN_13 (CPN_314 VSS) capacitor c=9.54286e-17
    ciCPN_12 (CPN_317 VSS) capacitor c=1.72954e-17
    ciCPN_11 (CPN_320 VSS) capacitor c=1.0114e-16
    ciCPN_10 (CPN_321 VSS) capacitor c=1.04397e-16
    ciCPN_9 (CPN_323 VSS) capacitor c=8.66253e-18
    ciCPN_8 (CPN_400 VSS) capacitor c=5.03777e-17
    ciCPN_7 (CPN_401 VSS) capacitor c=1.80712e-17
    ciCPN_6 (CPN_440 VSS) capacitor c=6.30845e-17
    ciCPN_5 (CPN_443 VSS) capacitor c=1.98622e-17
    ciCPN_4 (CPN_444 VSS) capacitor c=3.01009e-17
    ciCPN_3 (CPN_456 VSS) capacitor c=2.56178e-17
    ciCPN_2 (CPN_457 VSS) capacitor c=2.9223e-17
    ciCPN_1 (CPN_465 VSS) capacitor c=1.17421e-16
    ciCPN_0 (CPN VSS) capacitor c=1.82926e-17
    cinet49_6 (net49_3 VSS) capacitor c=7.16656e-17
    cinet49_5 (net49_4 VSS) capacitor c=1.28094e-16
    cinet49_4 (net49_8 VSS) capacitor c=7.05461e-17
    cinet49_3 (net49_9 VSS) capacitor c=1.2637e-16
    cinet49_2 (net49_12 VSS) capacitor c=4.92731e-17
    cinet49_1 (net49_15 VSS) capacitor c=1.84083e-17
    cinet49_0 (net49_19 VSS) capacitor c=2.23944e-17
    ciD_17 (D_22 VSS) capacitor c=6.71104e-18
    ciD_16 (D_25 VSS) capacitor c=3.24512e-18
    ciD_15 (D_28 VSS) capacitor c=2.15492e-16
    ciD_14 (D_30 VSS) capacitor c=2.61061e-17
    ciD_13 (D_38 VSS) capacitor c=2.24523e-17
    ciD_12 (D_55 VSS) capacitor c=4.09944e-18
    ciD_11 (D_60 VSS) capacitor c=5.93984e-18
    ciD_10 (D_66 VSS) capacitor c=1.77842e-16
    ciD_9 (D_74 VSS) capacitor c=2.23351e-17
    ciD_8 (D_82 VSS) capacitor c=2.63594e-17
    ciD_7 (D_90 VSS) capacitor c=3.98759e-18
    ciD_6 (D_93 VSS) capacitor c=6.94225e-18
    ciD_5 (D VSS) capacitor c=8.77216e-17
    ciD_4 (D_175 VSS) capacitor c=3.03799e-17
    ciD_3 (D_176 VSS) capacitor c=2.09171e-17
    ciD_2 (D_184 VSS) capacitor c=1.24823e-16
    ciD_1 (D_202 VSS) capacitor c=5.36148e-17
    ciD_0 (D_203 VSS) capacitor c=9.03943e-18
    ciCPNN_68 (CPNN_62 VSS) capacitor c=3.00043e-18
    ciCPNN_67 (CPNN_68 VSS) capacitor c=1.80873e-16
    ciCPNN_66 (CPNN_79 VSS) capacitor c=6.27395e-16
    ciCPNN_65 (CPNN_85 VSS) capacitor c=3.85496e-18
    ciCPNN_64 (CPNN_90 VSS) capacitor c=2.73232e-17
    ciCPNN_63 (CPNN_98 VSS) capacitor c=2.10657e-17
    ciCPNN_62 (CPNN_106 VSS) capacitor c=1.20384e-17
    ciCPNN_61 (CPNN_114 VSS) capacitor c=1.52949e-17
    ciCPNN_60 (CPNN_122 VSS) capacitor c=5.51938e-18
    ciCPNN_59 (CPNN_125 VSS) capacitor c=4.8925e-18
    ciCPNN_58 (CPNN_130 VSS) capacitor c=3.58176e-18
    ciCPNN_57 (CPNN_133 VSS) capacitor c=3.8335e-18
    ciCPNN_56 (CPNN_138 VSS) capacitor c=7.13834e-18
    ciCPNN_55 (CPNN_144 VSS) capacitor c=1.53549e-16
    ciCPNN_54 (CPNN_152 VSS) capacitor c=3.29066e-17
    ciCPNN_53 (CPNN_160 VSS) capacitor c=2.84415e-17
    ciCPNN_52 (CPNN_168 VSS) capacitor c=9.16502e-18
    ciCPNN_51 (CPNN_171 VSS) capacitor c=6.91821e-18
    ciCPNN_50 (CPNN_176 VSS) capacitor c=3.48325e-18
    ciCPNN_49 (CPNN_179 VSS) capacitor c=4.11777e-18
    ciCPNN_48 (CPNN_182 VSS) capacitor c=1.6533e-16
    ciCPNN_47 (CPNN_184 VSS) capacitor c=2.06745e-17
    ciCPNN_46 (CPNN_192 VSS) capacitor c=2.24618e-17
    ciCPNN_45 (CPNN_209 VSS) capacitor c=5.85024e-18
    ciCPNN_44 (CPNN_214 VSS) capacitor c=6.53968e-18
    ciCPNN_43 (CPNN_220 VSS) capacitor c=2.18542e-16
    ciCPNN_42 (CPNN_228 VSS) capacitor c=3.06647e-17
    ciCPNN_41 (CPNN_236 VSS) capacitor c=2.19142e-17
    ciCPNN_40 (CPNN_244 VSS) capacitor c=1.09272e-17
    ciCPNN_39 (CPNN_247 VSS) capacitor c=7.64645e-18
    ciCPNN_38 (CPNN_255 VSS) capacitor c=1.54026e-16
    ciCPNN_37 (CPNN_261 VSS) capacitor c=5.55839e-18
    ciCPNN_36 (CPNN_266 VSS) capacitor c=1.57244e-17
    ciCPNN_35 (CPNN_274 VSS) capacitor c=2.95372e-17
    ciCPNN_34 (CPNN_282 VSS) capacitor c=4.57751e-18
    ciCPNN_33 (CPNN_285 VSS) capacitor c=5.18998e-18
    ciCPNN_32 (CPNN_393 VSS) capacitor c=5.45572e-17
    ciCPNN_31 (CPNN_394 VSS) capacitor c=1.11566e-16
    ciCPNN_30 (CPNN_398 VSS) capacitor c=1.78917e-16
    ciCPNN_29 (CPNN_399 VSS) capacitor c=3.29389e-16
    ciCPNN_28 (CPNN_407 VSS) capacitor c=5.01789e-17
    ciCPNN_27 (CPNN_408 VSS) capacitor c=1.44108e-17
    ciCPNN_26 (CPNN_409 VSS) capacitor c=4.33004e-17
    ciCPNN_25 (CPNN_410 VSS) capacitor c=1.26431e-17
    ciCPNN_24 (CPNN_412 VSS) capacitor c=3.21344e-18
    ciCPNN_23 (CPNN_414 VSS) capacitor c=8.69778e-18
    ciCPNN_22 (CPNN_416 VSS) capacitor c=1.72215e-17
    ciCPNN_21 (CPNN_417 VSS) capacitor c=2.66988e-17
    ciCPNN_20 (CPNN_419 VSS) capacitor c=7.6555e-17
    ciCPNN_19 (CPNN_423 VSS) capacitor c=1.72886e-17
    ciCPNN_18 (CPNN_425 VSS) capacitor c=1.55572e-17
    ciCPNN_17 (CPNN_426 VSS) capacitor c=3.21418e-17
    ciCPNN_16 (CPNN_429 VSS) capacitor c=4.31248e-17
    ciCPNN_15 (CPNN_432 VSS) capacitor c=9.39113e-17
    ciCPNN_14 (CPNN_433 VSS) capacitor c=3.3395e-16
    ciCPNN_13 (CPNN_434 VSS) capacitor c=1.81288e-17
    ciCPNN_12 (CPNN_437 VSS) capacitor c=1.05778e-16
    ciCPNN_11 (CPNN_441 VSS) capacitor c=1.10726e-16
    ciCPNN_10 (CPNN_442 VSS) capacitor c=1.08444e-16
    ciCPNN_9 (CPNN_443 VSS) capacitor c=1.33806e-17
    ciCPNN_8 (CPNN_445 VSS) capacitor c=2.18745e-16
    ciCPNN_7 (CPNN_526 VSS) capacitor c=7.86757e-17
    ciCPNN_6 (CPNN_630 VSS) capacitor c=2.56178e-17
    ciCPNN_5 (CPNN_631 VSS) capacitor c=2.83969e-17
    ciCPNN_4 (CPNN_636 VSS) capacitor c=5.18827e-17
    ciCPNN_3 (CPNN_639 VSS) capacitor c=1.6172e-17
    ciCPNN_2 (CPNN_640 VSS) capacitor c=2.51417e-17
    ciCPNN_1 (CPNN_653 VSS) capacitor c=6.62499e-17
    ciCPNN_0 (CPNN_656 VSS) capacitor c=1.87092e-17
    ciCP_13 (CP_22 VSS) capacitor c=2.22299e-18
    ciCP_12 (CP_28 VSS) capacitor c=1.77235e-16
    ciCP_11 (CP_39 VSS) capacitor c=5.58143e-16
    ciCP_10 (CP_45 VSS) capacitor c=2.22299e-18
    ciCP_9 (CP_50 VSS) capacitor c=2.23697e-17
    ciCP_8 (CP_58 VSS) capacitor c=2.24908e-17
    ciCP_7 (CP_66 VSS) capacitor c=1.36936e-17
    ciCP_6 (CP_74 VSS) capacitor c=1.51948e-17
    ciCP_5 (CP_82 VSS) capacitor c=4.2013e-18
    ciCP_4 (CP_85 VSS) capacitor c=8.01306e-18
    ciCP_3 (CP_90 VSS) capacitor c=5.01351e-18
    ciCP_2 (CP_93 VSS) capacitor c=5.13601e-18
    ciCP_1 (CP VSS) capacitor c=5.51651e-17
    ciCP_0 (CP_201 VSS) capacitor c=3.22364e-17
    rnet299_32 (MM6_s net299_2) resistor r=18.0507
    rnet299_31 (MM6_s net299_5) resistor r=15.1041
    rnet299_30 (MM6_s net299_5) resistor r=2.67027
    rnet299_29 (MM6_s net299_7) resistor r=12.8495
    rnet299_28 (MM6_s net299_7) resistor r=1.69926
    rnet299_27 (MM6_s net299_11) resistor r=4.22001
    rnet299_26 (MM6_s net299) resistor r=10.6787
    rnet299_25 (net299_2 net299_4) resistor r=9.43134
    rnet299_24 (net299_4 net299_5) resistor r=15.1041
    rnet299_23 (net299_6 net299_7) resistor r=12.8495
    rnet299_22 (net299_6 net299_18) resistor r=10.6787
    rnet299_21 (net299_8 net299_11) resistor r=4.22001
    rnet299_20 (net299_8 net299_18) resistor r=0.57282
    rnet299_19 (net299_9 net299_11) resistor r=4.22001
    rnet299_18 (net299_9 net299) resistor r=0.57282
    rnet299_17 (MM4_d net299_11) resistor r=4.22001
    rnet299_16 (MM4_d net299_14) resistor r=15.1041
    rnet299_15 (MM4_d net299_14) resistor r=2.67027
    rnet299_14 (MM4_d net299_16) resistor r=12.1643
    rnet299_13 (MM4_d net299_16) resistor r=1.36649
    rnet299_12 (MM4_d net299_17) resistor r=18.0507
    rnet299_11 (MM4_d net299_18) resistor r=10.6787
    rnet299_10 (net299_12 net299_14) resistor r=15.1041
    rnet299_9 (net299_12 net299_17) resistor r=9.43134
    rnet299_8 (net299_15 net299_16) resistor r=12.1643
    rnet299_7 (net299_15 net299) resistor r=10.6787
    rnet177_35 (MM5_s net177_2) resistor r=18.0507
    rnet177_34 (MM5_s net177_5) resistor r=2.67027
    rnet177_33 (MM5_s net177_7) resistor r=12.8495
    rnet177_32 (MM5_s net177_7) resistor r=1.69926
    rnet177_31 (MM5_s net177_11) resistor r=4.22001
    rnet177_30 (net177_2 net177_4) resistor r=9.43134
    rnet177_29 (net177_3 net177_5) resistor r=15.1041
    rnet177_28 (net177_3 net177_20) resistor r=11.0157
    rnet177_27 (net177_4 net177_5) resistor r=15.1041
    rnet177_26 (net177_6 net177_7) resistor r=12.8495
    rnet177_25 (net177_6 net177) resistor r=10.6787
    rnet177_24 (net177_8 net177_11) resistor r=4.22001
    rnet177_23 (net177_8 net177_20) resistor r=0.762262
    rnet177_22 (net177_9 net177_11) resistor r=4.22001
    rnet177_21 (net177_9 net177) resistor r=0.57282
    rnet177_20 (MM3_d net177_11) resistor r=4.22001
    rnet177_19 (MM3_d net177_14) resistor r=2.67027
    rnet177_18 (MM3_d net177_16) resistor r=12.8495
    rnet177_17 (MM3_d net177_16) resistor r=1.69926
    rnet177_16 (MM3_d net177_19) resistor r=4.557
    rnet177_15 (MM3_d net177) resistor r=10.6787
    rnet177_14 (net177_12 net177_14) resistor r=15.1041
    rnet177_13 (net177_12 net177_17) resistor r=9.43134
    rnet177_12 (net177_13 net177_14) resistor r=15.1041
    rnet177_11 (net177_13 net177_20) resistor r=11.0157
    rnet177_10 (net177_15 net177_16) resistor r=12.8495
    rnet177_9 (net177_15 net177_18) resistor r=9.4369
    rnet177_8 (net177_17 net177_19) resistor r=21.1301
    rnet177_7 (net177_18 net177_19) resistor r=21.1301
    rnet29_32 (MM11_ELT_s net29_2) resistor r=18.0507
    rnet29_31 (MM11_ELT_s net29_5) resistor r=15.1041
    rnet29_30 (MM11_ELT_s net29_5) resistor r=2.67027
    rnet29_29 (MM11_ELT_s net29_7) resistor r=12.8495
    rnet29_28 (MM11_ELT_s net29_7) resistor r=1.69926
    rnet29_27 (MM11_ELT_s net29_11) resistor r=4.22001
    rnet29_26 (MM11_ELT_s net29) resistor r=10.6787
    rnet29_25 (net29_2 net29_4) resistor r=9.43134
    rnet29_24 (net29_4 net29_5) resistor r=15.1041
    rnet29_23 (net29_6 net29_7) resistor r=12.8495
    rnet29_22 (net29_6 net29_18) resistor r=10.6787
    rnet29_21 (net29_8 net29_11) resistor r=4.22001
    rnet29_20 (net29_8 net29_18) resistor r=0.57282
    rnet29_19 (net29_9 net29_11) resistor r=4.22001
    rnet29_18 (net29_9 net29) resistor r=0.57282
    rnet29_17 (MM12_ELT_d net29_11) resistor r=4.22001
    rnet29_16 (MM12_ELT_d net29_14) resistor r=15.1041
    rnet29_15 (MM12_ELT_d net29_14) resistor r=2.67027
    rnet29_14 (MM12_ELT_d net29_16) resistor r=12.1643
    rnet29_13 (MM12_ELT_d net29_16) resistor r=1.36649
    rnet29_12 (MM12_ELT_d net29_17) resistor r=18.0507
    rnet29_11 (MM12_ELT_d net29_18) resistor r=10.6787
    rnet29_10 (net29_12 net29_14) resistor r=15.1041
    rnet29_9 (net29_12 net29_17) resistor r=9.43134
    rnet29_8 (net29_15 net29_16) resistor r=12.1643
    rnet29_7 (net29_15 net29) resistor r=10.6787
    rnet17_38 (MM16_ELT_s net17_2) resistor r=18.0507
    rnet17_37 (MM16_ELT_s net17_5) resistor r=2.67027
    rnet17_36 (MM16_ELT_s net17_7) resistor r=12.8495
    rnet17_35 (MM16_ELT_s net17_7) resistor r=1.69926
    rnet17_34 (MM16_ELT_s net17_11) resistor r=4.22001
    rnet17_33 (net17_2 net17_4) resistor r=9.43134
    rnet17_32 (net17_3 net17_5) resistor r=15.1041
    rnet17_31 (net17_3 net17_20) resistor r=11.0157
    rnet17_30 (net17_4 net17_5) resistor r=15.1041
    rnet17_29 (net17_6 net17_7) resistor r=12.8495
    rnet17_28 (net17_6 net17) resistor r=10.6787
    rnet17_27 (net17_8 net17_11) resistor r=4.22001
    rnet17_26 (net17_8 net17_20) resistor r=0.762262
    rnet17_25 (net17_9 net17_11) resistor r=4.22001
    rnet17_24 (net17_9 net17) resistor r=0.57282
    rnet17_23 (MM17_ELT_d net17_11) resistor r=4.22001
    rnet17_22 (MM17_ELT_d net17_14) resistor r=2.67027
    rnet17_21 (MM17_ELT_d net17_16) resistor r=12.8495
    rnet17_20 (MM17_ELT_d net17_16) resistor r=1.69926
    rnet17_19 (MM17_ELT_d net17_19) resistor r=4.557
    rnet17_18 (MM17_ELT_d net17) resistor r=10.6787
    rnet17_17 (net17_12 net17_14) resistor r=15.1041
    rnet17_16 (net17_12 net17_17) resistor r=9.43134
    rnet17_15 (net17_13 net17_14) resistor r=15.1041
    rnet17_14 (net17_13 net17_20) resistor r=11.0157
    rnet17_13 (net17_15 net17_16) resistor r=12.8495
    rnet17_12 (net17_15 net17_18) resistor r=9.4369
    rnet17_11 (net17_17 net17_19) resistor r=21.1301
    rnet17_10 (net17_18 net17_19) resistor r=21.1301
    rnet722_36 (net722_1 net722_4) resistor r=20.2547
    rnet722_35 (net722_1 net722_5) resistor r=9.04595
    rnet722_34 (net722_2 net722_4) resistor r=20.2547
    rnet722_33 (net722_2 net722_8) resistor r=9.04062
    rnet722_32 (MM8_s net722_4) resistor r=4.36821
    rnet722_31 (MM8_s net722_6) resistor r=12.3172
    rnet722_30 (MM8_s net722_6) resistor r=1.62887
    rnet722_29 (MM8_s net722_9) resistor r=2.55965
    rnet722_28 (MM8_s net722_13) resistor r=4.04518
    rnet722_27 (MM8_s net722_20) resistor r=10.2363
    rnet722_26 (net722_5 net722_6) resistor r=12.3172
    rnet722_25 (net722_7 net722_9) resistor r=14.4784
    rnet722_24 (net722_7 net722) resistor r=10.5593
    rnet722_23 (net722_8 net722_9) resistor r=14.4784
    rnet722_22 (net722_10 net722_13) resistor r=4.04518
    rnet722_21 (net722_10 net722_20) resistor r=0.549089
    rnet722_20 (net722_11 net722_13) resistor r=4.04518
    rnet722_19 (net722_11 net722) resistor r=0.730683
    rnet722_18 (MM12_d net722_13) resistor r=4.04518
    rnet722_17 (MM12_d net722_15) resistor r=11.6604
    rnet722_16 (MM12_d net722_15) resistor r=1.30988
    rnet722_15 (MM12_d net722_18) resistor r=2.55965
    rnet722_14 (MM12_d net722_19) resistor r=17.3029
    rnet722_13 (net722_14 net722_15) resistor r=11.6604
    rnet722_12 (net722_14 net722_20) resistor r=10.2363
    rnet722_11 (net722_16 net722_18) resistor r=14.4784
    rnet722_10 (net722_16 net722_19) resistor r=9.04062
    rnet722_9 (net722_17 net722_18) resistor r=14.4784
    rnet722_8 (net722_17 net722) resistor r=10.5593
    rnet72_37 (net72_1 net72_4) resistor r=20.2547
    rnet72_36 (net72_1 net72_5) resistor r=9.04595
    rnet72_35 (net72_2 net72_4) resistor r=20.2547
    rnet72_34 (net72_2 net72_8) resistor r=9.04062
    rnet72_33 (MM10_ELT_s net72_4) resistor r=4.36821
    rnet72_32 (MM10_ELT_s net72_6) resistor r=12.3172
    rnet72_31 (MM10_ELT_s net72_6) resistor r=1.62887
    rnet72_30 (MM10_ELT_s net72_9) resistor r=2.55965
    rnet72_29 (MM10_ELT_s net72_13) resistor r=4.04518
    rnet72_28 (MM10_ELT_s net72_20) resistor r=10.2363
    rnet72_27 (net72_5 net72_6) resistor r=12.3172
    rnet72_26 (net72_7 net72_9) resistor r=14.4784
    rnet72_25 (net72_7 net72) resistor r=10.5593
    rnet72_24 (net72_8 net72_9) resistor r=14.4784
    rnet72_23 (net72_10 net72_13) resistor r=4.04518
    rnet72_22 (net72_10 net72_20) resistor r=0.549089
    rnet72_21 (net72_11 net72_13) resistor r=4.04518
    rnet72_20 (net72_11 net72) resistor r=0.730683
    rnet72_19 (MM9_ELT_d net72_13) resistor r=4.04518
    rnet72_18 (MM9_ELT_d net72_15) resistor r=11.6604
    rnet72_17 (MM9_ELT_d net72_15) resistor r=1.30988
    rnet72_16 (MM9_ELT_d net72_18) resistor r=2.55965
    rnet72_15 (MM9_ELT_d net72_19) resistor r=17.3029
    rnet72_14 (net72_14 net72_15) resistor r=11.6604
    rnet72_13 (net72_14 net72_20) resistor r=10.2363
    rnet72_12 (net72_16 net72_18) resistor r=14.4784
    rnet72_11 (net72_16 net72_19) resistor r=9.04062
    rnet72_10 (net72_17 net72_18) resistor r=14.4784
    rnet72_9 (net72_17 net72) resistor r=10.5593
    rQ_52 (Q_1 Q_3) resistor r=0.474056
    rQ_51 (Q_1 Q_18) resistor r=0.0961177
    rQ_50 (Q_3 Q_4) resistor r=13
    rQ_49 (Q_4 MM133_ELT_d) resistor r=8.44
    rQ_48 (Q_6 Q_8) resistor r=0.485761
    rQ_47 (Q_6 Q_20) resistor r=0.0961177
    rQ_46 (Q_8 Q_9) resistor r=8.66667
    rQ_45 (Q_8 Q_11) resistor r=0.702305
    rQ_44 (Q_9 MM144_ELT_d) resistor r=32.3614
    rQ_43 (Q_11 Q_12) resistor r=8.66667
    rQ_42 (Q_11 Q_14) resistor r=0.468203
    rQ_41 (Q_12 MM144_ELT_d) resistor r=16.1807
    rQ_40 (Q_12 Q_15) resistor r=32.3614
    rQ_39 (Q_14 Q_15) resistor r=26
    rQ_38 (Q_17 Q_18) resistor r=0.669348
    rQ_37 (Q_17 Q_41) resistor r=0.0556903
    rQ_36 (Q_19 Q_20) resistor r=0.540592
    rQ_35 (Q_19 Q_44) resistor r=0.0466593
    rQ_34 (Q_21 Q_23) resistor r=0.431786
    rQ_33 (Q_21 Q_41) resistor r=0.0101031
    rQ_32 (Q_23 Q_24) resistor r=13
    rQ_31 (Q_24 MM3_ELT_d) resistor r=8.44
    rQ_30 (Q_26 Q_28) resistor r=0.442448
    rQ_29 (Q_26 Q_44) resistor r=0.0101031
    rQ_28 (Q_28 Q_29) resistor r=8.66667
    rQ_27 (Q_28 Q_31) resistor r=0.639683
    rQ_26 (Q_29 MM2_ELT_d) resistor r=32.3614
    rQ_25 (Q_31 Q_32) resistor r=8.66667
    rQ_24 (Q_31 Q_34) resistor r=0.426455
    rQ_23 (Q_32 MM2_ELT_d) resistor r=16.1807
    rQ_22 (Q_32 Q_35) resistor r=32.3614
    rQ_21 (Q_34 Q_35) resistor r=26
    rQ_20 (Q_37 Q) resistor r=0.0878586
    rQ_19 (Q_37 Q_42) resistor r=0.0101031
    rQ_18 (Q_38 Q) resistor r=0.434152
    rQ_17 (Q_38 Q_45) resistor r=0.0101031
    rQ_16 (Q_41 Q_42) resistor r=0.185634
    rQ_15 (Q_44 Q_45) resistor r=0.155531
    rVDD_378 (MM1_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_377 (MM15_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_376 (MM14_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_375 (MM10_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_374 (MM9_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_373 (MM8_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_372 (MM6_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_371 (MM7_b MM28_ELT_b) resistor r=0.01
    rVDD_370 (MM10_b MM28_ELT_b) resistor r=0.01
    rVDD_369 (MM8_b MM28_ELT_b) resistor r=0.01
    rVDD_368 (MM12_b MM28_ELT_b) resistor r=0.01
    rVDD_367 (MM11_b MM28_ELT_b) resistor r=0.01
    rVDD_366 (MM9_b MM28_ELT_b) resistor r=0.01
    rVDD_365 (MM4_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_364 (MM144_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_363 (MM2_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_362 (MM28_ELT_b VDD_69) resistor r=8.66667
    rVDD_361 (MM28_ELT_b VDD_72) resistor r=8.66667
    rVDD_360 (MM28_ELT_b VDD_82) resistor r=8.66667
    rVDD_359 (MM28_ELT_b VDD_92) resistor r=8.66667
    rVDD_358 (MM28_ELT_b VDD_120) resistor r=8.66667
    rVDD_357 (MM28_ELT_b VDD_123) resistor r=13
    rVDD_356 (MM28_ELT_b VDD_135) resistor r=8.66667
    rVDD_355 (MM28_ELT_b VDD_138) resistor r=8.66667
    rVDD_354 (MM28_ELT_b VDD_132) resistor r=22.5067
    rVDD_353 (VDD_2 VDD_7) resistor r=0.114637
    rVDD_352 (VDD_2 VDD_126) resistor r=0.022155
    rVDD_351 (VDD VDD_7) resistor r=0.102778
    rVDD_350 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_349 (VDD_8 VDD_24) resistor r=67.52
    rVDD_348 (VDD_9 VDD_18) resistor r=0.538434
    rVDD_347 (VDD_9 VDD_126) resistor r=0.0882627
    rVDD_346 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_345 (VDD_11 VDD_15) resistor r=0.702305
    rVDD_344 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_343 (VDD_15 VDD_18) resistor r=0.468203
    rVDD_342 (VDD_18 VDD_19) resistor r=13
    rVDD_341 (VDD_19 MM1_ELT_s) resistor r=4.04518
    rVDD_340 (VDD_19 VDD_242) resistor r=4.04518
    rVDD_339 (VDD_19 MM28_ELT_s) resistor r=4.04518
    rVDD_338 (VDD_19 VDD_240) resistor r=4.04518
    rVDD_337 (VDD_20 VDD_23) resistor r=0.168002
    rVDD_336 (VDD_20 VDD_127) resistor r=0.022155
    rVDD_335 (VDD_21 VDD_23) resistor r=0.0869656
    rVDD_334 (VDD_21 VDD_126) resistor r=0.022155
    rVDD_333 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_332 (VDD_24 VDD_34) resistor r=67.52
    rVDD_331 (VDD_25 VDD_27) resistor r=0.511747
    rVDD_330 (VDD_25 VDD_127) resistor r=0.0882627
    rVDD_329 (VDD_27 VDD_28) resistor r=8.66667
    rVDD_328 (VDD_28 VDD_245) resistor r=16.4995
    rVDD_327 (VDD_28 VDD_244) resistor r=16.4995
    rVDD_326 (VDD_28 MM14_ELT_s) resistor r=3.29107
    rVDD_325 (VDD_30 VDD_39) resistor r=0.0336004
    rVDD_324 (VDD_30 VDD_128) resistor r=0.022155
    rVDD_323 (VDD_31 VDD_33) resistor r=0.0336004
    rVDD_322 (VDD_31 VDD_127) resistor r=0.022155
    rVDD_321 (VDD_33 VDD_34) resistor r=8.66667
    rVDD_320 (VDD_33 VDD_36) resistor r=0.237179
    rVDD_319 (VDD_34 VDD_37) resistor r=67.52
    rVDD_318 (VDD_36 VDD_37) resistor r=8.66667
    rVDD_317 (VDD_36 VDD_39) resistor r=0.237179
    rVDD_316 (VDD_37 VDD_40) resistor r=67.52
    rVDD_315 (VDD_39 VDD_40) resistor r=8.66667
    rVDD_314 (VDD_40 VDD_50) resistor r=67.52
    rVDD_313 (VDD_41 VDD_43) resistor r=0.5662
    rVDD_312 (VDD_41 VDD_128) resistor r=0.0882627
    rVDD_311 (VDD_43 VDD_44) resistor r=13
    rVDD_310 (VDD_44 MM9_ELT_s) resistor r=8.09035
    rVDD_309 (VDD_46 VDD_49) resistor r=0.168002
    rVDD_308 (VDD_46 VDD_129) resistor r=0.022155
    rVDD_307 (VDD_47 VDD_49) resistor r=0.168002
    rVDD_306 (VDD_47 VDD_128) resistor r=0.022155
    rVDD_305 (VDD_49 VDD_50) resistor r=8.66667
    rVDD_304 (VDD_50 VDD_60) resistor r=67.52
    rVDD_303 (VDD_51 VDD_53) resistor r=0.538434
    rVDD_302 (VDD_51 VDD_129) resistor r=0.0882627
    rVDD_301 (VDD_53 VDD_54) resistor r=8.66667
    rVDD_300 (VDD_54 MM6_ELT_s) resistor r=4.04518
    rVDD_299 (VDD_54 VDD_252) resistor r=4.04518
    rVDD_298 (VDD_54 MM8_ELT_s) resistor r=4.04518
    rVDD_297 (VDD_54 VDD_250) resistor r=4.04518
    rVDD_296 (VDD_56 VDD_59) resistor r=0.221367
    rVDD_295 (VDD_56 VDD_131) resistor r=0.022155
    rVDD_294 (VDD_57 VDD_59) resistor r=0.0336004
    rVDD_293 (VDD_57 VDD_129) resistor r=0.022155
    rVDD_292 (VDD_59 VDD_60) resistor r=8.66667
    rVDD_291 (VDD_60 VDD_132) resistor r=67.52
    rVDD_290 (VDD_61 VDD_63) resistor r=0.511747
    rVDD_289 (VDD_61 VDD_131) resistor r=0.0882627
    rVDD_288 (VDD_63 VDD_64) resistor r=8.66667
    rVDD_287 (VDD_64 VDD_257) resistor r=16.4995
    rVDD_286 (VDD_64 VDD_256) resistor r=16.4995
    rVDD_285 (VDD_64 MM10_s) resistor r=3.29107
    rVDD_284 (VDD_66 VDD_72) resistor r=0.0869656
    rVDD_283 (VDD_66 VDD_133) resistor r=0.022155
    rVDD_282 (VDD_67 VDD_69) resistor r=0.217414
    rVDD_281 (VDD_67 VDD_131) resistor r=0.022155
    rVDD_280 (VDD_69 VDD_72) resistor r=0.237179
    rVDD_279 (VDD_74 VDD_76) resistor r=0.5662
    rVDD_278 (VDD_74 VDD_133) resistor r=0.0882627
    rVDD_277 (VDD_76 VDD_77) resistor r=13
    rVDD_276 (VDD_77 MM12_s) resistor r=8.09035
    rVDD_275 (VDD_79 VDD_82) resistor r=0.221367
    rVDD_274 (VDD_79 VDD_135) resistor r=0.022155
    rVDD_273 (VDD_80 VDD_82) resistor r=0.114637
    rVDD_272 (VDD_80 VDD_133) resistor r=0.022155
    rVDD_271 (VDD_84 VDD_86) resistor r=0.538434
    rVDD_270 (VDD_84 VDD_135) resistor r=0.0882627
    rVDD_269 (VDD_86 VDD_87) resistor r=8.66667
    rVDD_268 (VDD_87 MM9_s) resistor r=4.04518
    rVDD_267 (VDD_87 VDD_264) resistor r=4.04518
    rVDD_266 (VDD_87 MM11_s) resistor r=4.04518
    rVDD_265 (VDD_87 VDD_262) resistor r=4.04518
    rVDD_264 (VDD_89 VDD_92) resistor r=0.221367
    rVDD_263 (VDD_89 VDD_138) resistor r=0.022155
    rVDD_262 (VDD_90 VDD_92) resistor r=0.217414
    rVDD_261 (VDD_90 VDD_135) resistor r=0.022155
    rVDD_260 (VDD_94 VDD_103) resistor r=0.538434
    rVDD_259 (VDD_94 VDD_138) resistor r=0.0882627
    rVDD_258 (VDD_96 VDD_104) resistor r=8.66667
    rVDD_257 (VDD_96 VDD_100) resistor r=0.702305
    rVDD_256 (VDD_100 VDD_104) resistor r=8.66667
    rVDD_255 (VDD_100 VDD_103) resistor r=0.468203
    rVDD_254 (VDD_103 VDD_104) resistor r=13
    rVDD_253 (VDD_104 MM144_ELT_s) resistor r=4.04518
    rVDD_252 (VDD_104 VDD_269) resistor r=4.04518
    rVDD_251 (VDD_104 MM4_ELT_s) resistor r=4.04518
    rVDD_250 (VDD_104 VDD_267) resistor r=4.04518
    rVDD_249 (VDD_105 VDD_106) resistor r=0.169978
    rVDD_248 (VDD_105 VDD_140) resistor r=0.022155
    rVDD_247 (VDD_106 VDD_138) resistor r=0.022155
    rVDD_246 (VDD_107 VDD_116) resistor r=0.538434
    rVDD_245 (VDD_107 VDD_140) resistor r=0.0882627
    rVDD_244 (VDD_109 VDD_117) resistor r=8.66667
    rVDD_243 (VDD_109 VDD_113) resistor r=0.702305
    rVDD_242 (VDD_113 VDD_117) resistor r=8.66667
    rVDD_241 (VDD_113 VDD_116) resistor r=0.468203
    rVDD_240 (VDD_116 VDD_117) resistor r=13
    rVDD_239 (VDD_117 MM2_ELT_s) resistor r=4.04518
    rVDD_238 (VDD_117 VDD_273) resistor r=4.04518
    rVDD_237 (VDD_117 MM144_ELT_s) resistor r=4.04518
    rVDD_236 (VDD_117 VDD_271) resistor r=4.04518
    rVDD_235 (VDD_118 VDD_120) resistor r=0.011859
    rVDD_234 (VDD_118 VDD_140) resistor r=0.022155
    rVDD_233 (VDD_120 VDD_123) resistor r=0.158119
    rVDD_232 (VDD_131 VDD_132) resistor r=8.66667
    rVDD_231 (MM28_ELT_s VDD_144) resistor r=25.7298
    rVDD_230 (MM28_ELT_s VDD_147) resistor r=2.55965
    rVDD_229 (MM28_ELT_s VDD_149) resistor r=12.3172
    rVDD_228 (MM28_ELT_s VDD_149) resistor r=1.62887
    rVDD_227 (VDD_144 VDD_146) resistor r=9.04062
    rVDD_226 (VDD_145 VDD_147) resistor r=14.4784
    rVDD_225 (VDD_145 VDD_243) resistor r=10.5593
    rVDD_224 (VDD_146 VDD_147) resistor r=14.4784
    rVDD_223 (VDD_148 VDD_149) resistor r=12.3172
    rVDD_222 (VDD_148 VDD_241) resistor r=10.2363
    rVDD_221 (MM1_ELT_s VDD_153) resistor r=2.55965
    rVDD_220 (MM1_ELT_s VDD_155) resistor r=12.3172
    rVDD_219 (MM1_ELT_s VDD_155) resistor r=1.62887
    rVDD_218 (MM1_ELT_s VDD_158) resistor r=6.12113
    rVDD_217 (MM1_ELT_s VDD_241) resistor r=10.2363
    rVDD_216 (VDD_151 VDD_153) resistor r=14.4784
    rVDD_215 (VDD_151 VDD_157) resistor r=9.04062
    rVDD_214 (VDD_152 VDD_153) resistor r=14.4784
    rVDD_213 (VDD_152 VDD_243) resistor r=10.5593
    rVDD_212 (VDD_154 VDD_155) resistor r=12.3172
    rVDD_211 (VDD_154 VDD_156) resistor r=9.04595
    rVDD_210 (VDD_156 VDD_158) resistor r=31.2341
    rVDD_209 (VDD_157 VDD_158) resistor r=31.2341
    rVDD_208 (MM14_ELT_s VDD_161) resistor r=12.3172
    rVDD_207 (MM14_ELT_s VDD_161) resistor r=1.62887
    rVDD_206 (MM14_ELT_s VDD_164) resistor r=2.55965
    rVDD_205 (MM14_ELT_s VDD_165) resistor r=17.3029
    rVDD_204 (VDD_160 VDD_161) resistor r=12.3172
    rVDD_203 (VDD_160 VDD_244) resistor r=9.39461
    rVDD_202 (VDD_162 VDD_164) resistor r=14.4784
    rVDD_201 (VDD_162 VDD_165) resistor r=9.04062
    rVDD_200 (VDD_163 VDD_164) resistor r=14.4784
    rVDD_199 (VDD_163 VDD_245) resistor r=9.48555
    rVDD_198 (VDD_166 VDD_169) resistor r=20.2547
    rVDD_197 (VDD_166 VDD_170) resistor r=9.04595
    rVDD_196 (VDD_167 VDD_169) resistor r=20.2547
    rVDD_195 (VDD_167 VDD_173) resistor r=9.04062
    rVDD_194 (MM8_ELT_s VDD_169) resistor r=4.36821
    rVDD_193 (MM8_ELT_s VDD_171) resistor r=7.31976
    rVDD_192 (MM8_ELT_s VDD_171) resistor r=1.40052
    rVDD_191 (MM8_ELT_s VDD_174) resistor r=2.55965
    rVDD_190 (MM8_ELT_s VDD_246) resistor r=0.294905
    rVDD_189 (MM8_ELT_s VDD_246) resistor r=8.76455
    rVDD_188 (VDD_170 VDD_171) resistor r=7.31976
    rVDD_187 (VDD_172 VDD_174) resistor r=14.4784
    rVDD_186 (VDD_172 VDD_253) resistor r=10.5593
    rVDD_185 (VDD_173 VDD_174) resistor r=14.4784
    rVDD_184 (VDD_175 VDD_246) resistor r=16.8549
    rVDD_183 (VDD_175 VDD_250) resistor r=5.39357
    rVDD_182 (MM6_ELT_s VDD_180) resistor r=2.55965
    rVDD_181 (MM6_ELT_s VDD_182) resistor r=7.31976
    rVDD_180 (MM6_ELT_s VDD_182) resistor r=1.40052
    rVDD_179 (MM6_ELT_s VDD_187) resistor r=20.2547
    rVDD_178 (MM6_ELT_s VDD_187) resistor r=4.36821
    rVDD_177 (MM6_ELT_s VDD_250) resistor r=13.4839
    rVDD_176 (MM6_ELT_s VDD_181) resistor r=8.54901
    rVDD_175 (VDD_178 VDD_180) resistor r=14.4784
    rVDD_174 (VDD_178 VDD_186) resistor r=9.04062
    rVDD_173 (VDD_179 VDD_180) resistor r=14.4784
    rVDD_172 (VDD_179 VDD_253) resistor r=10.5593
    rVDD_171 (VDD_181 VDD_182) resistor r=7.31976
    rVDD_170 (VDD_186 VDD_187) resistor r=20.2547
    rVDD_169 (MM10_s VDD_190) resistor r=12.3172
    rVDD_168 (MM10_s VDD_190) resistor r=1.62887
    rVDD_167 (MM10_s VDD_193) resistor r=2.55965
    rVDD_166 (MM10_s VDD_194) resistor r=17.3029
    rVDD_165 (VDD_189 VDD_190) resistor r=12.3172
    rVDD_164 (VDD_189 VDD_256) resistor r=9.39461
    rVDD_163 (VDD_191 VDD_193) resistor r=14.4784
    rVDD_162 (VDD_191 VDD_194) resistor r=9.04062
    rVDD_161 (VDD_192 VDD_193) resistor r=14.4784
    rVDD_160 (VDD_192 VDD_257) resistor r=9.48555
    rVDD_159 (VDD_195 VDD_198) resistor r=20.2547
    rVDD_158 (VDD_195 VDD_199) resistor r=9.04595
    rVDD_157 (VDD_196 VDD_198) resistor r=20.2547
    rVDD_156 (VDD_196 VDD_202) resistor r=9.04062
    rVDD_155 (MM11_s VDD_198) resistor r=4.36821
    rVDD_154 (MM11_s VDD_200) resistor r=7.31976
    rVDD_153 (MM11_s VDD_200) resistor r=1.40052
    rVDD_152 (MM11_s VDD_203) resistor r=2.55965
    rVDD_151 (MM11_s VDD_258) resistor r=0.294905
    rVDD_150 (MM11_s VDD_258) resistor r=8.76455
    rVDD_149 (VDD_199 VDD_200) resistor r=7.31976
    rVDD_148 (VDD_201 VDD_203) resistor r=14.4784
    rVDD_147 (VDD_201 VDD_265) resistor r=10.5593
    rVDD_146 (VDD_202 VDD_203) resistor r=14.4784
    rVDD_145 (VDD_204 VDD_258) resistor r=16.8549
    rVDD_144 (VDD_204 VDD_262) resistor r=5.39357
    rVDD_143 (MM9_s VDD_209) resistor r=2.55965
    rVDD_142 (MM9_s VDD_211) resistor r=11.6604
    rVDD_141 (MM9_s VDD_211) resistor r=1.30988
    rVDD_140 (MM9_s VDD_216) resistor r=4.36821
    rVDD_139 (MM9_s VDD_262) resistor r=13.4839
    rVDD_138 (VDD_207 VDD_209) resistor r=14.4784
    rVDD_137 (VDD_207 VDD_215) resistor r=9.04062
    rVDD_136 (VDD_208 VDD_209) resistor r=14.4784
    rVDD_135 (VDD_208 VDD_265) resistor r=10.5593
    rVDD_134 (VDD_210 VDD_211) resistor r=11.6604
    rVDD_133 (VDD_210 VDD_214) resistor r=9.04595
    rVDD_132 (MM4_ELT_s VDD_213) resistor r=9.18184
    rVDD_131 (MM4_ELT_s VDD_219) resistor r=5.25806
    rVDD_130 (MM4_ELT_s VDD_222) resistor r=2.55965
    rVDD_129 (MM4_ELT_s VDD_224) resistor r=11.6604
    rVDD_128 (MM4_ELT_s VDD_224) resistor r=1.30988
    rVDD_127 (MM4_ELT_s VDD_266) resistor r=2.69818
    rVDD_126 (VDD_213 VDD_266) resistor r=5.83401
    rVDD_125 (VDD_214 VDD_216) resistor r=20.2547
    rVDD_124 (VDD_215 VDD_216) resistor r=20.2547
    rVDD_123 (VDD_217 VDD_219) resistor r=24.5762
    rVDD_122 (VDD_217 VDD_266) resistor r=5.83401
    rVDD_121 (VDD_218 VDD_219) resistor r=24.5762
    rVDD_120 (VDD_218 VDD_221) resistor r=9.04062
    rVDD_119 (VDD_220 VDD_222) resistor r=14.4784
    rVDD_118 (VDD_220 VDD_270) resistor r=10.5593
    rVDD_117 (VDD_221 VDD_222) resistor r=14.4784
    rVDD_116 (VDD_223 VDD_224) resistor r=11.6604
    rVDD_115 (VDD_223 VDD_268) resistor r=10.2363
    rVDD_114 (MM144_ELT_s VDD_228) resistor r=2.55965
    rVDD_113 (MM144_ELT_s VDD_230) resistor r=11.6604
    rVDD_112 (MM144_ELT_s VDD_230) resistor r=1.30988
    rVDD_111 (MM144_ELT_s VDD_268) resistor r=10.2363
    rVDD_110 (VDD_226 VDD_228) resistor r=14.4784
    rVDD_109 (VDD_226 VDD_274) resistor r=10.5593
    rVDD_108 (VDD_227 VDD_228) resistor r=14.4784
    rVDD_107 (VDD_227 VDD_270) resistor r=10.5593
    rVDD_106 (VDD_229 VDD_230) resistor r=11.6604
    rVDD_105 (VDD_229 VDD_272) resistor r=10.2363
    rVDD_104 (MM2_ELT_s VDD_234) resistor r=2.55965
    rVDD_103 (MM2_ELT_s VDD_236) resistor r=11.6604
    rVDD_102 (MM2_ELT_s VDD_236) resistor r=1.30988
    rVDD_101 (MM2_ELT_s VDD_239) resistor r=6.12113
    rVDD_100 (MM2_ELT_s VDD_272) resistor r=10.2363
    rVDD_99 (VDD_232 VDD_234) resistor r=14.4784
    rVDD_98 (VDD_232 VDD_238) resistor r=9.04062
    rVDD_97 (VDD_233 VDD_234) resistor r=14.4784
    rVDD_96 (VDD_233 VDD_274) resistor r=10.5593
    rVDD_95 (VDD_235 VDD_236) resistor r=11.6604
    rVDD_94 (VDD_235 VDD_237) resistor r=9.04595
    rVDD_93 (VDD_237 VDD_239) resistor r=31.2341
    rVDD_92 (VDD_238 VDD_239) resistor r=31.2341
    rVDD_91 (VDD_240 VDD_241) resistor r=0.549089
    rVDD_90 (VDD_242 VDD_243) resistor r=0.730683
    rVDD_89 (VDD_252 VDD_253) resistor r=0.730683
    rVDD_88 (VDD_264 VDD_265) resistor r=0.730683
    rVDD_87 (VDD_267 VDD_268) resistor r=0.549089
    rVDD_86 (VDD_269 VDD_270) resistor r=0.730683
    rVDD_85 (VDD_271 VDD_272) resistor r=0.549089
    rVDD_84 (VDD_273 VDD_274) resistor r=0.730683
    rVSS_324 (MM0_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_323 (MM16_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_322 (MM17_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_321 (MM11_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_320 (MM18_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_319 (MM12_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_318 (MM13_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_317 (MM7_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_316 (MM5_b MM29_ELT_b) resistor r=0.01
    rVSS_315 (MM3_b MM29_ELT_b) resistor r=0.01
    rVSS_314 (MM6_b MM29_ELT_b) resistor r=0.01
    rVSS_313 (MM0_b MM29_ELT_b) resistor r=0.01
    rVSS_312 (MM4_b MM29_ELT_b) resistor r=0.01
    rVSS_311 (MM1_b MM29_ELT_b) resistor r=0.01
    rVSS_310 (MM2_b MM29_ELT_b) resistor r=0.01
    rVSS_309 (MM5_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_308 (MM133_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_307 (MM3_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_306 (MM29_ELT_b VSS_53) resistor r=21.5743
    rVSS_305 (MM29_ELT_b VSS_56) resistor r=43.1485
    rVSS_304 (VSS_2 VSS_7) resistor r=0.114637
    rVSS_303 (VSS_2 VSS_103) resistor r=0.022155
    rVSS_302 (VSS VSS_7) resistor r=0.100801
    rVSS_301 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_300 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_299 (VSS_9 VSS_11) resistor r=0.438941
    rVSS_298 (VSS_9 VSS_103) resistor r=0.0882627
    rVSS_297 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_296 (VSS_12 MM0_ELT_s) resistor r=4.22001
    rVSS_295 (VSS_12 VSS_208) resistor r=4.22001
    rVSS_294 (VSS_12 MM29_ELT_s) resistor r=4.22001
    rVSS_293 (VSS_12 VSS_206) resistor r=4.22001
    rVSS_292 (VSS_14 VSS_26) resistor r=0.114637
    rVSS_291 (VSS_14 VSS_104) resistor r=0.022155
    rVSS_290 (VSS_15 VSS_17) resistor r=0.087091
    rVSS_289 (VSS_15 VSS_103) resistor r=0.022155
    rVSS_288 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_287 (VSS_17 VSS_20) resistor r=0.237521
    rVSS_286 (VSS_18 VSS_21) resistor r=64.7228
    rVSS_285 (VSS_20 VSS_21) resistor r=8.66667
    rVSS_284 (VSS_20 VSS_23) resistor r=0.237521
    rVSS_283 (VSS_21 VSS_24) resistor r=64.7228
    rVSS_282 (VSS_23 VSS_24) resistor r=8.66667
    rVSS_281 (VSS_23 VSS_26) resistor r=0.237179
    rVSS_280 (VSS_24 VSS_27) resistor r=64.7228
    rVSS_279 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_278 (VSS_27 VSS_37) resistor r=64.7228
    rVSS_277 (VSS_28 VSS_30) resistor r=0.438941
    rVSS_276 (VSS_28 VSS_104) resistor r=0.0882627
    rVSS_275 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_274 (VSS_31 MM13_ELT_s) resistor r=2.27123
    rVSS_273 (VSS_31 MM18_ELT_s) resistor r=2.27123
    rVSS_272 (VSS_31 VSS_210) resistor r=8.4738
    rVSS_271 (VSS_33 VSS_36) resistor r=0.168002
    rVSS_270 (VSS_33 VSS_105) resistor r=0.022155
    rVSS_269 (VSS_34 VSS_36) resistor r=0.0869656
    rVSS_268 (VSS_34 VSS_104) resistor r=0.022155
    rVSS_267 (VSS_36 VSS_37) resistor r=8.66667
    rVSS_266 (VSS_37 VSS_50) resistor r=64.7228
    rVSS_265 (VSS_38 VSS_40) resistor r=0.399802
    rVSS_264 (VSS_38 VSS_105) resistor r=0.0882627
    rVSS_263 (VSS_40 VSS_44) resistor r=8.66667
    rVSS_262 (VSS_40 VSS_43) resistor r=0.426455
    rVSS_261 (VSS_43 VSS_44) resistor r=26
    rVSS_260 (VSS_44 MM7_ELT_s) resistor r=2.90692
    rVSS_259 (VSS_44 VSS_212) resistor r=12.1406
    rVSS_258 (VSS_46 VSS_58) resistor r=0.168002
    rVSS_257 (VSS_46 VSS_106) resistor r=0.022155
    rVSS_256 (VSS_47 VSS_49) resistor r=0.0336004
    rVSS_255 (VSS_47 VSS_105) resistor r=0.022155
    rVSS_254 (VSS_49 VSS_50) resistor r=8.66667
    rVSS_253 (VSS_49 VSS_52) resistor r=0.237179
    rVSS_252 (VSS_50 VSS_53) resistor r=64.7228
    rVSS_251 (VSS_52 VSS_53) resistor r=8.66667
    rVSS_250 (VSS_52 VSS_55) resistor r=0.237179
    rVSS_249 (VSS_55 VSS_56) resistor r=8.66667
    rVSS_248 (VSS_55 VSS_58) resistor r=0.237179
    rVSS_247 (VSS_56 VSS_59) resistor r=64.7228
    rVSS_246 (VSS_58 VSS_59) resistor r=8.66667
    rVSS_245 (VSS_59 VSS_69) resistor r=64.7228
    rVSS_244 (VSS_60 VSS_62) resistor r=0.438941
    rVSS_243 (VSS_60 VSS_106) resistor r=0.0882627
    rVSS_242 (VSS_62 VSS_63) resistor r=8.66667
    rVSS_241 (VSS_63 MM1_s) resistor r=2.27123
    rVSS_240 (VSS_63 MM0_s) resistor r=2.27123
    rVSS_239 (VSS_63 VSS_213) resistor r=8.4738
    rVSS_238 (VSS_65 VSS_68) resistor r=0.221367
    rVSS_237 (VSS_65 VSS_108) resistor r=0.022155
    rVSS_236 (VSS_66 VSS_68) resistor r=0.0336004
    rVSS_235 (VSS_66 VSS_106) resistor r=0.022155
    rVSS_234 (VSS_68 VSS_69) resistor r=8.66667
    rVSS_233 (VSS_69 VSS_109) resistor r=64.7228
    rVSS_232 (VSS_70 VSS_72) resistor r=0.399802
    rVSS_231 (VSS_70 VSS_108) resistor r=0.0882627
    rVSS_230 (VSS_72 VSS_76) resistor r=8.66667
    rVSS_229 (VSS_72 VSS_75) resistor r=0.426455
    rVSS_228 (VSS_75 VSS_76) resistor r=26
    rVSS_227 (VSS_76 MM2_s) resistor r=2.90692
    rVSS_226 (VSS_76 VSS_215) resistor r=12.1406
    rVSS_225 (VSS_78 VSS_81) resistor r=0.221367
    rVSS_224 (VSS_78 VSS_111) resistor r=0.022155
    rVSS_223 (VSS_79 VSS_81) resistor r=0.217414
    rVSS_222 (VSS_79 VSS_108) resistor r=0.022155
    rVSS_221 (VSS_81 VSS_82) resistor r=8.66667
    rVSS_220 (VSS_82 VSS_109) resistor r=64.7228
    rVSS_219 (VSS_82 VSS_112) resistor r=64.7228
    rVSS_218 (VSS_83 VSS_85) resistor r=0.438941
    rVSS_217 (VSS_83 VSS_111) resistor r=0.0882627
    rVSS_216 (VSS_85 VSS_86) resistor r=8.66667
    rVSS_215 (VSS_86 MM133_ELT_s) resistor r=4.22001
    rVSS_214 (VSS_86 VSS_218) resistor r=4.22001
    rVSS_213 (VSS_86 MM5_ELT_s) resistor r=4.22001
    rVSS_212 (VSS_86 VSS_216) resistor r=4.22001
    rVSS_211 (VSS_88 VSS_89) resistor r=0.169978
    rVSS_210 (VSS_88 VSS_113) resistor r=0.022155
    rVSS_209 (VSS_89 VSS_111) resistor r=0.022155
    rVSS_208 (VSS_90 VSS_92) resistor r=0.438941
    rVSS_207 (VSS_90 VSS_113) resistor r=0.0882627
    rVSS_206 (VSS_92 VSS_93) resistor r=8.66667
    rVSS_205 (VSS_93 MM3_ELT_s) resistor r=4.22001
    rVSS_204 (VSS_93 VSS_222) resistor r=4.22001
    rVSS_203 (VSS_93 MM133_ELT_s) resistor r=4.22001
    rVSS_202 (VSS_93 VSS_220) resistor r=4.22001
    rVSS_201 (VSS_95 VSS_97) resistor r=0.011859
    rVSS_200 (VSS_95 VSS_113) resistor r=0.022155
    rVSS_199 (VSS_97 VSS_98) resistor r=8.66667
    rVSS_198 (VSS_97 VSS_100) resistor r=0.158119
    rVSS_197 (VSS_98 VSS_112) resistor r=64.7228
    rVSS_196 (VSS_98 VSS_101) resistor r=43.1485
    rVSS_195 (VSS_100 VSS_101) resistor r=13
    rVSS_194 (VSS_108 VSS_109) resistor r=8.66667
    rVSS_193 (VSS_111 VSS_112) resistor r=8.66667
    rVSS_192 (MM29_ELT_s VSS_115) resistor r=18.0507
    rVSS_191 (MM29_ELT_s VSS_118) resistor r=2.67027
    rVSS_190 (MM29_ELT_s VSS_120) resistor r=12.8495
    rVSS_189 (MM29_ELT_s VSS_120) resistor r=1.69926
    rVSS_188 (VSS_115 VSS_117) resistor r=9.43134
    rVSS_187 (VSS_116 VSS_118) resistor r=15.1041
    rVSS_186 (VSS_116 VSS_207) resistor r=11.0157
    rVSS_185 (VSS_117 VSS_118) resistor r=15.1041
    rVSS_184 (VSS_119 VSS_120) resistor r=12.8495
    rVSS_183 (VSS_119 VSS_209) resistor r=10.6787
    rVSS_182 (MM0_ELT_s VSS_124) resistor r=2.67027
    rVSS_181 (MM0_ELT_s VSS_126) resistor r=12.8495
    rVSS_180 (MM0_ELT_s VSS_126) resistor r=1.69926
    rVSS_179 (MM0_ELT_s VSS_129) resistor r=4.557
    rVSS_178 (MM0_ELT_s VSS_209) resistor r=10.6787
    rVSS_177 (VSS_122 VSS_124) resistor r=15.1041
    rVSS_176 (VSS_122 VSS_127) resistor r=9.43134
    rVSS_175 (VSS_123 VSS_124) resistor r=15.1041
    rVSS_174 (VSS_123 VSS_207) resistor r=11.0157
    rVSS_173 (VSS_125 VSS_126) resistor r=12.8495
    rVSS_172 (VSS_125 VSS_128) resistor r=9.4369
    rVSS_171 (VSS_127 VSS_129) resistor r=21.1301
    rVSS_170 (VSS_128 VSS_129) resistor r=21.1301
    rVSS_169 (VSS_130 VSS_133) resistor r=21.1301
    rVSS_168 (VSS_130 VSS_135) resistor r=9.43134
    rVSS_167 (VSS_131 VSS_133) resistor r=21.1301
    rVSS_166 (VSS_131 VSS_137) resistor r=9.4369
    rVSS_165 (MM18_ELT_s VSS_133) resistor r=4.557
    rVSS_164 (MM18_ELT_s VSS_136) resistor r=2.67027
    rVSS_163 (MM18_ELT_s VSS_138) resistor r=12.8495
    rVSS_162 (MM18_ELT_s VSS_138) resistor r=1.69926
    rVSS_161 (VSS_134 VSS_136) resistor r=15.1041
    rVSS_160 (VSS_134 VSS_211) resistor r=11.0157
    rVSS_159 (VSS_135 VSS_136) resistor r=15.1041
    rVSS_158 (VSS_137 VSS_138) resistor r=12.8495
    rVSS_157 (MM13_ELT_s VSS_142) resistor r=2.67027
    rVSS_156 (MM13_ELT_s VSS_144) resistor r=12.8495
    rVSS_155 (MM13_ELT_s VSS_144) resistor r=1.69926
    rVSS_154 (MM13_ELT_s VSS_147) resistor r=4.557
    rVSS_153 (VSS_140 VSS_142) resistor r=15.1041
    rVSS_152 (VSS_140 VSS_145) resistor r=9.43134
    rVSS_151 (VSS_141 VSS_142) resistor r=15.1041
    rVSS_150 (VSS_141 VSS_211) resistor r=11.0157
    rVSS_149 (VSS_143 VSS_144) resistor r=12.8495
    rVSS_148 (VSS_143 VSS_146) resistor r=9.4369
    rVSS_147 (VSS_145 VSS_147) resistor r=21.1301
    rVSS_146 (VSS_146 VSS_147) resistor r=21.1301
    rVSS_145 (MM7_ELT_s VSS_151) resistor r=2.67027
    rVSS_144 (MM7_ELT_s VSS_153) resistor r=12.1643
    rVSS_143 (MM7_ELT_s VSS_153) resistor r=1.36649
    rVSS_142 (MM7_ELT_s VSS_156) resistor r=4.557
    rVSS_141 (VSS_149 VSS_151) resistor r=15.1041
    rVSS_140 (VSS_149 VSS_154) resistor r=9.43134
    rVSS_139 (VSS_150 VSS_151) resistor r=15.1041
    rVSS_138 (VSS_150 VSS_212) resistor r=9.89549
    rVSS_137 (VSS_152 VSS_153) resistor r=12.1643
    rVSS_136 (VSS_152 VSS_155) resistor r=9.4369
    rVSS_135 (VSS_154 VSS_156) resistor r=21.1301
    rVSS_134 (VSS_155 VSS_156) resistor r=21.1301
    rVSS_133 (VSS_157 VSS_160) resistor r=21.1301
    rVSS_132 (VSS_157 VSS_162) resistor r=9.43134
    rVSS_131 (VSS_158 VSS_160) resistor r=21.1301
    rVSS_130 (VSS_158 VSS_164) resistor r=9.4369
    rVSS_129 (MM0_s VSS_160) resistor r=4.557
    rVSS_128 (MM0_s VSS_163) resistor r=2.67027
    rVSS_127 (MM0_s VSS_165) resistor r=12.8495
    rVSS_126 (MM0_s VSS_165) resistor r=1.69926
    rVSS_125 (VSS_161 VSS_163) resistor r=15.1041
    rVSS_124 (VSS_161 VSS_214) resistor r=11.0157
    rVSS_123 (VSS_162 VSS_163) resistor r=15.1041
    rVSS_122 (VSS_164 VSS_165) resistor r=12.8495
    rVSS_121 (MM1_s VSS_169) resistor r=2.67027
    rVSS_120 (MM1_s VSS_171) resistor r=12.8495
    rVSS_119 (MM1_s VSS_171) resistor r=1.69926
    rVSS_118 (MM1_s VSS_174) resistor r=4.557
    rVSS_117 (VSS_167 VSS_169) resistor r=15.1041
    rVSS_116 (VSS_167 VSS_172) resistor r=9.43134
    rVSS_115 (VSS_168 VSS_169) resistor r=15.1041
    rVSS_114 (VSS_168 VSS_214) resistor r=11.0157
    rVSS_113 (VSS_170 VSS_171) resistor r=12.8495
    rVSS_112 (VSS_170 VSS_173) resistor r=9.4369
    rVSS_111 (VSS_172 VSS_174) resistor r=21.1301
    rVSS_110 (VSS_173 VSS_174) resistor r=21.1301
    rVSS_109 (MM2_s VSS_178) resistor r=2.67027
    rVSS_108 (MM2_s VSS_180) resistor r=12.1643
    rVSS_107 (MM2_s VSS_180) resistor r=1.36649
    rVSS_106 (MM2_s VSS_183) resistor r=4.557
    rVSS_105 (VSS_176 VSS_178) resistor r=15.1041
    rVSS_104 (VSS_176 VSS_181) resistor r=9.43134
    rVSS_103 (VSS_177 VSS_178) resistor r=15.1041
    rVSS_102 (VSS_177 VSS_215) resistor r=9.89549
    rVSS_101 (VSS_179 VSS_180) resistor r=12.1643
    rVSS_100 (VSS_179 VSS_182) resistor r=9.4369
    rVSS_99 (VSS_181 VSS_183) resistor r=21.1301
    rVSS_98 (VSS_182 VSS_183) resistor r=21.1301
    rVSS_97 (MM5_ELT_s VSS_185) resistor r=18.0507
    rVSS_96 (MM5_ELT_s VSS_188) resistor r=2.67027
    rVSS_95 (MM5_ELT_s VSS_190) resistor r=12.1643
    rVSS_94 (MM5_ELT_s VSS_190) resistor r=1.36649
    rVSS_93 (VSS_185 VSS_187) resistor r=9.43134
    rVSS_92 (VSS_186 VSS_188) resistor r=15.1041
    rVSS_91 (VSS_186 VSS_217) resistor r=11.0157
    rVSS_90 (VSS_187 VSS_188) resistor r=15.1041
    rVSS_89 (VSS_189 VSS_190) resistor r=12.1643
    rVSS_88 (VSS_189 VSS_219) resistor r=10.6787
    rVSS_87 (MM133_ELT_s VSS_194) resistor r=2.67027
    rVSS_86 (MM133_ELT_s VSS_196) resistor r=12.1643
    rVSS_85 (MM133_ELT_s VSS_196) resistor r=1.36649
    rVSS_84 (MM133_ELT_s VSS_219) resistor r=10.6787
    rVSS_83 (VSS_192 VSS_194) resistor r=15.1041
    rVSS_82 (VSS_192 VSS_221) resistor r=11.0157
    rVSS_81 (VSS_193 VSS_194) resistor r=15.1041
    rVSS_80 (VSS_193 VSS_217) resistor r=11.0157
    rVSS_79 (VSS_195 VSS_196) resistor r=12.1643
    rVSS_78 (VSS_195 VSS_223) resistor r=10.6787
    rVSS_77 (MM3_ELT_s VSS_200) resistor r=2.67027
    rVSS_76 (MM3_ELT_s VSS_202) resistor r=12.1643
    rVSS_75 (MM3_ELT_s VSS_202) resistor r=1.36649
    rVSS_74 (MM3_ELT_s VSS_205) resistor r=4.557
    rVSS_73 (MM3_ELT_s VSS_223) resistor r=10.6787
    rVSS_72 (VSS_198 VSS_200) resistor r=15.1041
    rVSS_71 (VSS_198 VSS_203) resistor r=9.43134
    rVSS_70 (VSS_199 VSS_200) resistor r=15.1041
    rVSS_69 (VSS_199 VSS_221) resistor r=11.0157
    rVSS_68 (VSS_201 VSS_202) resistor r=12.1643
    rVSS_67 (VSS_201 VSS_204) resistor r=9.4369
    rVSS_66 (VSS_203 VSS_205) resistor r=21.1301
    rVSS_65 (VSS_204 VSS_205) resistor r=21.1301
    rVSS_64 (VSS_206 VSS_207) resistor r=0.762262
    rVSS_63 (VSS_208 VSS_209) resistor r=0.57282
    rVSS_62 (VSS_210 VSS_211) resistor r=0.762262
    rVSS_61 (VSS_213 VSS_214) resistor r=0.762262
    rVSS_60 (VSS_216 VSS_217) resistor r=0.762262
    rVSS_59 (VSS_218 VSS_219) resistor r=0.57282
    rVSS_58 (VSS_220 VSS_221) resistor r=0.762262
    rVSS_57 (VSS_222 VSS_223) resistor r=0.57282
    rnet11_225 (MM4_ELT_d net11) resistor r=0.01
    rnet11_224 (net11_42 net11_48) resistor r=58.3583
    rnet11_223 (net11_42 net11_48) resistor r=4.16253
    rnet11_222 (net11_42 net11_48) resistor r=58.3583
    rnet11_221 (net11_42 net11_48) resistor r=4.16253
    rnet11_220 (net11_45 net11_48) resistor r=58.3583
    rnet11_219 (net11_45 net11_48) resistor r=5.53947
    rnet11_218 (net11_45 net11_48) resistor r=58.3583
    rnet11_217 (net11_45 net11_48) resistor r=5.53947
    rnet11_216 (net11_48 net11_50) resistor r=11.175
    rnet11_215 (net11_48 net11_73) resistor r=24.8333
    rnet11_214 (net11_48 net11_70) resistor r=24.8333
    rnet11_213 (net11_48 net11_89) resistor r=22.35
    rnet11_212 (net11_48 net11_86) resistor r=22.35
    rnet11_211 (net11_48 net11_102) resistor r=58.3583
    rnet11_210 (net11_48 net11_105) resistor r=58.3583
    rnet11_209 (net11_48 net11_73) resistor r=4.16253
    rnet11_208 (net11_48 net11_50) resistor r=5.53947
    rnet11_207 (net11_48 net11_89) resistor r=2.32428
    rnet11_206 (net11_48 net11_70) resistor r=4.16253
    rnet11_205 (net11_48 net11_102) resistor r=4.16253
    rnet11_204 (net11_48 net11_86) resistor r=4.16253
    rnet11_203 (net11_48 net11_105) resistor r=4.16253
    rnet11_202 (net11_48 net11_50) resistor r=11.175
    rnet11_201 (net11_48 net11_344) resistor r=29.8
    rnet11_200 (net11_48 net11_73) resistor r=24.8333
    rnet11_199 (net11_48 net11_70) resistor r=24.8333
    rnet11_198 (net11_48 net11_89) resistor r=22.35
    rnet11_197 (net11_48 net11_86) resistor r=22.35
    rnet11_196 (net11_48 net11_102) resistor r=58.3583
    rnet11_195 (net11_48 MM133_ELT_g) resistor r=7.45
    rnet11_194 (net11_48 net11_73) resistor r=4.16253
    rnet11_193 (net11_48 net11_50) resistor r=5.53947
    rnet11_192 (net11_48 net11_89) resistor r=2.32428
    rnet11_191 (net11_48 net11_70) resistor r=4.16253
    rnet11_190 (net11_48 net11_102) resistor r=4.16253
    rnet11_189 (net11_48 net11_86) resistor r=4.16253
    rnet11_188 (net11_48 net11_105) resistor r=4.16253
    rnet11_187 (net11_56 net11_59) resistor r=11.175
    rnet11_186 (net11_56 net11_59) resistor r=5.53947
    rnet11_185 (net11_56 net11_59) resistor r=11.175
    rnet11_184 (net11_56 net11_59) resistor r=5.53947
    rnet11_183 (net11_59 net11_62) resistor r=202.392
    rnet11_182 (net11_59 net11_65) resistor r=202.392
    rnet11_181 (net11_59 net11_81) resistor r=24.8333
    rnet11_180 (net11_59 net11_78) resistor r=24.8333
    rnet11_179 (net11_59 net11_97) resistor r=22.35
    rnet11_178 (net11_59 net11_94) resistor r=22.35
    rnet11_177 (net11_59 net11_110) resistor r=202.392
    rnet11_176 (net11_59 net11_113) resistor r=202.392
    rnet11_175 (net11_59 net11_62) resistor r=5.53947
    rnet11_174 (net11_59 net11_97) resistor r=2.32428
    rnet11_173 (net11_59 net11_81) resistor r=4.16253
    rnet11_172 (net11_59 net11_65) resistor r=4.16253
    rnet11_171 (net11_59 net11_94) resistor r=4.16253
    rnet11_170 (net11_59 net11_110) resistor r=4.16253
    rnet11_169 (net11_59 net11_78) resistor r=4.16253
    rnet11_168 (net11_59 net11_113) resistor r=4.16253
    rnet11_167 (net11_59 net11_346) resistor r=31.6625
    rnet11_166 (net11_59 net11_62) resistor r=202.392
    rnet11_165 (net11_59 net11_65) resistor r=202.392
    rnet11_164 (net11_59 net11_81) resistor r=24.8333
    rnet11_163 (net11_59 net11_78) resistor r=24.8333
    rnet11_162 (net11_59 net11_97) resistor r=22.35
    rnet11_161 (net11_59 net11_94) resistor r=22.35
    rnet11_160 (net11_59 net11_110) resistor r=202.392
    rnet11_159 (net11_59 MM144_ELT_g) resistor r=7.45
    rnet11_158 (net11_59 net11_62) resistor r=5.53947
    rnet11_157 (net11_59 net11_97) resistor r=2.32428
    rnet11_156 (net11_59 net11_81) resistor r=4.16253
    rnet11_155 (net11_59 net11_65) resistor r=4.16253
    rnet11_154 (net11_59 net11_94) resistor r=4.16253
    rnet11_153 (net11_59 net11_110) resistor r=4.16253
    rnet11_152 (net11_59 net11_78) resistor r=4.16253
    rnet11_151 (net11_59 net11_113) resistor r=4.16253
    rnet11_150 (net11_105 MM133_ELT_g) resistor r=50.9083
    rnet11_149 (net11_113 MM144_ELT_g) resistor r=194.942
    rnet11_148 (net11_118 net11_124) resistor r=58.3583
    rnet11_147 (net11_118 net11_124) resistor r=4.16253
    rnet11_146 (net11_118 net11_124) resistor r=58.3583
    rnet11_145 (net11_118 net11_124) resistor r=4.16253
    rnet11_144 (net11_121 net11_124) resistor r=58.3583
    rnet11_143 (net11_121 net11_124) resistor r=5.53947
    rnet11_142 (net11_121 net11_124) resistor r=58.3583
    rnet11_141 (net11_121 net11_124) resistor r=5.53947
    rnet11_140 (net11_124 net11_126) resistor r=11.175
    rnet11_139 (net11_124 net11_149) resistor r=24.8333
    rnet11_138 (net11_124 net11_146) resistor r=24.8333
    rnet11_137 (net11_124 net11_165) resistor r=22.35
    rnet11_136 (net11_124 net11_162) resistor r=22.35
    rnet11_135 (net11_124 net11_178) resistor r=58.3583
    rnet11_134 (net11_124 net11_181) resistor r=58.3583
    rnet11_133 (net11_124 net11_149) resistor r=4.16253
    rnet11_132 (net11_124 net11_126) resistor r=5.53947
    rnet11_131 (net11_124 net11_165) resistor r=2.32428
    rnet11_130 (net11_124 net11_146) resistor r=4.16253
    rnet11_129 (net11_124 net11_178) resistor r=4.16253
    rnet11_128 (net11_124 net11_162) resistor r=4.16253
    rnet11_127 (net11_124 net11_181) resistor r=4.16253
    rnet11_126 (net11_124 net11_126) resistor r=11.175
    rnet11_125 (net11_124 net11_378) resistor r=29.8
    rnet11_124 (net11_124 net11_149) resistor r=24.8333
    rnet11_123 (net11_124 net11_146) resistor r=24.8333
    rnet11_122 (net11_124 net11_165) resistor r=22.35
    rnet11_121 (net11_124 net11_162) resistor r=22.35
    rnet11_120 (net11_124 net11_178) resistor r=58.3583
    rnet11_119 (net11_124 MM3_ELT_g) resistor r=7.45
    rnet11_118 (net11_124 net11_149) resistor r=4.16253
    rnet11_117 (net11_124 net11_126) resistor r=5.53947
    rnet11_116 (net11_124 net11_165) resistor r=2.32428
    rnet11_115 (net11_124 net11_146) resistor r=4.16253
    rnet11_114 (net11_124 net11_178) resistor r=4.16253
    rnet11_113 (net11_124 net11_162) resistor r=4.16253
    rnet11_112 (net11_124 net11_181) resistor r=4.16253
    rnet11_111 (net11_132 net11_135) resistor r=11.175
    rnet11_110 (net11_132 net11_135) resistor r=5.53947
    rnet11_109 (net11_132 net11_135) resistor r=11.175
    rnet11_108 (net11_132 net11_135) resistor r=5.53947
    rnet11_107 (net11_135 net11_138) resistor r=202.392
    rnet11_106 (net11_135 net11_141) resistor r=202.392
    rnet11_105 (net11_135 net11_157) resistor r=24.8333
    rnet11_104 (net11_135 net11_154) resistor r=24.8333
    rnet11_103 (net11_135 net11_173) resistor r=22.35
    rnet11_102 (net11_135 net11_170) resistor r=22.35
    rnet11_101 (net11_135 net11_186) resistor r=202.392
    rnet11_100 (net11_135 net11_189) resistor r=202.392
    rnet11_99 (net11_135 net11_138) resistor r=5.53947
    rnet11_98 (net11_135 net11_173) resistor r=2.32428
    rnet11_97 (net11_135 net11_157) resistor r=4.16253
    rnet11_96 (net11_135 net11_141) resistor r=4.16253
    rnet11_95 (net11_135 net11_170) resistor r=4.16253
    rnet11_94 (net11_135 net11_186) resistor r=4.16253
    rnet11_93 (net11_135 net11_154) resistor r=4.16253
    rnet11_92 (net11_135 net11_189) resistor r=4.16253
    rnet11_91 (net11_135 net11_380) resistor r=31.6625
    rnet11_90 (net11_135 net11_138) resistor r=202.392
    rnet11_89 (net11_135 net11_141) resistor r=202.392
    rnet11_88 (net11_135 net11_157) resistor r=24.8333
    rnet11_87 (net11_135 net11_154) resistor r=24.8333
    rnet11_86 (net11_135 net11_173) resistor r=22.35
    rnet11_85 (net11_135 net11_170) resistor r=22.35
    rnet11_84 (net11_135 net11_186) resistor r=202.392
    rnet11_83 (net11_135 MM2_ELT_g) resistor r=7.45
    rnet11_82 (net11_135 net11_138) resistor r=5.53947
    rnet11_81 (net11_135 net11_173) resistor r=2.32428
    rnet11_80 (net11_135 net11_157) resistor r=4.16253
    rnet11_79 (net11_135 net11_141) resistor r=4.16253
    rnet11_78 (net11_135 net11_170) resistor r=4.16253
    rnet11_77 (net11_135 net11_186) resistor r=4.16253
    rnet11_76 (net11_135 net11_154) resistor r=4.16253
    rnet11_75 (net11_135 net11_189) resistor r=4.16253
    rnet11_74 (net11_181 MM3_ELT_g) resistor r=50.9083
    rnet11_73 (net11_189 MM2_ELT_g) resistor r=194.942
    rnet11_72 (net11_261 net11_263) resistor r=0.447778
    rnet11_71 (net11_261 net11_289) resistor r=0.0101031
    rnet11_70 (net11_263 net11_264) resistor r=13
    rnet11_69 (net11_264 MM5_ELT_d) resistor r=8.44
    rnet11_68 (net11_266 net11_268) resistor r=0.442448
    rnet11_67 (net11_266 net11_293) resistor r=0.0101031
    rnet11_66 (net11_268 net11_269) resistor r=8.66667
    rnet11_65 (net11_268 net11_271) resistor r=0.639683
    rnet11_64 (net11_269 net11) resistor r=32.3614
    rnet11_63 (net11_271 net11_272) resistor r=8.66667
    rnet11_62 (net11_271 net11_274) resistor r=0.426455
    rnet11_61 (net11_272 net11) resistor r=16.1807
    rnet11_60 (net11_272 net11_275) resistor r=32.3614
    rnet11_59 (net11_274 net11_275) resistor r=26
    rnet11_58 (net11_277 net11_278) resistor r=0.0878586
    rnet11_57 (net11_277 net11_291) resistor r=0.0101031
    rnet11_56 (net11_278 net11_297) resistor r=0.103398
    rnet11_55 (net11_279 net11_280) resistor r=0.180598
    rnet11_54 (net11_279 net11_297) resistor r=0.103398
    rnet11_53 (net11_280 net11_295) resistor r=0.0101031
    rnet11_52 (net11_281 net11_283) resistor r=0.234637
    rnet11_51 (net11_281 net11_297) resistor r=0.0030592
    rnet11_50 (net11_283 net11_284) resistor r=6.66667
    rnet11_49 (net11_283 net11_286) resistor r=0.517049
    rnet11_48 (net11_284 net11_410) resistor r=3.38636
    rnet11_47 (net11_284 net11_426) resistor r=56.2136
    rnet11_46 (net11_286 net11_287) resistor r=20
    rnet11_45 (net11_287 net11_428) resistor r=8.80455
    rnet11_44 (net11_289 net11_291) resistor r=0.191538
    rnet11_43 (net11_293 net11_295) resistor r=0.155531
    rnet11_42 (net11_344 net11_411) resistor r=3.725
    rnet11_41 (net11_346 net11_411) resistor r=3.725
    rnet11_40 (net11_378 net11_428) resistor r=3.1797
    rnet11_39 (net11_380 net11_428) resistor r=3.1797
    rnet11_38 (net11_410 net11_411) resistor r=3.725
    rnet11_37 (net11_426 net11_428) resistor r=5.41818
    rnet6_225 (MM9_d net6) resistor r=0.01
    rnet6_224 (net6_42 net6_48) resistor r=58.3583
    rnet6_223 (net6_42 net6_48) resistor r=4.16253
    rnet6_222 (net6_42 net6_48) resistor r=58.3583
    rnet6_221 (net6_42 net6_48) resistor r=4.16253
    rnet6_220 (net6_45 net6_48) resistor r=58.3583
    rnet6_219 (net6_45 net6_48) resistor r=4.16253
    rnet6_218 (net6_45 net6_48) resistor r=58.3583
    rnet6_217 (net6_45 net6_48) resistor r=4.16253
    rnet6_216 (net6_48 net6_53) resistor r=22.35
    rnet6_215 (net6_48 net6_50) resistor r=22.35
    rnet6_214 (net6_48 net6_61) resistor r=24.8333
    rnet6_213 (net6_48 net6_58) resistor r=24.8333
    rnet6_212 (net6_48 net6_74) resistor r=11.175
    rnet6_211 (net6_48 net6_96) resistor r=58.3583
    rnet6_210 (net6_48 net6_99) resistor r=58.3583
    rnet6_209 (net6_48 net6_53) resistor r=4.16253
    rnet6_208 (net6_48 net6_61) resistor r=4.16253
    rnet6_207 (net6_48 net6_96) resistor r=5.53947
    rnet6_206 (net6_48 net6_74) resistor r=5.53947
    rnet6_205 (net6_48 net6_50) resistor r=2.32428
    rnet6_204 (net6_48 net6_58) resistor r=4.16253
    rnet6_203 (net6_48 net6_99) resistor r=4.16253
    rnet6_202 (net6_48 net6_53) resistor r=22.35
    rnet6_201 (net6_48 net6_50) resistor r=22.35
    rnet6_200 (net6_48 net6_61) resistor r=24.8333
    rnet6_199 (net6_48 net6_58) resistor r=24.8333
    rnet6_198 (net6_48 net6_349) resistor r=35.3875
    rnet6_197 (net6_48 net6_74) resistor r=11.175
    rnet6_196 (net6_48 net6_96) resistor r=58.3583
    rnet6_195 (net6_48 MM12_g) resistor r=7.45
    rnet6_194 (net6_48 net6_53) resistor r=4.16253
    rnet6_193 (net6_48 net6_61) resistor r=4.16253
    rnet6_192 (net6_48 net6_96) resistor r=5.53947
    rnet6_191 (net6_48 net6_74) resistor r=5.53947
    rnet6_190 (net6_48 net6_50) resistor r=2.32428
    rnet6_189 (net6_48 net6_58) resistor r=4.16253
    rnet6_188 (net6_48 net6_99) resistor r=4.16253
    rnet6_187 (net6_66 net6_72) resistor r=58.3583
    rnet6_186 (net6_66 net6_72) resistor r=4.16253
    rnet6_185 (net6_66 net6_72) resistor r=58.3583
    rnet6_184 (net6_66 net6_72) resistor r=4.16253
    rnet6_183 (net6_69 net6_72) resistor r=58.3583
    rnet6_182 (net6_69 net6_72) resistor r=4.16253
    rnet6_181 (net6_69 net6_72) resistor r=58.3583
    rnet6_180 (net6_69 net6_72) resistor r=4.16253
    rnet6_179 (net6_72 net6_83) resistor r=24.8333
    rnet6_178 (net6_72 net6_80) resistor r=24.8333
    rnet6_177 (net6_72 net6_91) resistor r=22.35
    rnet6_176 (net6_72 net6_88) resistor r=22.35
    rnet6_175 (net6_72 net6_104) resistor r=11.175
    rnet6_174 (net6_72 net6_110) resistor r=58.3583
    rnet6_173 (net6_72 net6_113) resistor r=58.3583
    rnet6_172 (net6_72 net6_83) resistor r=4.16253
    rnet6_171 (net6_72 net6_91) resistor r=4.16253
    rnet6_170 (net6_72 net6_104) resistor r=5.53947
    rnet6_169 (net6_72 net6_113) resistor r=5.53947
    rnet6_168 (net6_72 net6_88) resistor r=2.32428
    rnet6_167 (net6_72 net6_80) resistor r=4.16253
    rnet6_166 (net6_72 net6_110) resistor r=4.16253
    rnet6_165 (net6_72 net6_83) resistor r=24.8333
    rnet6_164 (net6_72 net6_80) resistor r=24.8333
    rnet6_163 (net6_72 net6_91) resistor r=22.35
    rnet6_162 (net6_72 net6_88) resistor r=22.35
    rnet6_161 (net6_72 net6_104) resistor r=11.175
    rnet6_160 (net6_72 net6_364) resistor r=30.7313
    rnet6_159 (net6_72 net6_110) resistor r=58.3583
    rnet6_158 (net6_72 MM4_g) resistor r=22.35
    rnet6_157 (net6_72 net6_83) resistor r=4.16253
    rnet6_156 (net6_72 net6_91) resistor r=4.16253
    rnet6_155 (net6_72 net6_104) resistor r=5.53947
    rnet6_154 (net6_72 net6_113) resistor r=5.53947
    rnet6_153 (net6_72 net6_88) resistor r=2.32428
    rnet6_152 (net6_72 net6_80) resistor r=4.16253
    rnet6_151 (net6_72 net6_110) resistor r=4.16253
    rnet6_150 (net6_99 MM12_g) resistor r=50.9083
    rnet6_149 (net6_113 MM4_g) resistor r=36.0083
    rnet6_148 (net6_118 net6_124) resistor r=58.3583
    rnet6_147 (net6_118 net6_124) resistor r=4.16253
    rnet6_146 (net6_118 net6_124) resistor r=58.3583
    rnet6_145 (net6_118 net6_124) resistor r=4.16253
    rnet6_144 (net6_121 net6_124) resistor r=58.3583
    rnet6_143 (net6_121 net6_124) resistor r=5.53947
    rnet6_142 (net6_121 net6_124) resistor r=58.3583
    rnet6_141 (net6_121 net6_124) resistor r=5.53947
    rnet6_140 (net6_124 net6_126) resistor r=11.175
    rnet6_139 (net6_124 net6_149) resistor r=24.8333
    rnet6_138 (net6_124 net6_146) resistor r=24.8333
    rnet6_137 (net6_124 net6_165) resistor r=22.35
    rnet6_136 (net6_124 net6_162) resistor r=22.35
    rnet6_135 (net6_124 net6_178) resistor r=58.3583
    rnet6_134 (net6_124 net6_181) resistor r=58.3583
    rnet6_133 (net6_124 net6_149) resistor r=4.16253
    rnet6_132 (net6_124 net6_126) resistor r=5.53947
    rnet6_131 (net6_124 net6_165) resistor r=2.32428
    rnet6_130 (net6_124 net6_146) resistor r=4.16253
    rnet6_129 (net6_124 net6_178) resistor r=4.16253
    rnet6_128 (net6_124 net6_162) resistor r=4.16253
    rnet6_127 (net6_124 net6_181) resistor r=4.16253
    rnet6_126 (net6_124 net6_126) resistor r=11.175
    rnet6_125 (net6_124 net6_375) resistor r=29.8
    rnet6_124 (net6_124 net6_149) resistor r=24.8333
    rnet6_123 (net6_124 net6_146) resistor r=24.8333
    rnet6_122 (net6_124 net6_165) resistor r=22.35
    rnet6_121 (net6_124 net6_162) resistor r=22.35
    rnet6_120 (net6_124 net6_178) resistor r=58.3583
    rnet6_119 (net6_124 MM5_ELT_g) resistor r=7.45
    rnet6_118 (net6_124 net6_149) resistor r=4.16253
    rnet6_117 (net6_124 net6_126) resistor r=5.53947
    rnet6_116 (net6_124 net6_165) resistor r=2.32428
    rnet6_115 (net6_124 net6_146) resistor r=4.16253
    rnet6_114 (net6_124 net6_178) resistor r=4.16253
    rnet6_113 (net6_124 net6_162) resistor r=4.16253
    rnet6_112 (net6_124 net6_181) resistor r=4.16253
    rnet6_111 (net6_132 net6_135) resistor r=11.175
    rnet6_110 (net6_132 net6_135) resistor r=5.53947
    rnet6_109 (net6_132 net6_135) resistor r=11.175
    rnet6_108 (net6_132 net6_135) resistor r=5.53947
    rnet6_107 (net6_135 net6_138) resistor r=202.392
    rnet6_106 (net6_135 net6_141) resistor r=202.392
    rnet6_105 (net6_135 net6_157) resistor r=24.8333
    rnet6_104 (net6_135 net6_154) resistor r=24.8333
    rnet6_103 (net6_135 net6_173) resistor r=22.35
    rnet6_102 (net6_135 net6_170) resistor r=22.35
    rnet6_101 (net6_135 net6_186) resistor r=202.392
    rnet6_100 (net6_135 net6_189) resistor r=202.392
    rnet6_99 (net6_135 net6_138) resistor r=5.53947
    rnet6_98 (net6_135 net6_173) resistor r=2.32428
    rnet6_97 (net6_135 net6_157) resistor r=4.16253
    rnet6_96 (net6_135 net6_141) resistor r=4.16253
    rnet6_95 (net6_135 net6_170) resistor r=4.16253
    rnet6_94 (net6_135 net6_186) resistor r=4.16253
    rnet6_93 (net6_135 net6_154) resistor r=4.16253
    rnet6_92 (net6_135 net6_189) resistor r=4.16253
    rnet6_91 (net6_135 net6_377) resistor r=31.6625
    rnet6_90 (net6_135 net6_138) resistor r=202.392
    rnet6_89 (net6_135 net6_141) resistor r=202.392
    rnet6_88 (net6_135 net6_157) resistor r=24.8333
    rnet6_87 (net6_135 net6_154) resistor r=24.8333
    rnet6_86 (net6_135 net6_173) resistor r=22.35
    rnet6_85 (net6_135 net6_170) resistor r=22.35
    rnet6_84 (net6_135 net6_186) resistor r=202.392
    rnet6_83 (net6_135 MM4_ELT_g) resistor r=7.45
    rnet6_82 (net6_135 net6_138) resistor r=5.53947
    rnet6_81 (net6_135 net6_173) resistor r=2.32428
    rnet6_80 (net6_135 net6_157) resistor r=4.16253
    rnet6_79 (net6_135 net6_141) resistor r=4.16253
    rnet6_78 (net6_135 net6_170) resistor r=4.16253
    rnet6_77 (net6_135 net6_186) resistor r=4.16253
    rnet6_76 (net6_135 net6_154) resistor r=4.16253
    rnet6_75 (net6_135 net6_189) resistor r=4.16253
    rnet6_74 (net6_181 MM5_ELT_g) resistor r=50.9083
    rnet6_73 (net6_189 MM4_ELT_g) resistor r=194.942
    rnet6_72 (net6_261 net6_263) resistor r=1.38107
    rnet6_71 (net6_261 net6_295) resistor r=0.00874199
    rnet6_70 (net6_263 net6_264) resistor r=10
    rnet6_69 (net6_264 net6_427) resistor r=0.677273
    rnet6_68 (net6_266 net6_268) resistor r=0.30385
    rnet6_67 (net6_266 net6_287) resistor r=0.0101031
    rnet6_66 (net6_268 net6_269) resistor r=13
    rnet6_65 (net6_269 MM2_d) resistor r=8.44
    rnet6_64 (net6_271 net6_272) resistor r=0.745674
    rnet6_63 (net6_271 net6_291) resistor r=0.0101031
    rnet6_62 (net6_272 net6_295) resistor r=0.0857927
    rnet6_61 (net6_273 net6_275) resistor r=0.474432
    rnet6_60 (net6_273 net6_295) resistor r=0.0857927
    rnet6_59 (net6_275 net6_276) resistor r=13
    rnet6_58 (net6_276 net6) resistor r=8.09035
    rnet6_57 (net6_278 net6_279) resistor r=0.219646
    rnet6_56 (net6_278 net6_289) resistor r=0.0101031
    rnet6_55 (net6_279 net6_296) resistor r=0.103398
    rnet6_54 (net6_280 net6_281) resistor r=0.180598
    rnet6_53 (net6_280 net6_296) resistor r=0.103398
    rnet6_52 (net6_281 net6_293) resistor r=0.0101031
    rnet6_51 (net6_282 net6_284) resistor r=0.199876
    rnet6_50 (net6_282 net6_296) resistor r=0.0030592
    rnet6_49 (net6_284 net6_285) resistor r=10
    rnet6_48 (net6_285 net6_415) resistor r=12.8682
    rnet6_47 (net6_287 net6_289) resistor r=0.15115
    rnet6_46 (net6_291 net6_293) resistor r=0.155531
    rnet6_45 (net6_349 net6_427) resistor r=3.1797
    rnet6_44 (net6_364 net6_428) resistor r=3.1797
    rnet6_43 (net6_375 net6_416) resistor r=8.1518
    rnet6_42 (net6_377 net6_416) resistor r=8.1518
    rnet6_41 (net6_415 net6_416) resistor r=0.275023
    rnet6_40 (net6_427 net6_428) resistor r=25.7364
    rnet68_189 (MM11_d net68) resistor r=0.01
    rnet68_188 (net68_22 net68_28) resistor r=58.3583
    rnet68_187 (net68_22 net68_28) resistor r=4.16253
    rnet68_186 (net68_22 net68_28) resistor r=58.3583
    rnet68_185 (net68_22 net68_28) resistor r=4.16253
    rnet68_184 (net68_25 net68_28) resistor r=58.3583
    rnet68_183 (net68_25 net68_28) resistor r=5.53947
    rnet68_182 (net68_25 net68_28) resistor r=58.3583
    rnet68_181 (net68_25 net68_28) resistor r=5.53947
    rnet68_180 (net68_28 net68_30) resistor r=11.175
    rnet68_179 (net68_28 net68_53) resistor r=24.8333
    rnet68_178 (net68_28 net68_50) resistor r=24.8333
    rnet68_177 (net68_28 net68_69) resistor r=22.35
    rnet68_176 (net68_28 net68_66) resistor r=22.35
    rnet68_175 (net68_28 net68_82) resistor r=58.3583
    rnet68_174 (net68_28 net68_85) resistor r=58.3583
    rnet68_173 (net68_28 net68_53) resistor r=4.16253
    rnet68_172 (net68_28 net68_30) resistor r=5.53947
    rnet68_171 (net68_28 net68_69) resistor r=2.32428
    rnet68_170 (net68_28 net68_50) resistor r=4.16253
    rnet68_169 (net68_28 net68_82) resistor r=4.16253
    rnet68_168 (net68_28 net68_66) resistor r=4.16253
    rnet68_167 (net68_28 net68_85) resistor r=4.16253
    rnet68_166 (net68_28 net68_30) resistor r=11.175
    rnet68_165 (net68_28 net68_211) resistor r=29.8
    rnet68_164 (net68_28 net68_53) resistor r=24.8333
    rnet68_163 (net68_28 net68_50) resistor r=24.8333
    rnet68_162 (net68_28 net68_69) resistor r=22.35
    rnet68_161 (net68_28 net68_66) resistor r=22.35
    rnet68_160 (net68_28 net68_82) resistor r=58.3583
    rnet68_159 (net68_28 MM2_g) resistor r=7.45
    rnet68_158 (net68_28 net68_53) resistor r=4.16253
    rnet68_157 (net68_28 net68_30) resistor r=5.53947
    rnet68_156 (net68_28 net68_69) resistor r=2.32428
    rnet68_155 (net68_28 net68_50) resistor r=4.16253
    rnet68_154 (net68_28 net68_82) resistor r=4.16253
    rnet68_153 (net68_28 net68_66) resistor r=4.16253
    rnet68_152 (net68_28 net68_85) resistor r=4.16253
    rnet68_151 (net68_36 net68_39) resistor r=11.175
    rnet68_150 (net68_36 net68_39) resistor r=5.53947
    rnet68_149 (net68_36 net68_39) resistor r=11.175
    rnet68_148 (net68_36 net68_39) resistor r=5.53947
    rnet68_147 (net68_39 net68_42) resistor r=58.3583
    rnet68_146 (net68_39 net68_45) resistor r=58.3583
    rnet68_145 (net68_39 net68_61) resistor r=24.8333
    rnet68_144 (net68_39 net68_58) resistor r=24.8333
    rnet68_143 (net68_39 net68_77) resistor r=22.35
    rnet68_142 (net68_39 net68_74) resistor r=22.35
    rnet68_141 (net68_39 net68_90) resistor r=58.3583
    rnet68_140 (net68_39 net68_93) resistor r=58.3583
    rnet68_139 (net68_39 net68_42) resistor r=5.53947
    rnet68_138 (net68_39 net68_77) resistor r=2.32428
    rnet68_137 (net68_39 net68_61) resistor r=4.16253
    rnet68_136 (net68_39 net68_45) resistor r=4.16253
    rnet68_135 (net68_39 net68_74) resistor r=4.16253
    rnet68_134 (net68_39 net68_90) resistor r=4.16253
    rnet68_133 (net68_39 net68_58) resistor r=4.16253
    rnet68_132 (net68_39 net68_93) resistor r=4.16253
    rnet68_131 (net68_39 net68_213) resistor r=247.712
    rnet68_130 (net68_39 net68_42) resistor r=58.3583
    rnet68_129 (net68_39 net68_45) resistor r=58.3583
    rnet68_128 (net68_39 net68_61) resistor r=24.8333
    rnet68_127 (net68_39 net68_58) resistor r=24.8333
    rnet68_126 (net68_39 net68_77) resistor r=22.35
    rnet68_125 (net68_39 net68_74) resistor r=22.35
    rnet68_124 (net68_39 net68_90) resistor r=58.3583
    rnet68_123 (net68_39 MM9_g) resistor r=7.45
    rnet68_122 (net68_39 net68_42) resistor r=5.53947
    rnet68_121 (net68_39 net68_77) resistor r=2.32428
    rnet68_120 (net68_39 net68_61) resistor r=4.16253
    rnet68_119 (net68_39 net68_45) resistor r=4.16253
    rnet68_118 (net68_39 net68_74) resistor r=4.16253
    rnet68_117 (net68_39 net68_90) resistor r=4.16253
    rnet68_116 (net68_39 net68_58) resistor r=4.16253
    rnet68_115 (net68_39 net68_93) resistor r=4.16253
    rnet68_114 (net68_85 MM2_g) resistor r=50.9083
    rnet68_113 (net68_93 MM9_g) resistor r=50.9083
    rnet68_112 (net68_131 net68_133) resistor r=0.402244
    rnet68_111 (net68_131 net68_137) resistor r=0.09632
    rnet68_110 (net68_133 net68_134) resistor r=8.66667
    rnet68_109 (net68_134 MM7_d) resistor r=2.78649
    rnet68_108 (net68_134 net68_260) resistor r=11.6377
    rnet68_107 (net68_136 net68_137) resistor r=0.949561
    rnet68_106 (net68_136 net68_183) resistor r=0.0135421
    rnet68_105 (net68_138 net68_140) resistor r=0.366077
    rnet68_104 (net68_138 net68_144) resistor r=0.0961177
    rnet68_103 (net68_140 net68_141) resistor r=13
    rnet68_102 (net68_141 MM5_d) resistor r=8.44
    rnet68_101 (net68_143 net68_144) resistor r=0.499792
    rnet68_100 (net68_143 net68_145) resistor r=0.0961177
    rnet68_99 (net68_145 net68_146) resistor r=0.688117
    rnet68_98 (net68_146 net68_183) resistor r=0.079448
    rnet68_97 (net68_147 net68_148) resistor r=0.595486
    rnet68_96 (net68_147 net68_183) resistor r=0.079448
    rnet68_95 (net68_148 net68_150) resistor r=0.0961177
    rnet68_94 (net68_149 net68_150) resistor r=0.389832
    rnet68_93 (net68_149 net68_184) resistor r=0.072845
    rnet68_92 (net68_151 net68_153) resistor r=0.209884
    rnet68_91 (net68_151 net68_157) resistor r=0.0961177
    rnet68_90 (net68_153 net68_154) resistor r=13
    rnet68_89 (net68_154 MM8_d) resistor r=8.09035
    rnet68_88 (net68_156 net68_157) resistor r=0.385707
    rnet68_87 (net68_156 net68_186) resistor r=0.072845
    rnet68_86 (net68_158 net68_160) resistor r=0.414888
    rnet68_85 (net68_158 net68_184) resistor r=0.0189311
    rnet68_84 (net68_160 net68_161) resistor r=13
    rnet68_83 (net68_161 MM6_d) resistor r=8.44
    rnet68_82 (net68_163 net68_164) resistor r=0.167071
    rnet68_81 (net68_163 net68_185) resistor r=0.072845
    rnet68_80 (net68_164 net68_184) resistor r=0.072845
    rnet68_79 (net68_165 net68_166) resistor r=0.617541
    rnet68_78 (net68_165 net68_185) resistor r=0.0189311
    rnet68_77 (net68_166 net68_186) resistor r=0.0189311
    rnet68_76 (net68_167 net68_168) resistor r=1.34253
    rnet68_75 (net68_167 net68_177) resistor r=0.0961177
    rnet68_74 (net68_168 net68_185) resistor r=0.072845
    rnet68_73 (net68_169 net68_170) resistor r=0.980547
    rnet68_72 (net68_169 net68_171) resistor r=0.0961177
    rnet68_71 (net68_170 net68_186) resistor r=0.072845
    rnet68_70 (net68_171 net68_173) resistor r=0.22922
    rnet68_69 (net68_173 net68_174) resistor r=13
    rnet68_68 (net68_174 net68) resistor r=8.09035
    rnet68_67 (net68_176 net68_177) resistor r=0.831326
    rnet68_66 (net68_176 net68_178) resistor r=0.101309
    rnet68_65 (net68_178 net68_180) resistor r=0.0143147
    rnet68_64 (net68_180 net68_181) resistor r=10
    rnet68_63 (net68_181 net68_243) resistor r=12.8682
    rnet68_62 (net68_211 net68_244) resistor r=8.1518
    rnet68_61 (net68_213 net68_244) resistor r=8.1518
    rnet68_60 (net68_243 net68_244) resistor r=0.275023
    rnet68_59 (MM7_d net68_254) resistor r=2.55965
    rnet68_58 (MM7_d net68_256) resistor r=12.3172
    rnet68_57 (MM7_d net68_256) resistor r=1.62887
    rnet68_56 (MM7_d net68_259) resistor r=4.36821
    rnet68_55 (net68_252 net68_254) resistor r=14.4784
    rnet68_54 (net68_252 net68_257) resistor r=9.04062
    rnet68_53 (net68_253 net68_254) resistor r=14.4784
    rnet68_52 (net68_253 net68_260) resistor r=9.48555
    rnet68_51 (net68_255 net68_256) resistor r=12.3172
    rnet68_50 (net68_255 net68_258) resistor r=9.04595
    rnet68_49 (net68_257 net68_259) resistor r=20.2547
    rnet68_48 (net68_258 net68_259) resistor r=20.2547
    rnet255_15 (MM1_d net255) resistor r=0.01
    rnet255_14 (net255_1 net255_3) resistor r=0.170836
    rnet255_13 (net255_1 net255_7) resistor r=0.0961177
    rnet255_12 (net255_3 net255_4) resistor r=13
    rnet255_11 (net255_4 MM4_s) resistor r=8.44
    rnet255_10 (net255_6 net255_7) resistor r=0.224209
    rnet255_9 (net255_6 net255_8) resistor r=0.0961177
    rnet255_8 (net255_8 net255_10) resistor r=0.974155
    rnet255_7 (net255_10 net255_11) resistor r=13
    rnet255_6 (net255_11 net255) resistor r=8.44
    rnet200_18 (MM0_d net200) resistor r=0.01
    rnet200_17 (net200_1 net200_3) resistor r=0.0536913
    rnet200_16 (net200_1 net200_17) resistor r=0.072845
    rnet200_15 (net200_3 net200_4) resistor r=13
    rnet200_14 (net200_4 MM3_s) resistor r=8.44
    rnet200_13 (net200_8 net200_9) resistor r=0.575962
    rnet200_12 (net200_8 net200_18) resistor r=0.0189311
    rnet200_11 (net200_9 net200_17) resistor r=0.0189311
    rnet200_10 (net200_10 net200_12) resistor r=0.0586376
    rnet200_9 (net200_10 net200_18) resistor r=0.072845
    rnet200_8 (net200_12 net200_13) resistor r=13
    rnet200_7 (net200_13 net200) resistor r=8.44
    rnet499_20 (MM10_d net499) resistor r=0.01
    rnet499_19 (net499_1 net499_3) resistor r=0.426455
    rnet499_18 (net499_1 net499_13) resistor r=0.0101031
    rnet499_17 (net499_3 net499_4) resistor r=13
    rnet499_16 (net499_4 MM7_s) resistor r=8.09035
    rnet499_15 (net499_6 net499_8) resistor r=0.266535
    rnet499_14 (net499_6 net499_17) resistor r=0.0101031
    rnet499_13 (net499_8 net499_9) resistor r=13
    rnet499_12 (net499_9 net499) resistor r=8.09035
    rnet499_11 (net499_11 net499_12) resistor r=0.427768
    rnet499_10 (net499_11 net499_15) resistor r=0.0101031
    rnet499_9 (net499_12 net499_19) resistor r=0.0101031
    rnet499_8 (net499_13 net499_15) resistor r=0.0927396
    rnet499_7 (net499_17 net499_19) resistor r=0.0927396
    rnet5_240 (MM6_ELT_d net5) resistor r=0.01
    rnet5_239 (net5_42 net5_48) resistor r=58.3583
    rnet5_238 (net5_42 net5_48) resistor r=4.16253
    rnet5_237 (net5_42 net5_48) resistor r=58.3583
    rnet5_236 (net5_42 net5_48) resistor r=4.16253
    rnet5_235 (net5_45 net5_48) resistor r=58.3583
    rnet5_234 (net5_45 net5_48) resistor r=4.16253
    rnet5_233 (net5_45 net5_48) resistor r=58.3583
    rnet5_232 (net5_45 net5_48) resistor r=4.16253
    rnet5_231 (net5_48 net5_53) resistor r=22.35
    rnet5_230 (net5_48 net5_50) resistor r=22.35
    rnet5_229 (net5_48 net5_61) resistor r=24.8333
    rnet5_228 (net5_48 net5_58) resistor r=24.8333
    rnet5_227 (net5_48 net5_74) resistor r=11.175
    rnet5_226 (net5_48 net5_96) resistor r=58.3583
    rnet5_225 (net5_48 net5_99) resistor r=58.3583
    rnet5_224 (net5_48 net5_53) resistor r=4.16253
    rnet5_223 (net5_48 net5_61) resistor r=4.16253
    rnet5_222 (net5_48 net5_96) resistor r=5.53947
    rnet5_221 (net5_48 net5_74) resistor r=5.53947
    rnet5_220 (net5_48 net5_50) resistor r=2.32428
    rnet5_219 (net5_48 net5_58) resistor r=4.16253
    rnet5_218 (net5_48 net5_99) resistor r=4.16253
    rnet5_217 (net5_48 net5_53) resistor r=22.35
    rnet5_216 (net5_48 net5_50) resistor r=22.35
    rnet5_215 (net5_48 net5_61) resistor r=24.8333
    rnet5_214 (net5_48 net5_58) resistor r=24.8333
    rnet5_213 (net5_48 net5_351) resistor r=35.3875
    rnet5_212 (net5_48 net5_74) resistor r=11.175
    rnet5_211 (net5_48 net5_96) resistor r=58.3583
    rnet5_210 (net5_48 MM9_ELT_g) resistor r=7.45
    rnet5_209 (net5_48 net5_53) resistor r=4.16253
    rnet5_208 (net5_48 net5_61) resistor r=4.16253
    rnet5_207 (net5_48 net5_96) resistor r=5.53947
    rnet5_206 (net5_48 net5_74) resistor r=5.53947
    rnet5_205 (net5_48 net5_50) resistor r=2.32428
    rnet5_204 (net5_48 net5_58) resistor r=4.16253
    rnet5_203 (net5_48 net5_99) resistor r=4.16253
    rnet5_202 (net5_66 net5_72) resistor r=58.3583
    rnet5_201 (net5_66 net5_72) resistor r=4.16253
    rnet5_200 (net5_66 net5_72) resistor r=58.3583
    rnet5_199 (net5_66 net5_72) resistor r=4.16253
    rnet5_198 (net5_69 net5_72) resistor r=58.3583
    rnet5_197 (net5_69 net5_72) resistor r=4.16253
    rnet5_196 (net5_69 net5_72) resistor r=58.3583
    rnet5_195 (net5_69 net5_72) resistor r=4.16253
    rnet5_194 (net5_72 net5_83) resistor r=24.8333
    rnet5_193 (net5_72 net5_80) resistor r=24.8333
    rnet5_192 (net5_72 net5_91) resistor r=22.35
    rnet5_191 (net5_72 net5_88) resistor r=22.35
    rnet5_190 (net5_72 net5_104) resistor r=11.175
    rnet5_189 (net5_72 net5_110) resistor r=58.3583
    rnet5_188 (net5_72 net5_113) resistor r=58.3583
    rnet5_187 (net5_72 net5_83) resistor r=4.16253
    rnet5_186 (net5_72 net5_91) resistor r=4.16253
    rnet5_185 (net5_72 net5_104) resistor r=5.53947
    rnet5_184 (net5_72 net5_113) resistor r=5.53947
    rnet5_183 (net5_72 net5_88) resistor r=2.32428
    rnet5_182 (net5_72 net5_80) resistor r=4.16253
    rnet5_181 (net5_72 net5_110) resistor r=4.16253
    rnet5_180 (net5_72 net5_83) resistor r=24.8333
    rnet5_179 (net5_72 net5_80) resistor r=24.8333
    rnet5_178 (net5_72 net5_91) resistor r=22.35
    rnet5_177 (net5_72 net5_88) resistor r=22.35
    rnet5_176 (net5_72 net5_104) resistor r=11.175
    rnet5_175 (net5_72 net5_366) resistor r=30.7313
    rnet5_174 (net5_72 net5_110) resistor r=58.3583
    rnet5_173 (net5_72 MM12_ELT_g) resistor r=22.35
    rnet5_172 (net5_72 net5_83) resistor r=4.16253
    rnet5_171 (net5_72 net5_91) resistor r=4.16253
    rnet5_170 (net5_72 net5_104) resistor r=5.53947
    rnet5_169 (net5_72 net5_113) resistor r=5.53947
    rnet5_168 (net5_72 net5_88) resistor r=2.32428
    rnet5_167 (net5_72 net5_80) resistor r=4.16253
    rnet5_166 (net5_72 net5_110) resistor r=4.16253
    rnet5_165 (net5_99 MM9_ELT_g) resistor r=50.9083
    rnet5_164 (net5_113 MM12_ELT_g) resistor r=36.0083
    rnet5_163 (net5_118 net5_124) resistor r=58.3583
    rnet5_162 (net5_118 net5_124) resistor r=4.16253
    rnet5_161 (net5_118 net5_124) resistor r=58.3583
    rnet5_160 (net5_118 net5_124) resistor r=4.16253
    rnet5_159 (net5_121 net5_124) resistor r=58.3583
    rnet5_158 (net5_121 net5_124) resistor r=4.16253
    rnet5_157 (net5_121 net5_124) resistor r=58.3583
    rnet5_156 (net5_121 net5_124) resistor r=4.16253
    rnet5_155 (net5_124 net5_129) resistor r=24.8333
    rnet5_154 (net5_124 net5_126) resistor r=24.8333
    rnet5_153 (net5_124 net5_137) resistor r=24.8333
    rnet5_152 (net5_124 net5_134) resistor r=24.8333
    rnet5_151 (net5_124 net5_142) resistor r=14.9
    rnet5_150 (net5_124 net5_148) resistor r=58.3583
    rnet5_149 (net5_124 net5_151) resistor r=58.3583
    rnet5_148 (net5_124 net5_129) resistor r=4.16253
    rnet5_147 (net5_124 net5_137) resistor r=4.16253
    rnet5_146 (net5_124 net5_148) resistor r=6.30933
    rnet5_145 (net5_124 net5_142) resistor r=6.30933
    rnet5_144 (net5_124 net5_126) resistor r=1.63969
    rnet5_143 (net5_124 net5_134) resistor r=4.16253
    rnet5_142 (net5_124 net5_151) resistor r=4.16253
    rnet5_141 (net5_124 net5_129) resistor r=24.8333
    rnet5_140 (net5_124 net5_126) resistor r=24.8333
    rnet5_139 (net5_124 net5_137) resistor r=24.8333
    rnet5_138 (net5_124 net5_134) resistor r=24.8333
    rnet5_137 (net5_124 net5_382) resistor r=47.1833
    rnet5_136 (net5_124 net5_142) resistor r=14.9
    rnet5_135 (net5_124 net5_148) resistor r=58.3583
    rnet5_134 (net5_124 MM10_g) resistor r=7.45
    rnet5_133 (net5_124 net5_129) resistor r=4.16253
    rnet5_132 (net5_124 net5_137) resistor r=4.16253
    rnet5_131 (net5_124 net5_148) resistor r=6.30933
    rnet5_130 (net5_124 net5_142) resistor r=6.30933
    rnet5_129 (net5_124 net5_126) resistor r=1.63969
    rnet5_128 (net5_124 net5_134) resistor r=4.16253
    rnet5_127 (net5_124 net5_151) resistor r=4.16253
    rnet5_126 (net5_151 MM10_g) resistor r=50.9083
    rnet5_125 (net5_156 net5_162) resistor r=58.3583
    rnet5_124 (net5_156 net5_162) resistor r=4.16253
    rnet5_123 (net5_156 net5_162) resistor r=58.3583
    rnet5_122 (net5_156 net5_162) resistor r=4.16253
    rnet5_121 (net5_159 net5_162) resistor r=58.3583
    rnet5_120 (net5_159 net5_162) resistor r=6.30933
    rnet5_119 (net5_159 net5_162) resistor r=58.3583
    rnet5_118 (net5_159 net5_162) resistor r=6.30933
    rnet5_117 (net5_162 net5_164) resistor r=14.9
    rnet5_116 (net5_162 net5_173) resistor r=24.8333
    rnet5_115 (net5_162 net5_170) resistor r=24.8333
    rnet5_114 (net5_162 net5_181) resistor r=24.8333
    rnet5_113 (net5_162 net5_178) resistor r=24.8333
    rnet5_112 (net5_162 net5_186) resistor r=58.3583
    rnet5_111 (net5_162 net5_189) resistor r=58.3583
    rnet5_110 (net5_162 net5_173) resistor r=4.16253
    rnet5_109 (net5_162 net5_164) resistor r=6.30933
    rnet5_108 (net5_162 net5_181) resistor r=1.63969
    rnet5_107 (net5_162 net5_170) resistor r=4.16253
    rnet5_106 (net5_162 net5_186) resistor r=4.16253
    rnet5_105 (net5_162 net5_178) resistor r=4.16253
    rnet5_104 (net5_162 net5_189) resistor r=4.16253
    rnet5_103 (net5_162 net5_164) resistor r=14.9
    rnet5_102 (net5_162 net5_396) resistor r=39.7333
    rnet5_101 (net5_162 net5_173) resistor r=24.8333
    rnet5_100 (net5_162 net5_170) resistor r=24.8333
    rnet5_99 (net5_162 net5_181) resistor r=24.8333
    rnet5_98 (net5_162 net5_178) resistor r=24.8333
    rnet5_97 (net5_162 net5_186) resistor r=58.3583
    rnet5_96 (net5_162 MM3_g) resistor r=7.45
    rnet5_95 (net5_162 net5_173) resistor r=4.16253
    rnet5_94 (net5_162 net5_164) resistor r=6.30933
    rnet5_93 (net5_162 net5_181) resistor r=1.63969
    rnet5_92 (net5_162 net5_170) resistor r=4.16253
    rnet5_91 (net5_162 net5_186) resistor r=4.16253
    rnet5_90 (net5_162 net5_178) resistor r=4.16253
    rnet5_89 (net5_162 net5_189) resistor r=4.16253
    rnet5_88 (net5_189 MM3_g) resistor r=50.9083
    rnet5_87 (net5_261 net5_263) resistor r=0.949486
    rnet5_86 (net5_261 net5_293) resistor r=0.011441
    rnet5_85 (net5_263 net5_264) resistor r=10
    rnet5_84 (net5_264 net5_433) resistor r=0.677273
    rnet5_83 (net5_266 net5_267) resistor r=0.0575138
    rnet5_82 (net5_266 net5_293) resistor r=0.0820887
    rnet5_81 (net5_267 net5_273) resistor r=0.0961133
    rnet5_80 (net5_268 net5_269) resistor r=0.78722
    rnet5_79 (net5_268 net5_271) resistor r=0.0961177
    rnet5_78 (net5_269 net5_293) resistor r=0.0820887
    rnet5_77 (net5_270 net5_271) resistor r=0.514508
    rnet5_76 (net5_270 net5_287) resistor r=0.0961177
    rnet5_75 (net5_272 net5_273) resistor r=0.326538
    rnet5_74 (net5_272 net5_279) resistor r=0.0970821
    rnet5_73 (net5_274 net5_276) resistor r=0.30385
    rnet5_72 (net5_274 net5_294) resistor r=0.0101031
    rnet5_71 (net5_276 net5_277) resistor r=13
    rnet5_70 (net5_277 MM7_ELT_d) resistor r=8.44
    rnet5_69 (net5_279 net5_281) resistor r=0.293188
    rnet5_68 (net5_281 net5_282) resistor r=13
    rnet5_67 (net5_282 net5) resistor r=8.09035
    rnet5_66 (net5_284 net5_285) resistor r=0.219646
    rnet5_65 (net5_284 net5_296) resistor r=0.0101031
    rnet5_64 (net5_285 net5_298) resistor r=0.103398
    rnet5_63 (net5_286 net5_287) resistor r=0.185102
    rnet5_62 (net5_286 net5_298) resistor r=0.103398
    rnet5_61 (net5_288 net5_290) resistor r=0.616202
    rnet5_60 (net5_288 net5_298) resistor r=0.0030592
    rnet5_59 (net5_290 net5_291) resistor r=10
    rnet5_58 (net5_291 net5_425) resistor r=34.5409
    rnet5_57 (net5_294 net5_296) resistor r=0.15115
    rnet5_56 (net5_351 net5_433) resistor r=3.1797
    rnet5_55 (net5_366 net5_434) resistor r=3.1797
    rnet5_54 (net5_382 net5_391) resistor r=9.29775
    rnet5_53 (net5_390 net5_391) resistor r=22.35
    rnet5_52 (net5_390 net5_399) resistor r=9.29775
    rnet5_51 (net5_396 net5_426) resistor r=10.0997
    rnet5_50 (net5_398 net5_399) resistor r=255.783
    rnet5_49 (net5_398 net5_426) resistor r=10.0997
    rnet5_48 (net5_425 net5_426) resistor r=0.877078
    rnet5_47 (net5_433 net5_434) resistor r=25.7364
    rnet67_188 (MM8_ELT_d net67) resistor r=0.01
    rnet67_187 (net67_22 net67_28) resistor r=58.3583
    rnet67_186 (net67_22 net67_28) resistor r=4.16253
    rnet67_185 (net67_22 net67_28) resistor r=58.3583
    rnet67_184 (net67_22 net67_28) resistor r=4.16253
    rnet67_183 (net67_25 net67_28) resistor r=58.3583
    rnet67_182 (net67_25 net67_28) resistor r=5.53947
    rnet67_181 (net67_25 net67_28) resistor r=58.3583
    rnet67_180 (net67_25 net67_28) resistor r=5.53947
    rnet67_179 (net67_28 net67_30) resistor r=11.175
    rnet67_178 (net67_28 net67_53) resistor r=24.8333
    rnet67_177 (net67_28 net67_50) resistor r=24.8333
    rnet67_176 (net67_28 net67_69) resistor r=22.35
    rnet67_175 (net67_28 net67_66) resistor r=22.35
    rnet67_174 (net67_28 net67_82) resistor r=58.3583
    rnet67_173 (net67_28 net67_85) resistor r=58.3583
    rnet67_172 (net67_28 net67_53) resistor r=4.16253
    rnet67_171 (net67_28 net67_30) resistor r=5.53947
    rnet67_170 (net67_28 net67_69) resistor r=2.32428
    rnet67_169 (net67_28 net67_50) resistor r=4.16253
    rnet67_168 (net67_28 net67_82) resistor r=4.16253
    rnet67_167 (net67_28 net67_66) resistor r=4.16253
    rnet67_166 (net67_28 net67_85) resistor r=4.16253
    rnet67_165 (net67_28 net67_30) resistor r=11.175
    rnet67_164 (net67_28 net67_211) resistor r=29.8
    rnet67_163 (net67_28 net67_53) resistor r=24.8333
    rnet67_162 (net67_28 net67_50) resistor r=24.8333
    rnet67_161 (net67_28 net67_69) resistor r=22.35
    rnet67_160 (net67_28 net67_66) resistor r=22.35
    rnet67_159 (net67_28 net67_82) resistor r=58.3583
    rnet67_158 (net67_28 MM7_ELT_g) resistor r=7.45
    rnet67_157 (net67_28 net67_53) resistor r=4.16253
    rnet67_156 (net67_28 net67_30) resistor r=5.53947
    rnet67_155 (net67_28 net67_69) resistor r=2.32428
    rnet67_154 (net67_28 net67_50) resistor r=4.16253
    rnet67_153 (net67_28 net67_82) resistor r=4.16253
    rnet67_152 (net67_28 net67_66) resistor r=4.16253
    rnet67_151 (net67_28 net67_85) resistor r=4.16253
    rnet67_150 (net67_36 net67_39) resistor r=11.175
    rnet67_149 (net67_36 net67_39) resistor r=5.53947
    rnet67_148 (net67_36 net67_39) resistor r=11.175
    rnet67_147 (net67_36 net67_39) resistor r=5.53947
    rnet67_146 (net67_39 net67_42) resistor r=58.3583
    rnet67_145 (net67_39 net67_45) resistor r=58.3583
    rnet67_144 (net67_39 net67_61) resistor r=24.8333
    rnet67_143 (net67_39 net67_58) resistor r=24.8333
    rnet67_142 (net67_39 net67_77) resistor r=22.35
    rnet67_141 (net67_39 net67_74) resistor r=22.35
    rnet67_140 (net67_39 net67_90) resistor r=58.3583
    rnet67_139 (net67_39 net67_93) resistor r=58.3583
    rnet67_138 (net67_39 net67_42) resistor r=5.53947
    rnet67_137 (net67_39 net67_77) resistor r=2.32428
    rnet67_136 (net67_39 net67_61) resistor r=4.16253
    rnet67_135 (net67_39 net67_45) resistor r=4.16253
    rnet67_134 (net67_39 net67_74) resistor r=4.16253
    rnet67_133 (net67_39 net67_90) resistor r=4.16253
    rnet67_132 (net67_39 net67_58) resistor r=4.16253
    rnet67_131 (net67_39 net67_93) resistor r=4.16253
    rnet67_130 (net67_39 net67_213) resistor r=247.712
    rnet67_129 (net67_39 net67_42) resistor r=58.3583
    rnet67_128 (net67_39 net67_45) resistor r=58.3583
    rnet67_127 (net67_39 net67_61) resistor r=24.8333
    rnet67_126 (net67_39 net67_58) resistor r=24.8333
    rnet67_125 (net67_39 net67_77) resistor r=22.35
    rnet67_124 (net67_39 net67_74) resistor r=22.35
    rnet67_123 (net67_39 net67_90) resistor r=58.3583
    rnet67_122 (net67_39 MM6_ELT_g) resistor r=7.45
    rnet67_121 (net67_39 net67_42) resistor r=5.53947
    rnet67_120 (net67_39 net67_77) resistor r=2.32428
    rnet67_119 (net67_39 net67_61) resistor r=4.16253
    rnet67_118 (net67_39 net67_45) resistor r=4.16253
    rnet67_117 (net67_39 net67_74) resistor r=4.16253
    rnet67_116 (net67_39 net67_90) resistor r=4.16253
    rnet67_115 (net67_39 net67_58) resistor r=4.16253
    rnet67_114 (net67_39 net67_93) resistor r=4.16253
    rnet67_113 (net67_85 MM7_ELT_g) resistor r=50.9083
    rnet67_112 (net67_93 MM6_ELT_g) resistor r=50.9083
    rnet67_111 (net67_131 net67_132) resistor r=0.529471
    rnet67_110 (net67_131 net67_139) resistor r=0.0961177
    rnet67_109 (net67_132 net67_183) resistor r=0.072845
    rnet67_108 (net67_133 net67_135) resistor r=0.373076
    rnet67_107 (net67_133 net67_183) resistor r=0.072845
    rnet67_106 (net67_135 net67_136) resistor r=8.66667
    rnet67_105 (net67_136 MM15_ELT_d) resistor r=2.78649
    rnet67_104 (net67_136 net67_260) resistor r=11.6377
    rnet67_103 (net67_138 net67_139) resistor r=0.112264
    rnet67_102 (net67_138 net67_142) resistor r=0.0961177
    rnet67_101 (net67_140 net67_141) resistor r=1.02486
    rnet67_100 (net67_140 net67_147) resistor r=0.0961177
    rnet67_99 (net67_141 net67_183) resistor r=0.0189311
    rnet67_98 (net67_142 net67_144) resistor r=0.399802
    rnet67_97 (net67_144 net67_145) resistor r=13
    rnet67_96 (net67_145 MM16_ELT_d) resistor r=8.44
    rnet67_95 (net67_147 net67_148) resistor r=0.580843
    rnet67_94 (net67_148 net67_150) resistor r=0.0961177
    rnet67_93 (net67_149 net67_150) resistor r=0.389832
    rnet67_92 (net67_149 net67_184) resistor r=0.072845
    rnet67_91 (net67_151 net67_153) resistor r=0.209884
    rnet67_90 (net67_151 net67_157) resistor r=0.0961177
    rnet67_89 (net67_153 net67_154) resistor r=13
    rnet67_88 (net67_154 MM10_ELT_d) resistor r=8.09035
    rnet67_87 (net67_156 net67_157) resistor r=0.385707
    rnet67_86 (net67_156 net67_186) resistor r=0.072845
    rnet67_85 (net67_158 net67_160) resistor r=0.414888
    rnet67_84 (net67_158 net67_184) resistor r=0.0189311
    rnet67_83 (net67_160 net67_161) resistor r=13
    rnet67_82 (net67_161 MM11_ELT_d) resistor r=8.44
    rnet67_81 (net67_163 net67_164) resistor r=0.167071
    rnet67_80 (net67_163 net67_185) resistor r=0.072845
    rnet67_79 (net67_164 net67_184) resistor r=0.072845
    rnet67_78 (net67_165 net67_166) resistor r=0.617541
    rnet67_77 (net67_165 net67_185) resistor r=0.0189311
    rnet67_76 (net67_166 net67_186) resistor r=0.0189311
    rnet67_75 (net67_167 net67_168) resistor r=0.865185
    rnet67_74 (net67_167 net67_172) resistor r=0.0961177
    rnet67_73 (net67_168 net67_185) resistor r=0.072845
    rnet67_72 (net67_169 net67_170) resistor r=0.980547
    rnet67_71 (net67_169 net67_178) resistor r=0.0961177
    rnet67_70 (net67_170 net67_186) resistor r=0.072845
    rnet67_69 (net67_171 net67_172) resistor r=1.08932
    rnet67_68 (net67_171 net67_173) resistor r=0.101309
    rnet67_67 (net67_173 net67_175) resistor r=0.330101
    rnet67_66 (net67_175 net67_176) resistor r=10
    rnet67_65 (net67_176 net67_243) resistor r=12.8682
    rnet67_64 (net67_178 net67_180) resistor r=0.22922
    rnet67_63 (net67_180 net67_181) resistor r=13
    rnet67_62 (net67_181 net67) resistor r=8.09035
    rnet67_61 (net67_211 net67_244) resistor r=8.1518
    rnet67_60 (net67_213 net67_244) resistor r=8.1518
    rnet67_59 (net67_243 net67_244) resistor r=0.275023
    rnet67_58 (MM15_ELT_d net67_254) resistor r=2.55965
    rnet67_57 (MM15_ELT_d net67_256) resistor r=12.3172
    rnet67_56 (MM15_ELT_d net67_256) resistor r=1.62887
    rnet67_55 (MM15_ELT_d net67_259) resistor r=4.36821
    rnet67_54 (net67_252 net67_254) resistor r=14.4784
    rnet67_53 (net67_252 net67_257) resistor r=9.04062
    rnet67_52 (net67_253 net67_254) resistor r=14.4784
    rnet67_51 (net67_253 net67_260) resistor r=9.48555
    rnet67_50 (net67_255 net67_256) resistor r=12.3172
    rnet67_49 (net67_255 net67_258) resistor r=9.04595
    rnet67_48 (net67_257 net67_259) resistor r=20.2547
    rnet67_47 (net67_258 net67_259) resistor r=20.2547
    rnet25_21 (MM13_ELT_d net25) resistor r=0.01
    rnet25_20 (net25_1 net25_3) resistor r=0.170836
    rnet25_19 (net25_1 net25_7) resistor r=0.0961177
    rnet25_18 (net25_3 net25_4) resistor r=13
    rnet25_17 (net25_4 MM12_ELT_s) resistor r=8.44
    rnet25_16 (net25_6 net25_7) resistor r=0.127254
    rnet25_15 (net25_6 net25_9) resistor r=0.0961177
    rnet25_14 (net25_8 net25_9) resistor r=0.705502
    rnet25_13 (net25_8 net25_15) resistor r=0.0101031
    rnet25_12 (net25_10 net25_12) resistor r=0.399802
    rnet25_11 (net25_10 net25_17) resistor r=0.0101031
    rnet25_10 (net25_12 net25_13) resistor r=13
    rnet25_9 (net25_13 net25) resistor r=8.44
    rnet25_8 (net25_15 net25_17) resistor r=0.0780965
    rnet20_18 (MM18_ELT_d net20) resistor r=0.01
    rnet20_17 (net20_1 net20_3) resistor r=0.0586376
    rnet20_16 (net20_1 net20_17) resistor r=0.072845
    rnet20_15 (net20_3 net20_4) resistor r=13
    rnet20_14 (net20_4 MM17_ELT_s) resistor r=8.44
    rnet20_13 (net20_8 net20_9) resistor r=0.592419
    rnet20_12 (net20_8 net20_18) resistor r=0.0189311
    rnet20_11 (net20_9 net20_17) resistor r=0.0189311
    rnet20_10 (net20_10 net20_12) resistor r=0.0586376
    rnet20_9 (net20_10 net20_18) resistor r=0.072845
    rnet20_8 (net20_12 net20_13) resistor r=13
    rnet20_7 (net20_13 net20) resistor r=8.44
    rCDN_333 (CDN_66 CDN_72) resistor r=58.3583
    rCDN_332 (CDN_66 CDN_72) resistor r=4.16253
    rCDN_331 (CDN_66 CDN_72) resistor r=58.3583
    rCDN_330 (CDN_66 CDN_72) resistor r=4.16253
    rCDN_329 (CDN_69 CDN_72) resistor r=58.3583
    rCDN_328 (CDN_69 CDN_72) resistor r=4.16253
    rCDN_327 (CDN_69 CDN_72) resistor r=58.3583
    rCDN_326 (CDN_69 CDN_72) resistor r=4.16253
    rCDN_325 (CDN_72 CDN_77) resistor r=24.8333
    rCDN_324 (CDN_72 CDN_74) resistor r=24.8333
    rCDN_323 (CDN_72 CDN_85) resistor r=24.8333
    rCDN_322 (CDN_72 CDN_82) resistor r=24.8333
    rCDN_321 (CDN_72 CDN_90) resistor r=58.3583
    rCDN_320 (CDN_72 CDN_93) resistor r=58.3583
    rCDN_319 (CDN_72 CDN_98) resistor r=14.9
    rCDN_318 (CDN_72 CDN_77) resistor r=4.16253
    rCDN_317 (CDN_72 CDN_85) resistor r=4.16253
    rCDN_316 (CDN_72 CDN_74) resistor r=4.16253
    rCDN_315 (CDN_72 CDN_90) resistor r=4.16253
    rCDN_314 (CDN_72 CDN_98) resistor r=6.30933
    rCDN_313 (CDN_72 CDN_93) resistor r=6.30933
    rCDN_312 (CDN_72 CDN_82) resistor r=1.63969
    rCDN_311 (CDN_72 CDN_77) resistor r=24.8333
    rCDN_310 (CDN_72 CDN_74) resistor r=24.8333
    rCDN_309 (CDN_72 CDN_85) resistor r=24.8333
    rCDN_308 (CDN_72 CDN_82) resistor r=24.8333
    rCDN_307 (CDN_72 CDN_90) resistor r=58.3583
    rCDN_306 (CDN_72 MM18_ELT_g) resistor r=22.35
    rCDN_305 (CDN_72 CDN_98) resistor r=14.9
    rCDN_304 (CDN_72 CDN_514) resistor r=39.7333
    rCDN_303 (CDN_72 CDN_77) resistor r=4.16253
    rCDN_302 (CDN_72 CDN_85) resistor r=4.16253
    rCDN_301 (CDN_72 CDN_74) resistor r=4.16253
    rCDN_300 (CDN_72 CDN_90) resistor r=4.16253
    rCDN_299 (CDN_72 CDN_98) resistor r=6.30933
    rCDN_298 (CDN_72 CDN_93) resistor r=6.30933
    rCDN_297 (CDN_72 CDN_82) resistor r=1.63969
    rCDN_296 (CDN_93 MM18_ELT_g) resistor r=36.0083
    rCDN_295 (CDN_104 CDN_110) resistor r=58.3583
    rCDN_294 (CDN_104 CDN_110) resistor r=4.16253
    rCDN_293 (CDN_104 CDN_110) resistor r=58.3583
    rCDN_292 (CDN_104 CDN_110) resistor r=4.16253
    rCDN_291 (CDN_107 CDN_110) resistor r=58.3583
    rCDN_290 (CDN_107 CDN_110) resistor r=6.30933
    rCDN_289 (CDN_107 CDN_110) resistor r=58.3583
    rCDN_288 (CDN_107 CDN_110) resistor r=6.30933
    rCDN_287 (CDN_110 CDN_112) resistor r=14.9
    rCDN_286 (CDN_110 CDN_121) resistor r=24.8333
    rCDN_285 (CDN_110 CDN_118) resistor r=24.8333
    rCDN_284 (CDN_110 CDN_129) resistor r=24.8333
    rCDN_283 (CDN_110 CDN_126) resistor r=24.8333
    rCDN_282 (CDN_110 CDN_142) resistor r=58.3583
    rCDN_281 (CDN_110 CDN_145) resistor r=58.3583
    rCDN_280 (CDN_110 CDN_121) resistor r=4.16253
    rCDN_279 (CDN_110 CDN_112) resistor r=6.30933
    rCDN_278 (CDN_110 CDN_129) resistor r=1.63969
    rCDN_277 (CDN_110 CDN_118) resistor r=4.16253
    rCDN_276 (CDN_110 CDN_142) resistor r=4.16253
    rCDN_275 (CDN_110 CDN_126) resistor r=4.16253
    rCDN_274 (CDN_110 CDN_145) resistor r=4.16253
    rCDN_273 (CDN_110 CDN_112) resistor r=14.9
    rCDN_272 (CDN_110 CDN_522) resistor r=39.7333
    rCDN_271 (CDN_110 CDN_121) resistor r=24.8333
    rCDN_270 (CDN_110 CDN_118) resistor r=24.8333
    rCDN_269 (CDN_110 CDN_129) resistor r=24.8333
    rCDN_268 (CDN_110 CDN_126) resistor r=24.8333
    rCDN_267 (CDN_110 CDN_142) resistor r=58.3583
    rCDN_266 (CDN_110 MM13_ELT_g) resistor r=7.45
    rCDN_265 (CDN_110 CDN_121) resistor r=4.16253
    rCDN_264 (CDN_110 CDN_112) resistor r=6.30933
    rCDN_263 (CDN_110 CDN_129) resistor r=1.63969
    rCDN_262 (CDN_110 CDN_118) resistor r=4.16253
    rCDN_261 (CDN_110 CDN_142) resistor r=4.16253
    rCDN_260 (CDN_110 CDN_126) resistor r=4.16253
    rCDN_259 (CDN_110 CDN_145) resistor r=4.16253
    rCDN_258 (CDN_134 CDN_140) resistor r=58.3583
    rCDN_257 (CDN_134 CDN_140) resistor r=4.16253
    rCDN_256 (CDN_134 CDN_140) resistor r=58.3583
    rCDN_255 (CDN_134 CDN_140) resistor r=4.16253
    rCDN_254 (CDN_137 CDN_140) resistor r=58.3583
    rCDN_253 (CDN_137 CDN_140) resistor r=4.16253
    rCDN_252 (CDN_137 CDN_140) resistor r=58.3583
    rCDN_251 (CDN_137 CDN_140) resistor r=4.16253
    rCDN_250 (CDN_140 CDN_153) resistor r=8.69167
    rCDN_249 (CDN_140 CDN_150) resistor r=8.69167
    rCDN_248 (CDN_140 CDN_161) resistor r=24.8333
    rCDN_247 (CDN_140 CDN_158) resistor r=24.8333
    rCDN_246 (CDN_140 CDN_166) resistor r=14.9
    rCDN_245 (CDN_140 CDN_175) resistor r=8.69167
    rCDN_244 (CDN_140 CDN_172) resistor r=8.69167
    rCDN_243 (CDN_140 CDN_180) resistor r=58.3583
    rCDN_242 (CDN_140 CDN_183) resistor r=58.3583
    rCDN_241 (CDN_140 CDN_153) resistor r=4.16253
    rCDN_240 (CDN_140 CDN_161) resistor r=4.16253
    rCDN_239 (CDN_140 CDN_175) resistor r=6.30933
    rCDN_238 (CDN_140 CDN_150) resistor r=6.30933
    rCDN_237 (CDN_140 CDN_166) resistor r=1.63969
    rCDN_236 (CDN_140 CDN_172) resistor r=4.16253
    rCDN_235 (CDN_140 CDN_180) resistor r=4.16253
    rCDN_234 (CDN_140 CDN_158) resistor r=4.16253
    rCDN_233 (CDN_140 CDN_183) resistor r=4.16253
    rCDN_232 (CDN_140 CDN_153) resistor r=8.69167
    rCDN_231 (CDN_140 CDN_150) resistor r=8.69167
    rCDN_230 (CDN_140 CDN_161) resistor r=24.8333
    rCDN_229 (CDN_140 CDN_158) resistor r=24.8333
    rCDN_228 (CDN_140 CDN_546) resistor r=330.283
    rCDN_227 (CDN_140 CDN_166) resistor r=14.9
    rCDN_226 (CDN_140 CDN_175) resistor r=8.69167
    rCDN_225 (CDN_140 CDN_172) resistor r=8.69167
    rCDN_224 (CDN_140 CDN_180) resistor r=58.3583
    rCDN_223 (CDN_140 MM8_ELT_g) resistor r=7.45
    rCDN_222 (CDN_140 CDN_153) resistor r=4.16253
    rCDN_221 (CDN_140 CDN_161) resistor r=4.16253
    rCDN_220 (CDN_140 CDN_175) resistor r=6.30933
    rCDN_219 (CDN_140 CDN_150) resistor r=6.30933
    rCDN_218 (CDN_140 CDN_166) resistor r=1.63969
    rCDN_217 (CDN_140 CDN_172) resistor r=4.16253
    rCDN_216 (CDN_140 CDN_180) resistor r=4.16253
    rCDN_215 (CDN_140 CDN_158) resistor r=4.16253
    rCDN_214 (CDN_140 CDN_183) resistor r=4.16253
    rCDN_213 (CDN_145 MM13_ELT_g) resistor r=50.9083
    rCDN_212 (CDN_183 MM8_ELT_g) resistor r=50.9083
    rCDN_211 (CDN_188 CDN_194) resistor r=58.3583
    rCDN_210 (CDN_188 CDN_194) resistor r=4.16253
    rCDN_209 (CDN_188 CDN_194) resistor r=58.3583
    rCDN_208 (CDN_188 CDN_194) resistor r=4.16253
    rCDN_207 (CDN_191 CDN_194) resistor r=58.3583
    rCDN_206 (CDN_191 CDN_194) resistor r=4.16253
    rCDN_205 (CDN_191 CDN_194) resistor r=58.3583
    rCDN_204 (CDN_191 CDN_194) resistor r=4.16253
    rCDN_203 (CDN_194 CDN_199) resistor r=24.8333
    rCDN_202 (CDN_194 CDN_196) resistor r=24.8333
    rCDN_201 (CDN_194 CDN_207) resistor r=24.8333
    rCDN_200 (CDN_194 CDN_204) resistor r=24.8333
    rCDN_199 (CDN_194 CDN_212) resistor r=58.3583
    rCDN_198 (CDN_194 CDN_215) resistor r=58.3583
    rCDN_197 (CDN_194 CDN_220) resistor r=14.9
    rCDN_196 (CDN_194 CDN_199) resistor r=4.16253
    rCDN_195 (CDN_194 CDN_207) resistor r=4.16253
    rCDN_194 (CDN_194 CDN_196) resistor r=4.16253
    rCDN_193 (CDN_194 CDN_212) resistor r=4.16253
    rCDN_192 (CDN_194 CDN_220) resistor r=6.30933
    rCDN_191 (CDN_194 CDN_215) resistor r=6.30933
    rCDN_190 (CDN_194 CDN_204) resistor r=1.63969
    rCDN_189 (CDN_194 CDN_199) resistor r=24.8333
    rCDN_188 (CDN_194 CDN_196) resistor r=24.8333
    rCDN_187 (CDN_194 CDN_207) resistor r=24.8333
    rCDN_186 (CDN_194 CDN_204) resistor r=24.8333
    rCDN_185 (CDN_194 CDN_212) resistor r=58.3583
    rCDN_184 (CDN_194 MM0_g) resistor r=22.35
    rCDN_183 (CDN_194 CDN_220) resistor r=14.9
    rCDN_182 (CDN_194 CDN_572) resistor r=39.7333
    rCDN_181 (CDN_194 CDN_199) resistor r=4.16253
    rCDN_180 (CDN_194 CDN_207) resistor r=4.16253
    rCDN_179 (CDN_194 CDN_196) resistor r=4.16253
    rCDN_178 (CDN_194 CDN_212) resistor r=4.16253
    rCDN_177 (CDN_194 CDN_220) resistor r=6.30933
    rCDN_176 (CDN_194 CDN_215) resistor r=6.30933
    rCDN_175 (CDN_194 CDN_204) resistor r=1.63969
    rCDN_174 (CDN_215 MM0_g) resistor r=36.0083
    rCDN_173 (CDN_226 CDN_232) resistor r=58.3583
    rCDN_172 (CDN_226 CDN_232) resistor r=4.16253
    rCDN_171 (CDN_226 CDN_232) resistor r=58.3583
    rCDN_170 (CDN_226 CDN_232) resistor r=4.16253
    rCDN_169 (CDN_229 CDN_232) resistor r=58.3583
    rCDN_168 (CDN_229 CDN_232) resistor r=6.30933
    rCDN_167 (CDN_229 CDN_232) resistor r=58.3583
    rCDN_166 (CDN_229 CDN_232) resistor r=6.30933
    rCDN_165 (CDN_232 CDN_234) resistor r=14.9
    rCDN_164 (CDN_232 CDN_243) resistor r=24.8333
    rCDN_163 (CDN_232 CDN_240) resistor r=24.8333
    rCDN_162 (CDN_232 CDN_251) resistor r=24.8333
    rCDN_161 (CDN_232 CDN_248) resistor r=24.8333
    rCDN_160 (CDN_232 CDN_264) resistor r=58.3583
    rCDN_159 (CDN_232 CDN_267) resistor r=58.3583
    rCDN_158 (CDN_232 CDN_243) resistor r=4.16253
    rCDN_157 (CDN_232 CDN_234) resistor r=6.30933
    rCDN_156 (CDN_232 CDN_251) resistor r=1.63969
    rCDN_155 (CDN_232 CDN_240) resistor r=4.16253
    rCDN_154 (CDN_232 CDN_264) resistor r=4.16253
    rCDN_153 (CDN_232 CDN_248) resistor r=4.16253
    rCDN_152 (CDN_232 CDN_267) resistor r=4.16253
    rCDN_151 (CDN_232 CDN_234) resistor r=14.9
    rCDN_150 (CDN_232 CDN_580) resistor r=39.7333
    rCDN_149 (CDN_232 CDN_243) resistor r=24.8333
    rCDN_148 (CDN_232 CDN_240) resistor r=24.8333
    rCDN_147 (CDN_232 CDN_251) resistor r=24.8333
    rCDN_146 (CDN_232 CDN_248) resistor r=24.8333
    rCDN_145 (CDN_232 CDN_264) resistor r=58.3583
    rCDN_144 (CDN_232 MM1_g) resistor r=7.45
    rCDN_143 (CDN_232 CDN_243) resistor r=4.16253
    rCDN_142 (CDN_232 CDN_234) resistor r=6.30933
    rCDN_141 (CDN_232 CDN_251) resistor r=1.63969
    rCDN_140 (CDN_232 CDN_240) resistor r=4.16253
    rCDN_139 (CDN_232 CDN_264) resistor r=4.16253
    rCDN_138 (CDN_232 CDN_248) resistor r=4.16253
    rCDN_137 (CDN_232 CDN_267) resistor r=4.16253
    rCDN_136 (CDN_256 CDN_262) resistor r=58.3583
    rCDN_135 (CDN_256 CDN_262) resistor r=4.16253
    rCDN_134 (CDN_256 CDN_262) resistor r=58.3583
    rCDN_133 (CDN_256 CDN_262) resistor r=4.16253
    rCDN_132 (CDN_259 CDN_262) resistor r=58.3583
    rCDN_131 (CDN_259 CDN_262) resistor r=4.16253
    rCDN_130 (CDN_259 CDN_262) resistor r=58.3583
    rCDN_129 (CDN_259 CDN_262) resistor r=4.16253
    rCDN_128 (CDN_262 CDN_275) resistor r=8.69167
    rCDN_127 (CDN_262 CDN_272) resistor r=8.69167
    rCDN_126 (CDN_262 CDN_283) resistor r=24.8333
    rCDN_125 (CDN_262 CDN_280) resistor r=24.8333
    rCDN_124 (CDN_262 CDN_288) resistor r=14.9
    rCDN_123 (CDN_262 CDN_297) resistor r=8.69167
    rCDN_122 (CDN_262 CDN_294) resistor r=8.69167
    rCDN_121 (CDN_262 CDN_302) resistor r=58.3583
    rCDN_120 (CDN_262 CDN_305) resistor r=58.3583
    rCDN_119 (CDN_262 CDN_275) resistor r=4.16253
    rCDN_118 (CDN_262 CDN_283) resistor r=4.16253
    rCDN_117 (CDN_262 CDN_297) resistor r=6.30933
    rCDN_116 (CDN_262 CDN_272) resistor r=6.30933
    rCDN_115 (CDN_262 CDN_288) resistor r=1.63969
    rCDN_114 (CDN_262 CDN_294) resistor r=4.16253
    rCDN_113 (CDN_262 CDN_302) resistor r=4.16253
    rCDN_112 (CDN_262 CDN_280) resistor r=4.16253
    rCDN_111 (CDN_262 CDN_305) resistor r=4.16253
    rCDN_110 (CDN_262 CDN_275) resistor r=8.69167
    rCDN_109 (CDN_262 CDN_272) resistor r=8.69167
    rCDN_108 (CDN_262 CDN_283) resistor r=24.8333
    rCDN_107 (CDN_262 CDN_280) resistor r=24.8333
    rCDN_106 (CDN_262 CDN_604) resistor r=330.283
    rCDN_105 (CDN_262 CDN_288) resistor r=14.9
    rCDN_104 (CDN_262 CDN_297) resistor r=8.69167
    rCDN_103 (CDN_262 CDN_294) resistor r=8.69167
    rCDN_102 (CDN_262 CDN_302) resistor r=58.3583
    rCDN_101 (CDN_262 MM11_g) resistor r=7.45
    rCDN_100 (CDN_262 CDN_275) resistor r=4.16253
    rCDN_99 (CDN_262 CDN_283) resistor r=4.16253
    rCDN_98 (CDN_262 CDN_297) resistor r=6.30933
    rCDN_97 (CDN_262 CDN_272) resistor r=6.30933
    rCDN_96 (CDN_262 CDN_288) resistor r=1.63969
    rCDN_95 (CDN_262 CDN_294) resistor r=4.16253
    rCDN_94 (CDN_262 CDN_302) resistor r=4.16253
    rCDN_93 (CDN_262 CDN_280) resistor r=4.16253
    rCDN_92 (CDN_262 CDN_305) resistor r=4.16253
    rCDN_91 (CDN_267 MM1_g) resistor r=50.9083
    rCDN_90 (CDN_305 MM11_g) resistor r=50.9083
    rCDN_89 (CDN_419 CDN_421) resistor r=0.147974
    rCDN_88 (CDN_419 CDN_425) resistor r=0.07651
    rCDN_87 (CDN_421 CDN) resistor r=0.75
    rCDN_86 (CDN_424 CDN_425) resistor r=0.116821
    rCDN_85 (CDN_424 CDN_427) resistor r=0.07651
    rCDN_84 (CDN_426 CDN_427) resistor r=2.51037
    rCDN_83 (CDN_426 CDN_428) resistor r=0.07651
    rCDN_82 (CDN_428 CDN_429) resistor r=0.116821
    rCDN_81 (CDN_429 CDN_433) resistor r=0.038255
    rCDN_80 (CDN_433 CDN_653) resistor r=0.75
    rCDN_79 (CDN_514 CDN_620) resistor r=4.38767
    rCDN_78 (CDN_516 CDN_517) resistor r=27.0909
    rCDN_77 (CDN_516 CDN_623) resistor r=3.71511
    rCDN_76 (CDN_517 CDN_620) resistor r=3.71511
    rCDN_75 (CDN_522 CDN_623) resistor r=4.38767
    rCDN_74 (CDN_530 CDN_531) resistor r=38.6045
    rCDN_73 (CDN_530 CDN_546) resistor r=9.29775
    rCDN_72 (CDN_531 CDN_623) resistor r=3.71511
    rCDN_71 (CDN_572 CDN_636) resistor r=4.38767
    rCDN_70 (CDN_574 CDN_575) resistor r=27.0909
    rCDN_69 (CDN_574 CDN_639) resistor r=3.71511
    rCDN_68 (CDN_575 CDN_636) resistor r=3.71511
    rCDN_67 (CDN_580 CDN_639) resistor r=4.38767
    rCDN_66 (CDN_588 CDN_589) resistor r=38.6045
    rCDN_65 (CDN_588 CDN_604) resistor r=9.29775
    rCDN_64 (CDN_589 CDN_639) resistor r=3.71511
    rCDN_63 (CDN_619 CDN_620) resistor r=3.71511
    rCDN_62 (CDN_619 CDN_648) resistor r=11.5136
    rCDN_61 (CDN_635 CDN_636) resistor r=3.71511
    rCDN_60 (CDN_635 CDN_652) resistor r=11.5136
    rCDN_59 (CDN_648 CDN) resistor r=10
    rCDN_58 (CDN_652 CDN_653) resistor r=10
    rCPN_278 (CPN_42 CPN_48) resistor r=58.3583
    rCPN_277 (CPN_42 CPN_48) resistor r=4.16253
    rCPN_276 (CPN_42 CPN_48) resistor r=58.3583
    rCPN_275 (CPN_42 CPN_48) resistor r=4.16253
    rCPN_274 (CPN_45 CPN_48) resistor r=58.3583
    rCPN_273 (CPN_45 CPN_48) resistor r=6.30933
    rCPN_272 (CPN_45 CPN_48) resistor r=58.3583
    rCPN_271 (CPN_45 CPN_48) resistor r=6.30933
    rCPN_270 (CPN_48 CPN_50) resistor r=14.9
    rCPN_269 (CPN_48 CPN_59) resistor r=24.8333
    rCPN_268 (CPN_48 CPN_56) resistor r=24.8333
    rCPN_267 (CPN_48 CPN_67) resistor r=24.8333
    rCPN_266 (CPN_48 CPN_64) resistor r=24.8333
    rCPN_265 (CPN_48 CPN_72) resistor r=58.3583
    rCPN_264 (CPN_48 CPN_75) resistor r=58.3583
    rCPN_263 (CPN_48 CPN_59) resistor r=4.16253
    rCPN_262 (CPN_48 CPN_50) resistor r=6.30933
    rCPN_261 (CPN_48 CPN_67) resistor r=1.63969
    rCPN_260 (CPN_48 CPN_56) resistor r=4.16253
    rCPN_259 (CPN_48 CPN_72) resistor r=4.16253
    rCPN_258 (CPN_48 CPN_64) resistor r=4.16253
    rCPN_257 (CPN_48 CPN_75) resistor r=4.16253
    rCPN_256 (CPN_48 CPN_50) resistor r=14.9
    rCPN_255 (CPN_48 CPN_368) resistor r=39.7333
    rCPN_254 (CPN_48 CPN_59) resistor r=24.8333
    rCPN_253 (CPN_48 CPN_56) resistor r=24.8333
    rCPN_252 (CPN_48 CPN_67) resistor r=24.8333
    rCPN_251 (CPN_48 CPN_64) resistor r=24.8333
    rCPN_250 (CPN_48 CPN_72) resistor r=58.3583
    rCPN_249 (CPN_48 MM15_ELT_g) resistor r=7.45
    rCPN_248 (CPN_48 CPN_59) resistor r=4.16253
    rCPN_247 (CPN_48 CPN_50) resistor r=6.30933
    rCPN_246 (CPN_48 CPN_67) resistor r=1.63969
    rCPN_245 (CPN_48 CPN_56) resistor r=4.16253
    rCPN_244 (CPN_48 CPN_72) resistor r=4.16253
    rCPN_243 (CPN_48 CPN_64) resistor r=4.16253
    rCPN_242 (CPN_48 CPN_75) resistor r=4.16253
    rCPN_241 (CPN_75 MM15_ELT_g) resistor r=50.9083
    rCPN_240 (CPN_80 CPN_83) resistor r=14.9
    rCPN_239 (CPN_80 CPN_83) resistor r=6.30933
    rCPN_238 (CPN_80 CPN_83) resistor r=14.9
    rCPN_237 (CPN_80 CPN_83) resistor r=6.30933
    rCPN_236 (CPN_83 CPN_86) resistor r=58.3583
    rCPN_235 (CPN_83 CPN_89) resistor r=58.3583
    rCPN_234 (CPN_83 CPN_97) resistor r=24.8333
    rCPN_233 (CPN_83 CPN_94) resistor r=24.8333
    rCPN_232 (CPN_83 CPN_105) resistor r=24.8333
    rCPN_231 (CPN_83 CPN_102) resistor r=24.8333
    rCPN_230 (CPN_83 CPN_110) resistor r=58.3583
    rCPN_229 (CPN_83 CPN_113) resistor r=58.3583
    rCPN_228 (CPN_83 CPN_86) resistor r=6.30933
    rCPN_227 (CPN_83 CPN_97) resistor r=1.63969
    rCPN_226 (CPN_83 CPN_105) resistor r=4.16253
    rCPN_225 (CPN_83 CPN_89) resistor r=4.16253
    rCPN_224 (CPN_83 CPN_94) resistor r=4.16253
    rCPN_223 (CPN_83 CPN_110) resistor r=4.16253
    rCPN_222 (CPN_83 CPN_102) resistor r=4.16253
    rCPN_221 (CPN_83 CPN_113) resistor r=4.16253
    rCPN_220 (CPN_83 CPN_381) resistor r=39.7333
    rCPN_219 (CPN_83 CPN_86) resistor r=58.3583
    rCPN_218 (CPN_83 CPN_89) resistor r=58.3583
    rCPN_217 (CPN_83 CPN_97) resistor r=24.8333
    rCPN_216 (CPN_83 CPN_94) resistor r=24.8333
    rCPN_215 (CPN_83 CPN_105) resistor r=24.8333
    rCPN_214 (CPN_83 CPN_102) resistor r=24.8333
    rCPN_213 (CPN_83 CPN_110) resistor r=58.3583
    rCPN_212 (CPN_83 MM11_ELT_g) resistor r=7.45
    rCPN_211 (CPN_83 CPN_86) resistor r=6.30933
    rCPN_210 (CPN_83 CPN_97) resistor r=1.63969
    rCPN_209 (CPN_83 CPN_105) resistor r=4.16253
    rCPN_208 (CPN_83 CPN_89) resistor r=4.16253
    rCPN_207 (CPN_83 CPN_94) resistor r=4.16253
    rCPN_206 (CPN_83 CPN_110) resistor r=4.16253
    rCPN_205 (CPN_83 CPN_102) resistor r=4.16253
    rCPN_204 (CPN_83 CPN_113) resistor r=4.16253
    rCPN_203 (CPN_113 MM11_ELT_g) resistor r=50.9083
    rCPN_202 (CPN_118 CPN_124) resistor r=58.3583
    rCPN_201 (CPN_118 CPN_124) resistor r=4.16253
    rCPN_200 (CPN_118 CPN_124) resistor r=58.3583
    rCPN_199 (CPN_118 CPN_124) resistor r=4.16253
    rCPN_198 (CPN_121 CPN_124) resistor r=58.3583
    rCPN_197 (CPN_121 CPN_124) resistor r=6.30933
    rCPN_196 (CPN_121 CPN_124) resistor r=58.3583
    rCPN_195 (CPN_121 CPN_124) resistor r=6.30933
    rCPN_194 (CPN_124 CPN_126) resistor r=14.9
    rCPN_193 (CPN_124 CPN_135) resistor r=24.8333
    rCPN_192 (CPN_124 CPN_132) resistor r=24.8333
    rCPN_191 (CPN_124 CPN_143) resistor r=24.8333
    rCPN_190 (CPN_124 CPN_140) resistor r=24.8333
    rCPN_189 (CPN_124 CPN_148) resistor r=58.3583
    rCPN_188 (CPN_124 CPN_151) resistor r=58.3583
    rCPN_187 (CPN_124 CPN_135) resistor r=4.16253
    rCPN_186 (CPN_124 CPN_126) resistor r=6.30933
    rCPN_185 (CPN_124 CPN_143) resistor r=1.63969
    rCPN_184 (CPN_124 CPN_132) resistor r=4.16253
    rCPN_183 (CPN_124 CPN_148) resistor r=4.16253
    rCPN_182 (CPN_124 CPN_140) resistor r=4.16253
    rCPN_181 (CPN_124 CPN_151) resistor r=4.16253
    rCPN_180 (CPN_124 CPN_126) resistor r=14.9
    rCPN_179 (CPN_124 CPN_406) resistor r=40.975
    rCPN_178 (CPN_124 CPN_135) resistor r=24.8333
    rCPN_177 (CPN_124 CPN_132) resistor r=24.8333
    rCPN_176 (CPN_124 CPN_143) resistor r=24.8333
    rCPN_175 (CPN_124 CPN_140) resistor r=24.8333
    rCPN_174 (CPN_124 CPN_148) resistor r=58.3583
    rCPN_173 (CPN_124 MM5_g) resistor r=7.45
    rCPN_172 (CPN_124 CPN_135) resistor r=4.16253
    rCPN_171 (CPN_124 CPN_126) resistor r=6.30933
    rCPN_170 (CPN_124 CPN_143) resistor r=1.63969
    rCPN_169 (CPN_124 CPN_132) resistor r=4.16253
    rCPN_168 (CPN_124 CPN_148) resistor r=4.16253
    rCPN_167 (CPN_124 CPN_140) resistor r=4.16253
    rCPN_166 (CPN_124 CPN_151) resistor r=4.16253
    rCPN_165 (CPN_151 MM5_g) resistor r=50.9083
    rCPN_164 (CPN_156 CPN_162) resistor r=58.3583
    rCPN_163 (CPN_156 CPN_162) resistor r=4.16253
    rCPN_162 (CPN_156 CPN_162) resistor r=58.3583
    rCPN_161 (CPN_156 CPN_162) resistor r=4.16253
    rCPN_160 (CPN_159 CPN_162) resistor r=58.3583
    rCPN_159 (CPN_159 CPN_162) resistor r=4.16253
    rCPN_158 (CPN_159 CPN_162) resistor r=58.3583
    rCPN_157 (CPN_159 CPN_162) resistor r=4.16253
    rCPN_156 (CPN_162 CPN_167) resistor r=24.8333
    rCPN_155 (CPN_162 CPN_164) resistor r=24.8333
    rCPN_154 (CPN_162 CPN_175) resistor r=24.8333
    rCPN_153 (CPN_162 CPN_172) resistor r=24.8333
    rCPN_152 (CPN_162 CPN_180) resistor r=14.9
    rCPN_151 (CPN_162 CPN_186) resistor r=58.3583
    rCPN_150 (CPN_162 CPN_189) resistor r=58.3583
    rCPN_149 (CPN_162 CPN_167) resistor r=4.16253
    rCPN_148 (CPN_162 CPN_175) resistor r=4.16253
    rCPN_147 (CPN_162 CPN_186) resistor r=6.30933
    rCPN_146 (CPN_162 CPN_180) resistor r=6.30933
    rCPN_145 (CPN_162 CPN_164) resistor r=1.63969
    rCPN_144 (CPN_162 CPN_172) resistor r=4.16253
    rCPN_143 (CPN_162 CPN_189) resistor r=4.16253
    rCPN_142 (CPN_162 CPN_167) resistor r=24.8333
    rCPN_141 (CPN_162 CPN_164) resistor r=24.8333
    rCPN_140 (CPN_162 CPN_175) resistor r=24.8333
    rCPN_139 (CPN_162 CPN_172) resistor r=24.8333
    rCPN_138 (CPN_162 CPN_428) resistor r=47.1833
    rCPN_137 (CPN_162 CPN_180) resistor r=14.9
    rCPN_136 (CPN_162 CPN_186) resistor r=58.3583
    rCPN_135 (CPN_162 MM8_g) resistor r=7.45
    rCPN_134 (CPN_162 CPN_167) resistor r=4.16253
    rCPN_133 (CPN_162 CPN_175) resistor r=4.16253
    rCPN_132 (CPN_162 CPN_186) resistor r=6.30933
    rCPN_131 (CPN_162 CPN_180) resistor r=6.30933
    rCPN_130 (CPN_162 CPN_164) resistor r=1.63969
    rCPN_129 (CPN_162 CPN_172) resistor r=4.16253
    rCPN_128 (CPN_162 CPN_189) resistor r=4.16253
    rCPN_127 (CPN_189 MM8_g) resistor r=50.9083
    rCPN_126 (CPN_261 CPN_264) resistor r=0.191905
    rCPN_125 (CPN_261 CPN_277) resistor r=0.0961177
    rCPN_124 (CPN_262 CPN_264) resistor r=0.399802
    rCPN_123 (CPN_262 CPN_279) resistor r=0.0961177
    rCPN_122 (CPN_264 CPN_265) resistor r=13
    rCPN_121 (CPN_265 MM0_ELT_d) resistor r=8.44
    rCPN_120 (CPN_266 CPN_269) resistor r=0.399802
    rCPN_119 (CPN_266 CPN_281) resistor r=0.0961177
    rCPN_118 (CPN_267 CPN_269) resistor r=0.362487
    rCPN_117 (CPN_267 CPN_298) resistor r=0.0695714
    rCPN_116 (CPN_269 CPN_270) resistor r=8.66667
    rCPN_115 (CPN_270 MM1_ELT_d) resistor r=32.3614
    rCPN_114 (CPN_273 CPN_274) resistor r=26
    rCPN_113 (CPN_273 CPN_300) resistor r=0.298519
    rCPN_112 (CPN_274 CPN_482) resistor r=32.3614
    rCPN_111 (CPN_276 CPN_277) resistor r=1.40788
    rCPN_110 (CPN_276 CPN_289) resistor r=0.0961177
    rCPN_109 (CPN_278 CPN_279) resistor r=0.219556
    rCPN_108 (CPN_278 CPN_287) resistor r=0.0961177
    rCPN_107 (CPN_280 CPN_281) resistor r=0.189092
    rCPN_106 (CPN_280 CPN_288) resistor r=0.0961177
    rCPN_105 (CPN_282 CPN_284) resistor r=0.346553
    rCPN_104 (CPN_282 CPN_298) resistor r=0.0217125
    rCPN_103 (CPN_284 CPN_285) resistor r=10
    rCPN_102 (CPN_285 CPN_440) resistor r=22.35
    rCPN_101 (CPN_287 CPN_288) resistor r=0.838494
    rCPN_100 (CPN_289 CPN_290) resistor r=0.649632
    rCPN_99 (CPN_290 CPN_292) resistor r=0.0961177
    rCPN_98 (CPN_291 CPN_292) resistor r=0.547585
    rCPN_97 (CPN_291 CPN_293) resistor r=0.0961177
    rCPN_96 (CPN_293 CPN_294) resistor r=0.179155
    rCPN_95 (CPN_294 CPN_302) resistor r=0.0480588
    rCPN_94 (CPN_298 CPN_307) resistor r=0.0695714
    rCPN_93 (CPN_299 CPN_300) resistor r=0.052801
    rCPN_92 (CPN_299 CPN) resistor r=0.0726051
    rCPN_91 (CPN_302 CPN_303) resistor r=10
    rCPN_90 (CPN_303 CPN_443) resistor r=5.41818
    rCPN_89 (CPN_304 CPN_306) resistor r=0.147974
    rCPN_88 (CPN_304 CPN_310) resistor r=0.07651
    rCPN_87 (CPN_306 CPN_307) resistor r=0.75
    rCPN_86 (CPN_307 CPN) resistor r=0.176327
    rCPN_85 (CPN_309 CPN_310) resistor r=2.68504
    rCPN_84 (CPN_309 CPN_317) resistor r=0.07651
    rCPN_83 (CPN_311 CPN_313) resistor r=0.47948
    rCPN_82 (CPN_311 CPN_323) resistor r=0.0579848
    rCPN_81 (CPN_313 CPN_314) resistor r=0.75
    rCPN_80 (CPN_314 CPN_465) resistor r=10
    rCPN_79 (CPN_316 CPN_317) resistor r=0.147974
    rCPN_78 (CPN_316 CPN_323) resistor r=0.0579848
    rCPN_77 (CPN_318 CPN_320) resistor r=0.864478
    rCPN_76 (CPN_318 CPN_323) resistor r=0.0150692
    rCPN_75 (CPN_320 CPN_321) resistor r=0.75
    rCPN_74 (CPN_321 CPN_469) resistor r=10
    rCPN_73 (CPN_368 CPN_440) resistor r=9.29775
    rCPN_72 (CPN_381 CPN_444) resistor r=4.38767
    rCPN_71 (CPN_400 CPN_401) resistor r=29.8
    rCPN_70 (CPN_400 CPN_406) resistor r=9.29775
    rCPN_69 (CPN_401 CPN_449) resistor r=8.32506
    rCPN_68 (CPN_428 CPN_457) resistor r=4.38767
    rCPN_67 (CPN_443 CPN_444) resistor r=3.71511
    rCPN_66 (CPN_449 CPN_465) resistor r=62.9864
    rCPN_65 (CPN_456 CPN_457) resistor r=3.71511
    rCPN_64 (CPN_456 CPN_469) resistor r=14.9
    rCPN_63 (MM1_ELT_d CPN_482) resistor r=16.1807
    rCPN_62 (CPN_482 CPN) resistor r=8.66667
    rnet49_20 (MM14_ELT_d net49) resistor r=0.01
    rnet49_19 (net49_1 net49_3) resistor r=0.447778
    rnet49_18 (net49_1 net49_13) resistor r=0.0101031
    rnet49_17 (net49_3 net49_4) resistor r=13
    rnet49_16 (net49_4 MM15_ELT_s) resistor r=8.09035
    rnet49_15 (net49_6 net49_8) resistor r=0.266535
    rnet49_14 (net49_6 net49_17) resistor r=0.0101031
    rnet49_13 (net49_8 net49_9) resistor r=13
    rnet49_12 (net49_9 net49) resistor r=8.09035
    rnet49_11 (net49_11 net49_12) resistor r=0.402229
    rnet49_10 (net49_11 net49_15) resistor r=0.0101031
    rnet49_9 (net49_12 net49_19) resistor r=0.0101031
    rnet49_8 (net49_13 net49_15) resistor r=0.0927396
    rnet49_7 (net49_17 net49_19) resistor r=0.0927396
    rD_103 (D_22 D_28) resistor r=58.3583
    rD_102 (D_22 D_28) resistor r=4.16253
    rD_101 (D_22 D_28) resistor r=58.3583
    rD_100 (D_22 D_28) resistor r=4.16253
    rD_99 (D_25 D_28) resistor r=58.3583
    rD_98 (D_25 D_28) resistor r=4.16253
    rD_97 (D_25 D_28) resistor r=58.3583
    rD_96 (D_25 D_28) resistor r=4.16253
    rD_95 (D_28 D_33) resistor r=24.8333
    rD_94 (D_28 D_30) resistor r=24.8333
    rD_93 (D_28 D_41) resistor r=24.8333
    rD_92 (D_28 D_38) resistor r=24.8333
    rD_91 (D_28 D_46) resistor r=14.9
    rD_90 (D_28 D_52) resistor r=58.3583
    rD_89 (D_28 D_55) resistor r=58.3583
    rD_88 (D_28 D_33) resistor r=4.16253
    rD_87 (D_28 D_41) resistor r=4.16253
    rD_86 (D_28 D_52) resistor r=6.30933
    rD_85 (D_28 D_46) resistor r=6.30933
    rD_84 (D_28 D_30) resistor r=1.63969
    rD_83 (D_28 D_38) resistor r=4.16253
    rD_82 (D_28 D_55) resistor r=4.16253
    rD_81 (D_28 D_33) resistor r=24.8333
    rD_80 (D_28 D_30) resistor r=24.8333
    rD_79 (D_28 D_41) resistor r=24.8333
    rD_78 (D_28 D_38) resistor r=24.8333
    rD_77 (D_28 D_167) resistor r=47.1833
    rD_76 (D_28 D_46) resistor r=14.9
    rD_75 (D_28 D_52) resistor r=58.3583
    rD_74 (D_28 MM14_ELT_g) resistor r=7.45
    rD_73 (D_28 D_33) resistor r=4.16253
    rD_72 (D_28 D_41) resistor r=4.16253
    rD_71 (D_28 D_52) resistor r=6.30933
    rD_70 (D_28 D_46) resistor r=6.30933
    rD_69 (D_28 D_30) resistor r=1.63969
    rD_68 (D_28 D_38) resistor r=4.16253
    rD_67 (D_28 D_55) resistor r=4.16253
    rD_66 (D_55 MM14_ELT_g) resistor r=50.9083
    rD_65 (D_60 D_66) resistor r=58.3583
    rD_64 (D_60 D_66) resistor r=4.16253
    rD_63 (D_60 D_66) resistor r=58.3583
    rD_62 (D_60 D_66) resistor r=4.16253
    rD_61 (D_63 D_66) resistor r=58.3583
    rD_60 (D_63 D_66) resistor r=6.30933
    rD_59 (D_63 D_66) resistor r=58.3583
    rD_58 (D_63 D_66) resistor r=6.30933
    rD_57 (D_66 D_68) resistor r=14.9
    rD_56 (D_66 D_77) resistor r=24.8333
    rD_55 (D_66 D_74) resistor r=24.8333
    rD_54 (D_66 D_85) resistor r=24.8333
    rD_53 (D_66 D_82) resistor r=24.8333
    rD_52 (D_66 D_90) resistor r=58.3583
    rD_51 (D_66 D_93) resistor r=58.3583
    rD_50 (D_66 D_77) resistor r=4.16253
    rD_49 (D_66 D_68) resistor r=6.30933
    rD_48 (D_66 D_85) resistor r=1.63969
    rD_47 (D_66 D_74) resistor r=4.16253
    rD_46 (D_66 D_90) resistor r=4.16253
    rD_45 (D_66 D_82) resistor r=4.16253
    rD_44 (D_66 D_93) resistor r=4.16253
    rD_43 (D_66 D_68) resistor r=14.9
    rD_42 (D_66 D_181) resistor r=39.7333
    rD_41 (D_66 D_77) resistor r=24.8333
    rD_40 (D_66 D_74) resistor r=24.8333
    rD_39 (D_66 D_85) resistor r=24.8333
    rD_38 (D_66 D_82) resistor r=24.8333
    rD_37 (D_66 D_90) resistor r=58.3583
    rD_36 (D_66 MM17_ELT_g) resistor r=7.45
    rD_35 (D_66 D_77) resistor r=4.16253
    rD_34 (D_66 D_68) resistor r=6.30933
    rD_33 (D_66 D_85) resistor r=1.63969
    rD_32 (D_66 D_74) resistor r=4.16253
    rD_31 (D_66 D_90) resistor r=4.16253
    rD_30 (D_66 D_82) resistor r=4.16253
    rD_29 (D_66 D_93) resistor r=4.16253
    rD_28 (D_93 MM17_ELT_g) resistor r=50.9083
    rD_27 (D_132 D_133) resistor r=10
    rD_26 (D_132 D) resistor r=0.0866308
    rD_25 (D_133 D_202) resistor r=34.5409
    rD_24 (D_167 D_176) resistor r=9.29775
    rD_23 (D_175 D_176) resistor r=22.35
    rD_22 (D_175 D_184) resistor r=9.29775
    rD_21 (D_181 D_203) resistor r=10.0997
    rD_20 (D_183 D_184) resistor r=255.783
    rD_19 (D_183 D_203) resistor r=10.0997
    rD_18 (D_202 D_203) resistor r=0.877078
    rCPNN_358 (MM28_ELT_d CPNN) resistor r=0.01
    rCPNN_357 (CPNN_62 CPNN_68) resistor r=58.3583
    rCPNN_356 (CPNN_62 CPNN_68) resistor r=4.16253
    rCPNN_355 (CPNN_62 CPNN_68) resistor r=58.3583
    rCPNN_354 (CPNN_62 CPNN_68) resistor r=4.16253
    rCPNN_353 (CPNN_65 CPNN_68) resistor r=58.3583
    rCPNN_352 (CPNN_65 CPNN_68) resistor r=6.30933
    rCPNN_351 (CPNN_65 CPNN_68) resistor r=58.3583
    rCPNN_350 (CPNN_65 CPNN_68) resistor r=6.30933
    rCPNN_349 (CPNN_68 CPNN_70) resistor r=14.9
    rCPNN_348 (CPNN_68 CPNN_93) resistor r=24.8333
    rCPNN_347 (CPNN_68 CPNN_90) resistor r=24.8333
    rCPNN_346 (CPNN_68 CPNN_101) resistor r=24.8333
    rCPNN_345 (CPNN_68 CPNN_98) resistor r=24.8333
    rCPNN_344 (CPNN_68 CPNN_122) resistor r=58.3583
    rCPNN_343 (CPNN_68 CPNN_125) resistor r=58.3583
    rCPNN_342 (CPNN_68 CPNN_93) resistor r=4.16253
    rCPNN_341 (CPNN_68 CPNN_70) resistor r=6.30933
    rCPNN_340 (CPNN_68 CPNN_101) resistor r=1.63969
    rCPNN_339 (CPNN_68 CPNN_90) resistor r=4.16253
    rCPNN_338 (CPNN_68 CPNN_122) resistor r=4.16253
    rCPNN_337 (CPNN_68 CPNN_98) resistor r=4.16253
    rCPNN_336 (CPNN_68 CPNN_125) resistor r=4.16253
    rCPNN_335 (CPNN_68 CPNN_70) resistor r=14.9
    rCPNN_334 (CPNN_68 CPNN_512) resistor r=40.975
    rCPNN_333 (CPNN_68 CPNN_93) resistor r=24.8333
    rCPNN_332 (CPNN_68 CPNN_90) resistor r=24.8333
    rCPNN_331 (CPNN_68 CPNN_101) resistor r=24.8333
    rCPNN_330 (CPNN_68 CPNN_98) resistor r=24.8333
    rCPNN_329 (CPNN_68 CPNN_122) resistor r=58.3583
    rCPNN_328 (CPNN_68 MM0_ELT_g) resistor r=7.45
    rCPNN_327 (CPNN_68 CPNN_93) resistor r=4.16253
    rCPNN_326 (CPNN_68 CPNN_70) resistor r=6.30933
    rCPNN_325 (CPNN_68 CPNN_101) resistor r=1.63969
    rCPNN_324 (CPNN_68 CPNN_90) resistor r=4.16253
    rCPNN_323 (CPNN_68 CPNN_122) resistor r=4.16253
    rCPNN_322 (CPNN_68 CPNN_98) resistor r=4.16253
    rCPNN_321 (CPNN_68 CPNN_125) resistor r=4.16253
    rCPNN_320 (CPNN_76 CPNN_79) resistor r=14.9
    rCPNN_319 (CPNN_76 CPNN_79) resistor r=6.30933
    rCPNN_318 (CPNN_76 CPNN_79) resistor r=14.9
    rCPNN_317 (CPNN_76 CPNN_79) resistor r=6.30933
    rCPNN_316 (CPNN_79 CPNN_82) resistor r=202.392
    rCPNN_315 (CPNN_79 CPNN_85) resistor r=202.392
    rCPNN_314 (CPNN_79 CPNN_109) resistor r=24.8333
    rCPNN_313 (CPNN_79 CPNN_106) resistor r=24.8333
    rCPNN_312 (CPNN_79 CPNN_117) resistor r=24.8333
    rCPNN_311 (CPNN_79 CPNN_114) resistor r=24.8333
    rCPNN_310 (CPNN_79 CPNN_130) resistor r=202.392
    rCPNN_309 (CPNN_79 CPNN_133) resistor r=202.392
    rCPNN_308 (CPNN_79 CPNN_82) resistor r=6.30933
    rCPNN_307 (CPNN_79 CPNN_109) resistor r=1.63969
    rCPNN_306 (CPNN_79 CPNN_117) resistor r=4.16253
    rCPNN_305 (CPNN_79 CPNN_85) resistor r=4.16253
    rCPNN_304 (CPNN_79 CPNN_106) resistor r=4.16253
    rCPNN_303 (CPNN_79 CPNN_130) resistor r=4.16253
    rCPNN_302 (CPNN_79 CPNN_114) resistor r=4.16253
    rCPNN_301 (CPNN_79 CPNN_133) resistor r=4.16253
    rCPNN_300 (CPNN_79 CPNN_514) resistor r=40.975
    rCPNN_299 (CPNN_79 CPNN_82) resistor r=202.392
    rCPNN_298 (CPNN_79 CPNN_85) resistor r=202.392
    rCPNN_297 (CPNN_79 CPNN_109) resistor r=24.8333
    rCPNN_296 (CPNN_79 CPNN_106) resistor r=24.8333
    rCPNN_295 (CPNN_79 CPNN_117) resistor r=24.8333
    rCPNN_294 (CPNN_79 CPNN_114) resistor r=24.8333
    rCPNN_293 (CPNN_79 CPNN_130) resistor r=202.392
    rCPNN_292 (CPNN_79 MM1_ELT_g) resistor r=7.45
    rCPNN_291 (CPNN_79 CPNN_82) resistor r=6.30933
    rCPNN_290 (CPNN_79 CPNN_109) resistor r=1.63969
    rCPNN_289 (CPNN_79 CPNN_117) resistor r=4.16253
    rCPNN_288 (CPNN_79 CPNN_85) resistor r=4.16253
    rCPNN_287 (CPNN_79 CPNN_106) resistor r=4.16253
    rCPNN_286 (CPNN_79 CPNN_130) resistor r=4.16253
    rCPNN_285 (CPNN_79 CPNN_114) resistor r=4.16253
    rCPNN_284 (CPNN_79 CPNN_133) resistor r=4.16253
    rCPNN_283 (CPNN_125 MM0_ELT_g) resistor r=50.9083
    rCPNN_282 (CPNN_133 MM1_ELT_g) resistor r=194.942
    rCPNN_281 (CPNN_138 CPNN_144) resistor r=58.3583
    rCPNN_280 (CPNN_138 CPNN_144) resistor r=4.16253
    rCPNN_279 (CPNN_138 CPNN_144) resistor r=58.3583
    rCPNN_278 (CPNN_138 CPNN_144) resistor r=4.16253
    rCPNN_277 (CPNN_141 CPNN_144) resistor r=58.3583
    rCPNN_276 (CPNN_141 CPNN_144) resistor r=6.30933
    rCPNN_275 (CPNN_141 CPNN_144) resistor r=58.3583
    rCPNN_274 (CPNN_141 CPNN_144) resistor r=6.30933
    rCPNN_273 (CPNN_144 CPNN_146) resistor r=14.9
    rCPNN_272 (CPNN_144 CPNN_155) resistor r=24.8333
    rCPNN_271 (CPNN_144 CPNN_152) resistor r=24.8333
    rCPNN_270 (CPNN_144 CPNN_163) resistor r=24.8333
    rCPNN_269 (CPNN_144 CPNN_160) resistor r=24.8333
    rCPNN_268 (CPNN_144 CPNN_168) resistor r=58.3583
    rCPNN_267 (CPNN_144 CPNN_171) resistor r=58.3583
    rCPNN_266 (CPNN_144 CPNN_155) resistor r=4.16253
    rCPNN_265 (CPNN_144 CPNN_146) resistor r=6.30933
    rCPNN_264 (CPNN_144 CPNN_163) resistor r=1.63969
    rCPNN_263 (CPNN_144 CPNN_152) resistor r=4.16253
    rCPNN_262 (CPNN_144 CPNN_168) resistor r=4.16253
    rCPNN_261 (CPNN_144 CPNN_160) resistor r=4.16253
    rCPNN_260 (CPNN_144 CPNN_171) resistor r=4.16253
    rCPNN_259 (CPNN_144 CPNN_146) resistor r=14.9
    rCPNN_258 (CPNN_144 CPNN_548) resistor r=40.975
    rCPNN_257 (CPNN_144 CPNN_155) resistor r=24.8333
    rCPNN_256 (CPNN_144 CPNN_152) resistor r=24.8333
    rCPNN_255 (CPNN_144 CPNN_163) resistor r=24.8333
    rCPNN_254 (CPNN_144 CPNN_160) resistor r=24.8333
    rCPNN_253 (CPNN_144 CPNN_168) resistor r=58.3583
    rCPNN_252 (CPNN_144 MM16_ELT_g) resistor r=7.45
    rCPNN_251 (CPNN_144 CPNN_155) resistor r=4.16253
    rCPNN_250 (CPNN_144 CPNN_146) resistor r=6.30933
    rCPNN_249 (CPNN_144 CPNN_163) resistor r=1.63969
    rCPNN_248 (CPNN_144 CPNN_152) resistor r=4.16253
    rCPNN_247 (CPNN_144 CPNN_168) resistor r=4.16253
    rCPNN_246 (CPNN_144 CPNN_160) resistor r=4.16253
    rCPNN_245 (CPNN_144 CPNN_171) resistor r=4.16253
    rCPNN_244 (CPNN_171 MM16_ELT_g) resistor r=50.9083
    rCPNN_243 (CPNN_176 CPNN_182) resistor r=58.3583
    rCPNN_242 (CPNN_176 CPNN_182) resistor r=4.16253
    rCPNN_241 (CPNN_176 CPNN_182) resistor r=58.3583
    rCPNN_240 (CPNN_176 CPNN_182) resistor r=4.16253
    rCPNN_239 (CPNN_179 CPNN_182) resistor r=58.3583
    rCPNN_238 (CPNN_179 CPNN_182) resistor r=4.16253
    rCPNN_237 (CPNN_179 CPNN_182) resistor r=58.3583
    rCPNN_236 (CPNN_179 CPNN_182) resistor r=4.16253
    rCPNN_235 (CPNN_182 CPNN_187) resistor r=24.8333
    rCPNN_234 (CPNN_182 CPNN_184) resistor r=24.8333
    rCPNN_233 (CPNN_182 CPNN_195) resistor r=24.8333
    rCPNN_232 (CPNN_182 CPNN_192) resistor r=24.8333
    rCPNN_231 (CPNN_182 CPNN_200) resistor r=14.9
    rCPNN_230 (CPNN_182 CPNN_206) resistor r=58.3583
    rCPNN_229 (CPNN_182 CPNN_209) resistor r=58.3583
    rCPNN_228 (CPNN_182 CPNN_187) resistor r=4.16253
    rCPNN_227 (CPNN_182 CPNN_195) resistor r=4.16253
    rCPNN_226 (CPNN_182 CPNN_206) resistor r=6.30933
    rCPNN_225 (CPNN_182 CPNN_200) resistor r=6.30933
    rCPNN_224 (CPNN_182 CPNN_184) resistor r=1.63969
    rCPNN_223 (CPNN_182 CPNN_192) resistor r=4.16253
    rCPNN_222 (CPNN_182 CPNN_209) resistor r=4.16253
    rCPNN_221 (CPNN_182 CPNN_187) resistor r=24.8333
    rCPNN_220 (CPNN_182 CPNN_184) resistor r=24.8333
    rCPNN_219 (CPNN_182 CPNN_195) resistor r=24.8333
    rCPNN_218 (CPNN_182 CPNN_192) resistor r=24.8333
    rCPNN_217 (CPNN_182 CPNN_570) resistor r=47.1833
    rCPNN_216 (CPNN_182 CPNN_200) resistor r=14.9
    rCPNN_215 (CPNN_182 CPNN_206) resistor r=58.3583
    rCPNN_214 (CPNN_182 MM10_ELT_g) resistor r=7.45
    rCPNN_213 (CPNN_182 CPNN_187) resistor r=4.16253
    rCPNN_212 (CPNN_182 CPNN_195) resistor r=4.16253
    rCPNN_211 (CPNN_182 CPNN_206) resistor r=6.30933
    rCPNN_210 (CPNN_182 CPNN_200) resistor r=6.30933
    rCPNN_209 (CPNN_182 CPNN_184) resistor r=1.63969
    rCPNN_208 (CPNN_182 CPNN_192) resistor r=4.16253
    rCPNN_207 (CPNN_182 CPNN_209) resistor r=4.16253
    rCPNN_206 (CPNN_209 MM10_ELT_g) resistor r=50.9083
    rCPNN_205 (CPNN_214 CPNN_220) resistor r=58.3583
    rCPNN_204 (CPNN_214 CPNN_220) resistor r=4.16253
    rCPNN_203 (CPNN_214 CPNN_220) resistor r=58.3583
    rCPNN_202 (CPNN_214 CPNN_220) resistor r=4.16253
    rCPNN_201 (CPNN_217 CPNN_220) resistor r=58.3583
    rCPNN_200 (CPNN_217 CPNN_220) resistor r=6.30933
    rCPNN_199 (CPNN_217 CPNN_220) resistor r=58.3583
    rCPNN_198 (CPNN_217 CPNN_220) resistor r=6.30933
    rCPNN_197 (CPNN_220 CPNN_222) resistor r=14.9
    rCPNN_196 (CPNN_220 CPNN_231) resistor r=24.8333
    rCPNN_195 (CPNN_220 CPNN_228) resistor r=24.8333
    rCPNN_194 (CPNN_220 CPNN_239) resistor r=24.8333
    rCPNN_193 (CPNN_220 CPNN_236) resistor r=24.8333
    rCPNN_192 (CPNN_220 CPNN_244) resistor r=58.3583
    rCPNN_191 (CPNN_220 CPNN_247) resistor r=58.3583
    rCPNN_190 (CPNN_220 CPNN_231) resistor r=4.16253
    rCPNN_189 (CPNN_220 CPNN_222) resistor r=6.30933
    rCPNN_188 (CPNN_220 CPNN_239) resistor r=1.63969
    rCPNN_187 (CPNN_220 CPNN_228) resistor r=4.16253
    rCPNN_186 (CPNN_220 CPNN_244) resistor r=4.16253
    rCPNN_185 (CPNN_220 CPNN_236) resistor r=4.16253
    rCPNN_184 (CPNN_220 CPNN_247) resistor r=4.16253
    rCPNN_183 (CPNN_220 CPNN_222) resistor r=14.9
    rCPNN_182 (CPNN_220 CPNN_584) resistor r=39.7333
    rCPNN_181 (CPNN_220 CPNN_231) resistor r=24.8333
    rCPNN_180 (CPNN_220 CPNN_228) resistor r=24.8333
    rCPNN_179 (CPNN_220 CPNN_239) resistor r=24.8333
    rCPNN_178 (CPNN_220 CPNN_236) resistor r=24.8333
    rCPNN_177 (CPNN_220 CPNN_244) resistor r=58.3583
    rCPNN_176 (CPNN_220 MM7_g) resistor r=7.45
    rCPNN_175 (CPNN_220 CPNN_231) resistor r=4.16253
    rCPNN_174 (CPNN_220 CPNN_222) resistor r=6.30933
    rCPNN_173 (CPNN_220 CPNN_239) resistor r=1.63969
    rCPNN_172 (CPNN_220 CPNN_228) resistor r=4.16253
    rCPNN_171 (CPNN_220 CPNN_244) resistor r=4.16253
    rCPNN_170 (CPNN_220 CPNN_236) resistor r=4.16253
    rCPNN_169 (CPNN_220 CPNN_247) resistor r=4.16253
    rCPNN_168 (CPNN_247 MM7_g) resistor r=50.9083
    rCPNN_167 (CPNN_252 CPNN_255) resistor r=14.9
    rCPNN_166 (CPNN_252 CPNN_255) resistor r=6.30933
    rCPNN_165 (CPNN_252 CPNN_255) resistor r=14.9
    rCPNN_164 (CPNN_252 CPNN_255) resistor r=6.30933
    rCPNN_163 (CPNN_255 CPNN_258) resistor r=58.3583
    rCPNN_162 (CPNN_255 CPNN_261) resistor r=58.3583
    rCPNN_161 (CPNN_255 CPNN_269) resistor r=24.8333
    rCPNN_160 (CPNN_255 CPNN_266) resistor r=24.8333
    rCPNN_159 (CPNN_255 CPNN_277) resistor r=24.8333
    rCPNN_158 (CPNN_255 CPNN_274) resistor r=24.8333
    rCPNN_157 (CPNN_255 CPNN_282) resistor r=58.3583
    rCPNN_156 (CPNN_255 CPNN_285) resistor r=58.3583
    rCPNN_155 (CPNN_255 CPNN_258) resistor r=6.30933
    rCPNN_154 (CPNN_255 CPNN_269) resistor r=1.63969
    rCPNN_153 (CPNN_255 CPNN_277) resistor r=4.16253
    rCPNN_152 (CPNN_255 CPNN_261) resistor r=4.16253
    rCPNN_151 (CPNN_255 CPNN_266) resistor r=4.16253
    rCPNN_150 (CPNN_255 CPNN_282) resistor r=4.16253
    rCPNN_149 (CPNN_255 CPNN_274) resistor r=4.16253
    rCPNN_148 (CPNN_255 CPNN_285) resistor r=4.16253
    rCPNN_147 (CPNN_255 CPNN_597) resistor r=39.7333
    rCPNN_146 (CPNN_255 CPNN_258) resistor r=58.3583
    rCPNN_145 (CPNN_255 CPNN_261) resistor r=58.3583
    rCPNN_144 (CPNN_255 CPNN_269) resistor r=24.8333
    rCPNN_143 (CPNN_255 CPNN_266) resistor r=24.8333
    rCPNN_142 (CPNN_255 CPNN_277) resistor r=24.8333
    rCPNN_141 (CPNN_255 CPNN_274) resistor r=24.8333
    rCPNN_140 (CPNN_255 CPNN_282) resistor r=58.3583
    rCPNN_139 (CPNN_255 MM6_g) resistor r=7.45
    rCPNN_138 (CPNN_255 CPNN_258) resistor r=6.30933
    rCPNN_137 (CPNN_255 CPNN_269) resistor r=1.63969
    rCPNN_136 (CPNN_255 CPNN_277) resistor r=4.16253
    rCPNN_135 (CPNN_255 CPNN_261) resistor r=4.16253
    rCPNN_134 (CPNN_255 CPNN_266) resistor r=4.16253
    rCPNN_133 (CPNN_255 CPNN_282) resistor r=4.16253
    rCPNN_132 (CPNN_255 CPNN_274) resistor r=4.16253
    rCPNN_131 (CPNN_255 CPNN_285) resistor r=4.16253
    rCPNN_130 (CPNN_285 MM6_g) resistor r=50.9083
    rCPNN_129 (CPNN_391 CPNN_393) resistor r=0.399802
    rCPNN_128 (CPNN_391 CPNN_408) resistor r=0.0961177
    rCPNN_127 (CPNN_393 CPNN_394) resistor r=13
    rCPNN_126 (CPNN_394 MM29_ELT_d) resistor r=8.44
    rCPNN_125 (CPNN_396 CPNN_398) resistor r=0.399802
    rCPNN_124 (CPNN_396 CPNN_410) resistor r=0.0961177
    rCPNN_123 (CPNN_398 CPNN_399) resistor r=8.66667
    rCPNN_122 (CPNN_398 CPNN_401) resistor r=0.639683
    rCPNN_121 (CPNN_399 CPNN) resistor r=32.3614
    rCPNN_120 (CPNN_401 CPNN_402) resistor r=8.66667
    rCPNN_119 (CPNN_401 CPNN_404) resistor r=0.426455
    rCPNN_118 (CPNN_402 CPNN) resistor r=16.1807
    rCPNN_117 (CPNN_402 CPNN_405) resistor r=32.3614
    rCPNN_116 (CPNN_404 CPNN_405) resistor r=26
    rCPNN_115 (CPNN_407 CPNN_408) resistor r=0.346999
    rCPNN_114 (CPNN_407 CPNN_411) resistor r=0.0964644
    rCPNN_113 (CPNN_409 CPNN_410) resistor r=0.28997
    rCPNN_112 (CPNN_409 CPNN_414) resistor r=0.0964644
    rCPNN_111 (CPNN_411 CPNN_412) resistor r=0.11982
    rCPNN_110 (CPNN_412 CPNN_423) resistor r=0.110255
    rCPNN_109 (CPNN_413 CPNN_414) resistor r=0.196506
    rCPNN_108 (CPNN_413 CPNN_423) resistor r=0.110255
    rCPNN_107 (CPNN_416 CPNN_425) resistor r=0.143949
    rCPNN_106 (CPNN_416 CPNN_424) resistor r=0.0961133
    rCPNN_105 (CPNN_417 CPNN_419) resistor r=0.104788
    rCPNN_104 (CPNN_417 CPNN_425) resistor r=0.133514
    rCPNN_103 (CPNN_419 CPNN_420) resistor r=10
    rCPNN_102 (CPNN_420 CPNN_636) resistor r=22.35
    rCPNN_101 (CPNN_422 CPNN_423) resistor r=0.00723014
    rCPNN_100 (CPNN_422 CPNN_429) resistor r=0.00846502
    rCPNN_99 (CPNN_424 CPNN_442) resistor r=0.635336
    rCPNN_98 (CPNN_426 CPNN_428) resistor r=0.342676
    rCPNN_97 (CPNN_426 CPNN_431) resistor r=0.07651
    rCPNN_96 (CPNN_428 CPNN_429) resistor r=0.75
    rCPNN_95 (CPNN_429 CPNN_656) resistor r=10
    rCPNN_94 (CPNN_431 CPNN_432) resistor r=0.806067
    rCPNN_93 (CPNN_432 CPNN_434) resistor r=0.07651
    rCPNN_92 (CPNN_433 CPNN_436) resistor r=1.35277
    rCPNN_91 (CPNN_433 CPNN_439) resistor r=0.07651
    rCPNN_90 (CPNN_434 CPNN_436) resistor r=0.832158
    rCPNN_89 (CPNN_436 CPNN_437) resistor r=0.75
    rCPNN_88 (CPNN_437 CPNN_646) resistor r=10
    rCPNN_87 (CPNN_438 CPNN_441) resistor r=0.403103
    rCPNN_86 (CPNN_438 CPNN_443) resistor r=0.07651
    rCPNN_85 (CPNN_439 CPNN_441) resistor r=0.47948
    rCPNN_84 (CPNN_441 CPNN_442) resistor r=0.75
    rCPNN_83 (CPNN_443 CPNN_445) resistor r=1.26418
    rCPNN_82 (CPNN_445 CPNN_653) resistor r=0.75
    rCPNN_81 (CPNN_512 CPNN_656) resistor r=10.0997
    rCPNN_80 (CPNN_514 CPNN_656) resistor r=10.0997
    rCPNN_79 (CPNN_526 CPNN_527) resistor r=83.9818
    rCPNN_78 (CPNN_526 CPNN_548) resistor r=9.29775
    rCPNN_77 (CPNN_527 CPNN_656) resistor r=0.877078
    rCPNN_76 (CPNN_570 CPNN_631) resistor r=4.38767
    rCPNN_75 (CPNN_584 CPNN_636) resistor r=9.29775
    rCPNN_74 (CPNN_597 CPNN_640) resistor r=4.38767
    rCPNN_73 (CPNN_630 CPNN_631) resistor r=3.71511
    rCPNN_72 (CPNN_630 CPNN_646) resistor r=14.9
    rCPNN_71 (CPNN_639 CPNN_640) resistor r=3.71511
    rCPNN_70 (CPNN_639 CPNN_652) resistor r=5.41818
    rCPNN_69 (CPNN_652 CPNN_653) resistor r=10
    rCP_93 (CP_22 CP_28) resistor r=58.3583
    rCP_92 (CP_22 CP_28) resistor r=4.16253
    rCP_91 (CP_22 CP_28) resistor r=58.3583
    rCP_90 (CP_22 CP_28) resistor r=4.16253
    rCP_89 (CP_25 CP_28) resistor r=58.3583
    rCP_88 (CP_25 CP_28) resistor r=6.30933
    rCP_87 (CP_25 CP_28) resistor r=58.3583
    rCP_86 (CP_25 CP_28) resistor r=6.30933
    rCP_85 (CP_28 CP_30) resistor r=14.9
    rCP_84 (CP_28 CP_53) resistor r=24.8333
    rCP_83 (CP_28 CP_50) resistor r=24.8333
    rCP_82 (CP_28 CP_61) resistor r=24.8333
    rCP_81 (CP_28 CP_58) resistor r=24.8333
    rCP_80 (CP_28 CP_82) resistor r=58.3583
    rCP_79 (CP_28 CP_85) resistor r=58.3583
    rCP_78 (CP_28 CP_53) resistor r=4.16253
    rCP_77 (CP_28 CP_30) resistor r=6.30933
    rCP_76 (CP_28 CP_61) resistor r=1.63969
    rCP_75 (CP_28 CP_50) resistor r=4.16253
    rCP_74 (CP_28 CP_82) resistor r=4.16253
    rCP_73 (CP_28 CP_58) resistor r=4.16253
    rCP_72 (CP_28 CP_85) resistor r=4.16253
    rCP_71 (CP_28 CP_30) resistor r=14.9
    rCP_70 (CP_28 CP_161) resistor r=40.975
    rCP_69 (CP_28 CP_53) resistor r=24.8333
    rCP_68 (CP_28 CP_50) resistor r=24.8333
    rCP_67 (CP_28 CP_61) resistor r=24.8333
    rCP_66 (CP_28 CP_58) resistor r=24.8333
    rCP_65 (CP_28 CP_82) resistor r=58.3583
    rCP_64 (CP_28 MM29_ELT_g) resistor r=7.45
    rCP_63 (CP_28 CP_53) resistor r=4.16253
    rCP_62 (CP_28 CP_30) resistor r=6.30933
    rCP_61 (CP_28 CP_61) resistor r=1.63969
    rCP_60 (CP_28 CP_50) resistor r=4.16253
    rCP_59 (CP_28 CP_82) resistor r=4.16253
    rCP_58 (CP_28 CP_58) resistor r=4.16253
    rCP_57 (CP_28 CP_85) resistor r=4.16253
    rCP_56 (CP_36 CP_39) resistor r=14.9
    rCP_55 (CP_36 CP_39) resistor r=6.30933
    rCP_54 (CP_36 CP_39) resistor r=14.9
    rCP_53 (CP_36 CP_39) resistor r=6.30933
    rCP_52 (CP_39 CP_42) resistor r=202.392
    rCP_51 (CP_39 CP_45) resistor r=202.392
    rCP_50 (CP_39 CP_69) resistor r=24.8333
    rCP_49 (CP_39 CP_66) resistor r=24.8333
    rCP_48 (CP_39 CP_77) resistor r=24.8333
    rCP_47 (CP_39 CP_74) resistor r=24.8333
    rCP_46 (CP_39 CP_90) resistor r=202.392
    rCP_45 (CP_39 CP_93) resistor r=202.392
    rCP_44 (CP_39 CP_42) resistor r=6.30933
    rCP_43 (CP_39 CP_69) resistor r=1.63969
    rCP_42 (CP_39 CP_77) resistor r=4.16253
    rCP_41 (CP_39 CP_45) resistor r=4.16253
    rCP_40 (CP_39 CP_66) resistor r=4.16253
    rCP_39 (CP_39 CP_90) resistor r=4.16253
    rCP_38 (CP_39 CP_74) resistor r=4.16253
    rCP_37 (CP_39 CP_93) resistor r=4.16253
    rCP_36 (CP_39 CP_163) resistor r=40.975
    rCP_35 (CP_39 CP_42) resistor r=202.392
    rCP_34 (CP_39 CP_45) resistor r=202.392
    rCP_33 (CP_39 CP_69) resistor r=24.8333
    rCP_32 (CP_39 CP_66) resistor r=24.8333
    rCP_31 (CP_39 CP_77) resistor r=24.8333
    rCP_30 (CP_39 CP_74) resistor r=24.8333
    rCP_29 (CP_39 CP_90) resistor r=202.392
    rCP_28 (CP_39 MM28_ELT_g) resistor r=7.45
    rCP_27 (CP_39 CP_42) resistor r=6.30933
    rCP_26 (CP_39 CP_69) resistor r=1.63969
    rCP_25 (CP_39 CP_77) resistor r=4.16253
    rCP_24 (CP_39 CP_45) resistor r=4.16253
    rCP_23 (CP_39 CP_66) resistor r=4.16253
    rCP_22 (CP_39 CP_90) resistor r=4.16253
    rCP_21 (CP_39 CP_74) resistor r=4.16253
    rCP_20 (CP_39 CP_93) resistor r=4.16253
    rCP_19 (CP_85 MM29_ELT_g) resistor r=50.9083
    rCP_18 (CP_93 MM28_ELT_g) resistor r=194.942
    rCP_17 (CP_133 CP) resistor r=10
    rCP_16 (CP_133 CP_201) resistor r=0.677273
    rCP_15 (CP_161 CP_201) resistor r=5.23411
    rCP_14 (CP_163 CP_201) resistor r=5.23411
ends DFCNQD2_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: TIEL_LVT_ELT
// View name: calibre
subckt TIEL_LVT_ELT VDD VSS ZN
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet5_14 (net5_22 VSS) capacitor c=4.28147e-18
    cinet5_13 (net5_28 VSS) capacitor c=1.88414e-16
    cinet5_12 (net5_39 VSS) capacitor c=2.3e-16
    cinet5_11 (net5_45 VSS) capacitor c=4.73887e-18
    cinet5_10 (net5_50 VSS) capacitor c=2.2416e-17
    cinet5_9 (net5_58 VSS) capacitor c=1.8708e-17
    cinet5_8 (net5_66 VSS) capacitor c=3.37228e-19
    cinet5_7 (net5_74 VSS) capacitor c=6.70564e-18
    cinet5_6 (net5_82 VSS) capacitor c=2.22299e-18
    cinet5_5 (net5_93 VSS) capacitor c=2.22299e-18
    cinet5_4 (net5_131 VSS) capacitor c=3.79471e-17
    cinet5_3 (net5_138 VSS) capacitor c=1.1793e-16
    cinet5_2 (net5_139 VSS) capacitor c=5.45762e-17
    cinet5_1 (net5_205 VSS) capacitor c=3.16009e-17
    cinet5_0 (net5_206 VSS) capacitor c=8.0875e-18
    ciZN_1 (ZN_2 VSS) capacitor c=7.5711e-17
    ciZN_0 (ZN_3 VSS) capacitor c=1.11311e-16
    ciVDD_6 (VDD_4 VSS) capacitor c=1.37396e-16
    ciVDD_5 (VDD_13 VSS) capacitor c=2.63453e-17
    ciVDD_4 (VDD_18 VSS) capacitor c=6.30097e-17
    ciVDD_3 (VDD_30 VSS) capacitor c=1.11099e-18
    ciVDD_2 (VDD_32 VSS) capacitor c=4.01793e-18
    ciVDD_1 (VDD_35 VSS) capacitor c=1.32762e-17
    ciVDD_0 (VDD_36 VSS) capacitor c=2.16736e-16
    ciVSS_4 (VSS_4 VSS) capacitor c=6.04118e-17
    ciVSS_3 (VSS_10 VSS) capacitor c=2.63453e-17
    ciVSS_2 (VSS_15 VSS) capacitor c=6.23003e-17
    ciVSS_1 (VSS_27 VSS) capacitor c=3.09968e-18
    ciVSS_0 (VSS_31 VSS) capacitor c=6.99899e-17
    rnet5_107 (MM1_ELT_d net5) resistor r=0.01
    rnet5_106 (net5_22 net5_28) resistor r=58.3583
    rnet5_105 (net5_22 net5_28) resistor r=4.16253
    rnet5_104 (net5_22 net5_28) resistor r=58.3583
    rnet5_103 (net5_22 net5_28) resistor r=4.16253
    rnet5_102 (net5_25 net5_28) resistor r=58.3583
    rnet5_101 (net5_25 net5_28) resistor r=6.30933
    rnet5_100 (net5_25 net5_28) resistor r=58.3583
    rnet5_99 (net5_25 net5_28) resistor r=6.30933
    rnet5_98 (net5_28 net5_30) resistor r=14.9
    rnet5_97 (net5_28 net5_53) resistor r=24.8333
    rnet5_96 (net5_28 net5_50) resistor r=24.8333
    rnet5_95 (net5_28 net5_61) resistor r=24.8333
    rnet5_94 (net5_28 net5_58) resistor r=24.8333
    rnet5_93 (net5_28 net5_82) resistor r=58.3583
    rnet5_92 (net5_28 net5_85) resistor r=58.3583
    rnet5_91 (net5_28 net5_53) resistor r=4.16253
    rnet5_90 (net5_28 net5_30) resistor r=6.30933
    rnet5_89 (net5_28 net5_61) resistor r=1.63969
    rnet5_88 (net5_28 net5_50) resistor r=4.16253
    rnet5_87 (net5_28 net5_82) resistor r=4.16253
    rnet5_86 (net5_28 net5_58) resistor r=4.16253
    rnet5_85 (net5_28 net5_85) resistor r=4.16253
    rnet5_84 (net5_28 net5_30) resistor r=14.9
    rnet5_83 (net5_28 net5_171) resistor r=40.975
    rnet5_82 (net5_28 net5_53) resistor r=24.8333
    rnet5_81 (net5_28 net5_50) resistor r=24.8333
    rnet5_80 (net5_28 net5_61) resistor r=24.8333
    rnet5_79 (net5_28 net5_58) resistor r=24.8333
    rnet5_78 (net5_28 net5_82) resistor r=58.3583
    rnet5_77 (net5_28 MM0_ELT_g) resistor r=7.45
    rnet5_76 (net5_28 net5_53) resistor r=4.16253
    rnet5_75 (net5_28 net5_30) resistor r=6.30933
    rnet5_74 (net5_28 net5_61) resistor r=1.63969
    rnet5_73 (net5_28 net5_50) resistor r=4.16253
    rnet5_72 (net5_28 net5_82) resistor r=4.16253
    rnet5_71 (net5_28 net5_58) resistor r=4.16253
    rnet5_70 (net5_28 net5_85) resistor r=4.16253
    rnet5_69 (net5_36 net5_39) resistor r=14.9
    rnet5_68 (net5_36 net5_39) resistor r=6.30933
    rnet5_67 (net5_36 net5_39) resistor r=14.9
    rnet5_66 (net5_36 net5_39) resistor r=6.30933
    rnet5_65 (net5_39 net5_42) resistor r=202.392
    rnet5_64 (net5_39 net5_45) resistor r=202.392
    rnet5_63 (net5_39 net5_69) resistor r=24.8333
    rnet5_62 (net5_39 net5_66) resistor r=24.8333
    rnet5_61 (net5_39 net5_77) resistor r=24.8333
    rnet5_60 (net5_39 net5_74) resistor r=24.8333
    rnet5_59 (net5_39 net5_90) resistor r=202.392
    rnet5_58 (net5_39 net5_93) resistor r=202.392
    rnet5_57 (net5_39 net5_42) resistor r=6.30933
    rnet5_56 (net5_39 net5_69) resistor r=1.63969
    rnet5_55 (net5_39 net5_77) resistor r=4.16253
    rnet5_54 (net5_39 net5_45) resistor r=4.16253
    rnet5_53 (net5_39 net5_66) resistor r=4.16253
    rnet5_52 (net5_39 net5_90) resistor r=4.16253
    rnet5_51 (net5_39 net5_74) resistor r=4.16253
    rnet5_50 (net5_39 net5_93) resistor r=4.16253
    rnet5_49 (net5_39 net5_173) resistor r=40.975
    rnet5_48 (net5_39 net5_42) resistor r=202.392
    rnet5_47 (net5_39 net5_45) resistor r=202.392
    rnet5_46 (net5_39 net5_69) resistor r=24.8333
    rnet5_45 (net5_39 net5_66) resistor r=24.8333
    rnet5_44 (net5_39 net5_77) resistor r=24.8333
    rnet5_43 (net5_39 net5_74) resistor r=24.8333
    rnet5_42 (net5_39 net5_90) resistor r=202.392
    rnet5_41 (net5_39 MM1_ELT_g) resistor r=7.45
    rnet5_40 (net5_39 net5_42) resistor r=6.30933
    rnet5_39 (net5_39 net5_69) resistor r=1.63969
    rnet5_38 (net5_39 net5_77) resistor r=4.16253
    rnet5_37 (net5_39 net5_45) resistor r=4.16253
    rnet5_36 (net5_39 net5_66) resistor r=4.16253
    rnet5_35 (net5_39 net5_90) resistor r=4.16253
    rnet5_34 (net5_39 net5_74) resistor r=4.16253
    rnet5_33 (net5_39 net5_93) resistor r=4.16253
    rnet5_32 (net5_85 MM0_ELT_g) resistor r=50.9083
    rnet5_31 (net5_93 MM1_ELT_g) resistor r=194.942
    rnet5_30 (net5_131 net5_133) resistor r=0.188099
    rnet5_29 (net5_131 net5_136) resistor r=0.107078
    rnet5_28 (net5_133 net5_134) resistor r=10
    rnet5_27 (net5_134 net5_205) resistor r=13.5455
    rnet5_26 (net5_136 net5_138) resistor r=0.713981
    rnet5_25 (net5_138 net5_139) resistor r=8.66667
    rnet5_24 (net5_138 net5_141) resistor r=0.639386
    rnet5_23 (net5_139 net5) resistor r=32.3614
    rnet5_22 (net5_141 net5_142) resistor r=8.66667
    rnet5_21 (net5_141 net5_144) resistor r=0.426257
    rnet5_20 (net5_142 net5) resistor r=16.1807
    rnet5_19 (net5_142 net5_145) resistor r=32.3614
    rnet5_18 (net5_144 net5_145) resistor r=26
    rnet5_17 (net5_171 net5_206) resistor r=3.725
    rnet5_16 (net5_173 net5_206) resistor r=3.725
    rnet5_15 (net5_205 net5_206) resistor r=3.725
    rZN_4 (ZN_2 ZN_3) resistor r=13
    rZN_3 (ZN_2 ZN) resistor r=0.122549
    rZN_2 (ZN_3 MM0_ELT_d) resistor r=8.44
    rVDD_34 (MM1_ELT_b VDD_18) resistor r=26
    rVDD_33 (MM1_ELT_b VDD_16) resistor r=11.2533
    rVDD_32 (VDD_2 VDD_11) resistor r=0.490196
    rVDD_31 (VDD_2 VDD_24) resistor r=0.11908
    rVDD_30 (VDD_4 VDD_12) resistor r=8.66667
    rVDD_29 (VDD_4 VDD_8) resistor r=0.639386
    rVDD_28 (VDD_8 VDD_12) resistor r=8.66667
    rVDD_27 (VDD_8 VDD_11) resistor r=0.639386
    rVDD_26 (VDD_11 VDD_12) resistor r=8.66667
    rVDD_25 (VDD_12 MM1_ELT_s) resistor r=1.847
    rVDD_24 (VDD_12 VDD_36) resistor r=20.317
    rVDD_23 (VDD_13 VDD_15) resistor r=0.0335667
    rVDD_22 (VDD_13 VDD_24) resistor r=0.0177706
    rVDD_21 (VDD_15 VDD_16) resistor r=8.66667
    rVDD_20 (VDD_15 VDD_18) resistor r=0.157961
    rVDD_19 (VDD VDD_24) resistor r=0.0513373
    rVDD_18 (MM1_ELT_s VDD_30) resistor r=2.55965
    rVDD_17 (MM1_ELT_s VDD_32) resistor r=12.3172
    rVDD_16 (MM1_ELT_s VDD_32) resistor r=1.62887
    rVDD_15 (MM1_ELT_s VDD_35) resistor r=6.12113
    rVDD_14 (VDD_28 VDD_30) resistor r=14.4784
    rVDD_13 (VDD_28 VDD_34) resistor r=9.04062
    rVDD_12 (VDD_29 VDD_30) resistor r=14.4784
    rVDD_11 (VDD_29 VDD_36) resistor r=9.48555
    rVDD_10 (VDD_31 VDD_32) resistor r=12.3172
    rVDD_9 (VDD_31 VDD_33) resistor r=9.04595
    rVDD_8 (VDD_33 VDD_35) resistor r=31.2341
    rVDD_7 (VDD_34 VDD_35) resistor r=31.2341
    rVSS_30 (MM0_ELT_b VSS_15) resistor r=26
    rVSS_29 (MM0_ELT_b VSS_13) resistor r=10.7871
    rVSS_28 (VSS_2 VSS_4) resistor r=0.404945
    rVSS_27 (VSS_2 VSS_21) resistor r=0.11908
    rVSS_26 (VSS_4 VSS_8) resistor r=8.66667
    rVSS_25 (VSS_4 VSS_7) resistor r=0.426257
    rVSS_24 (VSS_7 VSS_8) resistor r=26
    rVSS_23 (VSS_8 MM0_ELT_s) resistor r=2.90692
    rVSS_22 (VSS_8 VSS_31) resistor r=12.1406
    rVSS_21 (VSS_10 VSS_12) resistor r=0.0335667
    rVSS_20 (VSS_10 VSS_21) resistor r=0.0177706
    rVSS_19 (VSS_12 VSS_13) resistor r=8.66667
    rVSS_18 (VSS_12 VSS_15) resistor r=0.157961
    rVSS_17 (VSS VSS_21) resistor r=0.0493628
    rVSS_16 (MM0_ELT_s VSS_25) resistor r=2.67027
    rVSS_15 (MM0_ELT_s VSS_27) resistor r=12.8495
    rVSS_14 (MM0_ELT_s VSS_27) resistor r=1.69926
    rVSS_13 (MM0_ELT_s VSS_30) resistor r=4.557
    rVSS_12 (VSS_23 VSS_25) resistor r=15.1041
    rVSS_11 (VSS_23 VSS_28) resistor r=9.43134
    rVSS_10 (VSS_24 VSS_25) resistor r=15.1041
    rVSS_9 (VSS_24 VSS_31) resistor r=9.89549
    rVSS_8 (VSS_26 VSS_27) resistor r=12.8495
    rVSS_7 (VSS_26 VSS_29) resistor r=9.4369
    rVSS_6 (VSS_28 VSS_30) resistor r=21.1301
    rVSS_5 (VSS_29 VSS_30) resistor r=21.1301
ends TIEL_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: LHCNQD1_LVT_ELT
// View name: calibre
subckt LHCNQD1_LVT_ELT D E CDN Q VDD VSS
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 \
        ps=4.76e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM16_ELT (MM16_ELT_d MM16_ELT_g MM16_ELT_s MM16_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM29_ELT (MM29_ELT_d MM29_ELT_g MM29_ELT_s MM29_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=5.68868e-13 pd=3.66e-06 \
        ps=8.52312e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.50082e-13 pd=1.34e-06 \
        ps=3.74688e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=3.03125e-13 as=9.4e-14 pd=4.8e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM28_ELT (MM28_ELT_d MM28_ELT_g MM28_ELT_s MM28_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet29_6 (net29_4 VSS) capacitor c=5.47935e-18
    cinet29_5 (net29_5 VSS) capacitor c=2.81534e-18
    cinet29_4 (MM12_ELT_d VSS) capacitor c=5.49052e-18
    cinet29_3 (net29_12 VSS) capacitor c=1.20107e-18
    cinet29_2 (net29_14 VSS) capacitor c=5.70188e-18
    cinet29_1 (net29_16 VSS) capacitor c=4.71508e-18
    cinet29_0 (net29 VSS) capacitor c=9.46668e-18
    cinet17_8 (MM16_ELT_s VSS) capacitor c=6.741e-18
    cinet17_7 (net17_4 VSS) capacitor c=6.02701e-19
    cinet17_6 (net17_5 VSS) capacitor c=1.19602e-18
    cinet17_5 (net17_11 VSS) capacitor c=2.68406e-17
    cinet17_4 (net17_15 VSS) capacitor c=3.69063e-18
    cinet17_3 (net17_16 VSS) capacitor c=6.53282e-18
    cinet17_2 (net17_19 VSS) capacitor c=8.48875e-18
    cinet17_1 (net17_20 VSS) capacitor c=7.37056e-18
    cinet17_0 (net17 VSS) capacitor c=3.51213e-18
    cinet72_7 (net72_4 VSS) capacitor c=5.08287e-18
    cinet72_6 (net72_6 VSS) capacitor c=6.21964e-18
    cinet72_5 (net72_9 VSS) capacitor c=1.71175e-18
    cinet72_4 (MM9_ELT_d VSS) capacitor c=1.08186e-17
    cinet72_3 (net72_13 VSS) capacitor c=4.91492e-18
    cinet72_2 (net72_15 VSS) capacitor c=7.44397e-18
    cinet72_1 (net72_18 VSS) capacitor c=1.18424e-17
    cinet72_0 (net72_20 VSS) capacitor c=1.15496e-17
    ciQ_23 (Q_22 VSS) capacitor c=6.89598e-18
    ciQ_22 (Q_25 VSS) capacitor c=4.27597e-18
    ciQ_21 (Q_28 VSS) capacitor c=1.70465e-16
    ciQ_20 (Q_30 VSS) capacitor c=2.08995e-17
    ciQ_19 (Q_38 VSS) capacitor c=2.30316e-17
    ciQ_18 (Q_46 VSS) capacitor c=6.31515e-18
    ciQ_17 (Q_49 VSS) capacitor c=4.47573e-18
    ciQ_16 (Q_52 VSS) capacitor c=1.67762e-16
    ciQ_15 (Q_60 VSS) capacitor c=3.15386e-17
    ciQ_14 (Q_68 VSS) capacitor c=1.77129e-17
    ciQ_13 (Q_79 VSS) capacitor c=2.80371e-18
    ciQ_12 (Q_90 VSS) capacitor c=9.33931e-18
    ciQ_11 (Q_131 VSS) capacitor c=1.55987e-16
    ciQ_10 (Q_137 VSS) capacitor c=1.45618e-16
    ciQ_9 (Q_138 VSS) capacitor c=5.01954e-17
    ciQ_8 (Q_139 VSS) capacitor c=1.55425e-17
    ciQ_7 (Q_142 VSS) capacitor c=4.47351e-17
    ciQ_6 (Q_143 VSS) capacitor c=1.11627e-16
    ciQ_5 (Q_147 VSS) capacitor c=1.75017e-16
    ciQ_4 (Q_148 VSS) capacitor c=3.23187e-16
    ciQ_3 (Q VSS) capacitor c=6.13807e-17
    ciQ_2 (Q_162 VSS) capacitor c=2.65448e-17
    ciQ_1 (Q_165 VSS) capacitor c=2.86516e-17
    ciQ_0 (Q_232 VSS) capacitor c=5.19169e-17
    ciVDD_37 (VDD_2 VSS) capacitor c=6.33976e-17
    ciVDD_36 (VDD_11 VSS) capacitor c=2.75124e-16
    ciVDD_35 (VDD_19 VSS) capacitor c=3.85537e-16
    ciVDD_34 (VDD_20 VSS) capacitor c=5.0482e-17
    ciVDD_33 (VDD_27 VSS) capacitor c=8.23126e-17
    ciVDD_32 (VDD_28 VSS) capacitor c=8.25651e-17
    ciVDD_31 (VDD_30 VSS) capacitor c=1.0817e-16
    ciVDD_30 (VDD_43 VSS) capacitor c=5.80658e-17
    ciVDD_29 (VDD_44 VSS) capacitor c=1.18497e-16
    ciVDD_28 (VDD_46 VSS) capacitor c=6.27613e-17
    ciVDD_27 (VDD_53 VSS) capacitor c=2.56217e-16
    ciVDD_26 (VDD_61 VSS) capacitor c=1.97228e-16
    ciVDD_25 (VDD_67 VSS) capacitor c=7.85711e-17
    ciVDD_24 (VDD_70 VSS) capacitor c=3.58509e-18
    ciVDD_23 (VDD_71 VSS) capacitor c=3.58509e-18
    ciVDD_22 (VDD_72 VSS) capacitor c=3.58509e-18
    ciVDD_21 (VDD_73 VSS) capacitor c=3.58509e-18
    ciVDD_20 (MM1_ELT_s VSS) capacitor c=1.32762e-17
    ciVDD_19 (VDD_80 VSS) capacitor c=1.11099e-18
    ciVDD_18 (VDD_82 VSS) capacitor c=1.07074e-18
    ciVDD_17 (VDD_86 VSS) capacitor c=1.11099e-18
    ciVDD_16 (VDD_87 VSS) capacitor c=1.60033e-18
    ciVDD_15 (VDD_88 VSS) capacitor c=1.07074e-18
    ciVDD_14 (VDD_91 VSS) capacitor c=4.61254e-17
    ciVDD_13 (MM14_ELT_s VSS) capacitor c=5.08287e-18
    ciVDD_12 (VDD_94 VSS) capacitor c=6.12638e-18
    ciVDD_11 (VDD_97 VSS) capacitor c=1.71175e-18
    ciVDD_10 (VDD_102 VSS) capacitor c=3.97088e-18
    ciVDD_9 (VDD_103 VSS) capacitor c=7.12773e-18
    ciVDD_8 (VDD_104 VSS) capacitor c=4.39784e-18
    ciVDD_7 (VDD_107 VSS) capacitor c=1.71175e-18
    ciVDD_6 (VDD_109 VSS) capacitor c=3.37872e-18
    ciVDD_5 (VDD_113 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_114 VSS) capacitor c=5.85144e-18
    ciVDD_3 (VDD_115 VSS) capacitor c=6.51271e-18
    ciVDD_2 (VDD_118 VSS) capacitor c=1.56668e-17
    ciVDD_1 (VDD_120 VSS) capacitor c=2.70329e-18
    ciVDD_0 (VDD_142 VSS) capacitor c=1.32093e-17
    ciVSS_25 (VSS_2 VSS) capacitor c=6.13494e-17
    ciVSS_24 (VSS_11 VSS) capacitor c=1.02326e-16
    ciVSS_23 (VSS_12 VSS) capacitor c=1.22554e-16
    ciVSS_22 (VSS_14 VSS) capacitor c=2.07054e-16
    ciVSS_21 (VSS_30 VSS) capacitor c=7.22229e-17
    ciVSS_20 (VSS_31 VSS) capacitor c=1.13397e-16
    ciVSS_19 (VSS_33 VSS) capacitor c=4.57225e-17
    ciVSS_18 (VSS_40 VSS) capacitor c=7.68449e-17
    ciVSS_17 (VSS_51 VSS) capacitor c=7.64127e-17
    ciVSS_16 (VSS_54 VSS) capacitor c=3.58509e-18
    ciVSS_15 (VSS_55 VSS) capacitor c=3.58509e-18
    ciVSS_14 (VSS_56 VSS) capacitor c=3.58509e-18
    ciVSS_13 (VSS_63 VSS) capacitor c=2.47056e-18
    ciVSS_12 (VSS_65 VSS) capacitor c=4.18247e-19
    ciVSS_11 (VSS_67 VSS) capacitor c=2.11324e-18
    ciVSS_10 (VSS_68 VSS) capacitor c=2.03427e-18
    ciVSS_9 (VSS_69 VSS) capacitor c=3.15923e-18
    ciVSS_8 (VSS_72 VSS) capacitor c=6.52035e-18
    ciVSS_7 (VSS_76 VSS) capacitor c=8.25279e-18
    ciVSS_6 (VSS_87 VSS) capacitor c=4.23028e-18
    ciVSS_5 (VSS_95 VSS) capacitor c=5.9471e-18
    ciVSS_4 (VSS_96 VSS) capacitor c=2.33721e-18
    ciVSS_3 (VSS_99 VSS) capacitor c=2.63325e-18
    ciVSS_2 (VSS_101 VSS) capacitor c=1.96311e-18
    ciVSS_1 (VSS_103 VSS) capacitor c=4.06582e-18
    ciVSS_0 (VSS_106 VSS) capacitor c=7.77889e-17
    cinet25_7 (net25_3 VSS) capacitor c=4.43898e-17
    cinet25_6 (net25_4 VSS) capacitor c=1.09459e-16
    cinet25_5 (net25_6 VSS) capacitor c=2.84881e-17
    cinet25_4 (net25_7 VSS) capacitor c=1.33167e-17
    cinet25_3 (net25_9 VSS) capacitor c=7.48497e-17
    cinet25_2 (net25_12 VSS) capacitor c=5.39743e-17
    cinet25_1 (net25_13 VSS) capacitor c=1.12958e-16
    cinet25_0 (net25_17 VSS) capacitor c=2.20158e-17
    cinet20_6 (net20_3 VSS) capacitor c=1.68761e-17
    cinet20_5 (net20_4 VSS) capacitor c=1.19099e-16
    cinet20_4 (net20_8 VSS) capacitor c=7.55144e-17
    cinet20_3 (net20_12 VSS) capacitor c=1.65641e-17
    cinet20_2 (net20_13 VSS) capacitor c=1.20843e-16
    cinet20_1 (net20_17 VSS) capacitor c=2.69341e-17
    cinet20_0 (net20_18 VSS) capacitor c=2.1234e-17
    ciCDN_25 (CDN_34 VSS) capacitor c=3.98759e-18
    ciCDN_24 (CDN_37 VSS) capacitor c=2.81125e-18
    ciCDN_23 (CDN_40 VSS) capacitor c=1.95592e-16
    ciCDN_22 (CDN_42 VSS) capacitor c=2.23316e-17
    ciCDN_21 (CDN_50 VSS) capacitor c=1.57811e-17
    ciCDN_20 (CDN_58 VSS) capacitor c=3.00043e-18
    ciCDN_19 (CDN_72 VSS) capacitor c=2.96645e-18
    ciCDN_18 (CDN_78 VSS) capacitor c=1.90269e-16
    ciCDN_17 (CDN_86 VSS) capacitor c=2.23697e-17
    ciCDN_16 (CDN_94 VSS) capacitor c=2.26195e-17
    ciCDN_15 (CDN_102 VSS) capacitor c=4.18692e-18
    ciCDN_14 (CDN_105 VSS) capacitor c=4.19476e-18
    ciCDN_13 (CDN_108 VSS) capacitor c=3.37649e-16
    ciCDN_12 (CDN_110 VSS) capacitor c=3.35294e-18
    ciCDN_11 (CDN_113 VSS) capacitor c=1.55908e-18
    ciCDN_10 (CDN_118 VSS) capacitor c=1.63704e-17
    ciCDN_9 (CDN_126 VSS) capacitor c=2.2416e-17
    ciCDN_8 (CDN_140 VSS) capacitor c=1.54276e-17
    ciCDN_7 (CDN_148 VSS) capacitor c=2.87352e-18
    ciCDN_6 (CDN_151 VSS) capacitor c=3.85496e-18
    ciCDN_5 (CDN VSS) capacitor c=6.45322e-17
    ciCDN_4 (CDN_265 VSS) capacitor c=2.01853e-17
    ciCDN_3 (CDN_279 VSS) capacitor c=4.66839e-17
    ciCDN_2 (CDN_310 VSS) capacitor c=1.91321e-17
    ciCDN_1 (CDN_311 VSS) capacitor c=4.02528e-18
    ciCDN_0 (CDN_314 VSS) capacitor c=6.67042e-18
    ciD_17 (D_22 VSS) capacitor c=5.05393e-18
    ciD_16 (D_25 VSS) capacitor c=3.25905e-18
    ciD_15 (D_28 VSS) capacitor c=2.15451e-16
    ciD_14 (D_30 VSS) capacitor c=2.59479e-17
    ciD_13 (D_38 VSS) capacitor c=2.23851e-17
    ciD_12 (D_55 VSS) capacitor c=4.11003e-18
    ciD_11 (D_60 VSS) capacitor c=5.62988e-18
    ciD_10 (D_66 VSS) capacitor c=1.76671e-16
    ciD_9 (D_74 VSS) capacitor c=2.23351e-17
    ciD_8 (D_82 VSS) capacitor c=2.46693e-17
    ciD_7 (D_90 VSS) capacitor c=3.98759e-18
    ciD_6 (D_93 VSS) capacitor c=6.94225e-18
    ciD_5 (D VSS) capacitor c=8.32984e-17
    ciD_4 (D_174 VSS) capacitor c=3.14753e-17
    ciD_3 (D_175 VSS) capacitor c=2.10073e-17
    ciD_2 (D_183 VSS) capacitor c=1.24865e-16
    ciD_1 (D_201 VSS) capacitor c=3.2397e-17
    ciD_0 (D_202 VSS) capacitor c=2.25462e-17
    cinet49_6 (net49_3 VSS) capacitor c=7.44606e-17
    cinet49_5 (net49_4 VSS) capacitor c=1.24817e-16
    cinet49_4 (net49_8 VSS) capacitor c=6.67128e-17
    cinet49_3 (net49_9 VSS) capacitor c=1.2637e-16
    cinet49_2 (net49_12 VSS) capacitor c=5.08247e-17
    cinet49_1 (net49_15 VSS) capacitor c=1.8311e-17
    cinet49_0 (net49_19 VSS) capacitor c=2.02892e-17
    cinet67_47 (net67_22 VSS) capacitor c=4.28147e-18
    cinet67_46 (net67_28 VSS) capacitor c=1.95115e-16
    cinet67_45 (net67_39 VSS) capacitor c=5.66308e-16
    cinet67_44 (net67_45 VSS) capacitor c=5.13601e-18
    cinet67_43 (net67_50 VSS) capacitor c=2.23559e-17
    cinet67_42 (net67_58 VSS) capacitor c=1.51948e-17
    cinet67_41 (net67_66 VSS) capacitor c=1.92647e-17
    cinet67_40 (net67_74 VSS) capacitor c=1.60938e-17
    cinet67_39 (net67_82 VSS) capacitor c=2.11871e-18
    cinet67_38 (net67_85 VSS) capacitor c=4.66991e-18
    cinet67_37 (net67_90 VSS) capacitor c=7.42966e-18
    cinet67_36 (net67_93 VSS) capacitor c=2.22299e-18
    cinet67_35 (net67_133 VSS) capacitor c=9.15031e-17
    cinet67_34 (net67_134 VSS) capacitor c=1.57563e-17
    cinet67_33 (net67_136 VSS) capacitor c=4.46203e-17
    cinet67_32 (net67_137 VSS) capacitor c=4.07287e-17
    cinet67_31 (net67_138 VSS) capacitor c=1.36219e-17
    cinet67_30 (net67_141 VSS) capacitor c=4.12714e-17
    cinet67_29 (net67_142 VSS) capacitor c=1.1901e-16
    cinet67_28 (net67_144 VSS) capacitor c=4.51338e-17
    cinet67_27 (net67_145 VSS) capacitor c=1.26667e-17
    cinet67_26 (net67_148 VSS) capacitor c=3.24723e-17
    cinet67_25 (net67_149 VSS) capacitor c=1.07086e-16
    cinet67_24 (net67_151 VSS) capacitor c=7.9559e-18
    cinet67_23 (net67_154 VSS) capacitor c=3.28175e-17
    cinet67_22 (net67_155 VSS) capacitor c=1.13835e-16
    cinet67_21 (net67_157 VSS) capacitor c=1.24207e-16
    cinet67_20 (net67_160 VSS) capacitor c=1.33967e-16
    cinet67_19 (net67_161 VSS) capacitor c=2.59236e-17
    cinet67_18 (net67_163 VSS) capacitor c=9.06564e-17
    cinet67_17 (net67_168 VSS) capacitor c=5.87348e-17
    cinet67_16 (net67_169 VSS) capacitor c=1.49533e-16
    cinet67_15 (net67_172 VSS) capacitor c=2.50758e-17
    cinet67_14 (net67_174 VSS) capacitor c=4.06249e-17
    cinet67_13 (net67_177 VSS) capacitor c=8.49318e-18
    cinet67_12 (net67_178 VSS) capacitor c=5.24852e-18
    cinet67_11 (net67_179 VSS) capacitor c=6.8121e-18
    cinet67_10 (net67_182 VSS) capacitor c=1.19868e-16
    cinet67_9 (net67_187 VSS) capacitor c=2.82302e-17
    cinet67_8 (net67_192 VSS) capacitor c=1.94667e-17
    cinet67_7 (net67_250 VSS) capacitor c=3.24865e-17
    cinet67_6 (net67_251 VSS) capacitor c=1.52335e-17
    cinet67_5 (net67_261 VSS) capacitor c=1.71175e-18
    cinet67_4 (net67_263 VSS) capacitor c=8.43559e-18
    cinet67_3 (net67_266 VSS) capacitor c=3.97088e-18
    cinet67_2 (net67_267 VSS) capacitor c=1.55537e-16
    cinet67_1 (net67_271 VSS) capacitor c=1.06436e-16
    cinet67_0 (net67_272 VSS) capacitor c=7.96977e-17
    ciENN_30 (ENN_22 VSS) capacitor c=5.91538e-18
    ciENN_29 (ENN_28 VSS) capacitor c=1.69846e-16
    ciENN_28 (ENN_36 VSS) capacitor c=2.47942e-17
    ciENN_27 (ENN_44 VSS) capacitor c=1.8502e-17
    ciENN_26 (ENN_52 VSS) capacitor c=6.51671e-18
    ciENN_25 (ENN_55 VSS) capacitor c=5.2401e-18
    ciENN_24 (ENN_60 VSS) capacitor c=2e-18
    ciENN_23 (ENN_63 VSS) capacitor c=4.15066e-18
    ciENN_22 (ENN_66 VSS) capacitor c=1.64728e-16
    ciENN_21 (ENN_68 VSS) capacitor c=1.99757e-17
    ciENN_20 (ENN_76 VSS) capacitor c=2.2416e-17
    ciENN_19 (ENN_93 VSS) capacitor c=5.86975e-18
    ciENN_18 (ENN_133 VSS) capacitor c=5.38205e-17
    ciENN_17 (ENN_134 VSS) capacitor c=1.12678e-16
    ciENN_16 (ENN_138 VSS) capacitor c=1.95186e-16
    ciENN_15 (ENN_139 VSS) capacitor c=3.35581e-16
    ciENN_14 (ENN_147 VSS) capacitor c=3.27475e-17
    ciENN_13 (ENN_148 VSS) capacitor c=1.71099e-17
    ciENN_12 (ENN_149 VSS) capacitor c=3.14881e-17
    ciENN_11 (ENN_150 VSS) capacitor c=1.83973e-17
    ciENN_10 (ENN_152 VSS) capacitor c=2.37748e-17
    ciENN_9 (ENN_155 VSS) capacitor c=5.14448e-17
    ciENN_8 (ENN_160 VSS) capacitor c=1.85326e-17
    ciENN_7 (ENN_163 VSS) capacitor c=1.47025e-16
    ciENN_6 (ENN_164 VSS) capacitor c=7.50507e-18
    ciENN_5 (ENN_166 VSS) capacitor c=1.50933e-17
    ciENN_4 (ENN_168 VSS) capacitor c=1.07663e-16
    ciENN_3 (ENN_169 VSS) capacitor c=1.01201e-16
    ciENN_2 (ENN_229 VSS) capacitor c=4.60146e-17
    ciENN_1 (ENN_234 VSS) capacitor c=2.56178e-17
    ciENN_0 (ENN_235 VSS) capacitor c=2.9223e-17
    ciEN_55 (EN_42 VSS) capacitor c=3.65279e-18
    ciEN_54 (EN_48 VSS) capacitor c=1.98308e-16
    ciEN_53 (EN_59 VSS) capacitor c=6.10342e-16
    ciEN_52 (EN_65 VSS) capacitor c=3.83402e-18
    ciEN_51 (EN_70 VSS) capacitor c=2.28658e-17
    ciEN_50 (EN_78 VSS) capacitor c=2.15312e-17
    ciEN_49 (EN_86 VSS) capacitor c=1.20384e-17
    ciEN_48 (EN_94 VSS) capacitor c=1.51914e-17
    ciEN_47 (EN_102 VSS) capacitor c=4.17058e-18
    ciEN_46 (EN_105 VSS) capacitor c=6.84204e-18
    ciEN_45 (EN_110 VSS) capacitor c=6.81726e-18
    ciEN_44 (EN_113 VSS) capacitor c=3.81698e-18
    ciEN_43 (EN_118 VSS) capacitor c=2.94403e-17
    ciEN_42 (EN_124 VSS) capacitor c=2.47379e-16
    ciEN_41 (EN_132 VSS) capacitor c=2.76116e-17
    ciEN_40 (EN_140 VSS) capacitor c=2.33696e-17
    ciEN_39 (EN_148 VSS) capacitor c=1.12527e-17
    ciEN_38 (EN_151 VSS) capacitor c=7.60354e-18
    ciEN_37 (EN_159 VSS) capacitor c=1.54527e-16
    ciEN_36 (EN_165 VSS) capacitor c=5.55839e-18
    ciEN_35 (EN_170 VSS) capacitor c=1.57439e-17
    ciEN_34 (EN_178 VSS) capacitor c=2.93189e-17
    ciEN_33 (EN_186 VSS) capacitor c=4.57751e-18
    ciEN_32 (EN_189 VSS) capacitor c=5.30821e-18
    ciEN_31 (EN_263 VSS) capacitor c=5.28756e-17
    ciEN_30 (EN_264 VSS) capacitor c=1.11566e-16
    ciEN_29 (EN_268 VSS) capacitor c=1.73415e-16
    ciEN_28 (EN_269 VSS) capacitor c=3.29385e-16
    ciEN_27 (EN_277 VSS) capacitor c=4.76614e-17
    ciEN_26 (EN_278 VSS) capacitor c=1.44505e-17
    ciEN_25 (EN_279 VSS) capacitor c=4.09338e-17
    ciEN_24 (EN_280 VSS) capacitor c=1.26433e-17
    ciEN_23 (EN_282 VSS) capacitor c=9.85816e-18
    ciEN_22 (EN_285 VSS) capacitor c=4.37018e-17
    ciEN_21 (EN_288 VSS) capacitor c=1.34014e-17
    ciEN_20 (EN_290 VSS) capacitor c=3.59765e-17
    ciEN_19 (EN_293 VSS) capacitor c=7.73603e-17
    ciEN_18 (EN_294 VSS) capacitor c=1.47403e-17
    ciEN_17 (EN_296 VSS) capacitor c=2.52919e-17
    ciEN_16 (EN_301 VSS) capacitor c=1.58848e-17
    ciEN_15 (EN_305 VSS) capacitor c=2.16186e-17
    ciEN_14 (EN_310 VSS) capacitor c=1.29257e-16
    ciEN_13 (EN_311 VSS) capacitor c=4.56942e-18
    ciEN_12 (EN_312 VSS) capacitor c=9.26711e-17
    ciEN_11 (EN_313 VSS) capacitor c=1.15594e-17
    ciEN_10 (EN_314 VSS) capacitor c=2.34522e-17
    ciEN_9 (EN_315 VSS) capacitor c=6.84749e-18
    ciEN_8 (EN_318 VSS) capacitor c=1.74248e-17
    ciEN_7 (EN_319 VSS) capacitor c=7.97881e-17
    ciEN_6 (EN_325 VSS) capacitor c=2.41722e-17
    ciEN_5 (EN_327 VSS) capacitor c=3.33216e-17
    ciEN_4 (EN_328 VSS) capacitor c=1.08646e-16
    ciEN_3 (EN_449 VSS) capacitor c=5.89137e-17
    ciEN_2 (EN_452 VSS) capacitor c=2.35535e-17
    ciEN_1 (EN_453 VSS) capacitor c=3.04019e-17
    ciEN_0 (EN_464 VSS) capacitor c=4.22912e-17
    ciE_13 (E_22 VSS) capacitor c=2.22299e-18
    ciE_12 (E_28 VSS) capacitor c=1.77638e-16
    ciE_11 (E_39 VSS) capacitor c=5.58555e-16
    ciE_10 (E_45 VSS) capacitor c=2.22299e-18
    ciE_9 (E_50 VSS) capacitor c=2.23697e-17
    ciE_8 (E_58 VSS) capacitor c=2.25728e-17
    ciE_7 (E_66 VSS) capacitor c=1.36936e-17
    ciE_6 (E_74 VSS) capacitor c=1.51948e-17
    ciE_5 (E_82 VSS) capacitor c=4.2013e-18
    ciE_4 (E_85 VSS) capacitor c=8.18924e-18
    ciE_3 (E_90 VSS) capacitor c=5.03111e-18
    ciE_2 (E_93 VSS) capacitor c=5.13601e-18
    ciE_1 (E VSS) capacitor c=5.55239e-17
    ciE_0 (E_201 VSS) capacitor c=3.21202e-17
    rnet29_32 (MM11_ELT_s net29_2) resistor r=18.0507
    rnet29_31 (MM11_ELT_s net29_5) resistor r=15.1041
    rnet29_30 (MM11_ELT_s net29_5) resistor r=2.67027
    rnet29_29 (MM11_ELT_s net29_7) resistor r=12.8495
    rnet29_28 (MM11_ELT_s net29_7) resistor r=1.69926
    rnet29_27 (MM11_ELT_s net29_11) resistor r=4.22001
    rnet29_26 (MM11_ELT_s net29) resistor r=10.6787
    rnet29_25 (net29_2 net29_4) resistor r=9.43134
    rnet29_24 (net29_4 net29_5) resistor r=15.1041
    rnet29_23 (net29_6 net29_7) resistor r=12.8495
    rnet29_22 (net29_6 net29_18) resistor r=10.6787
    rnet29_21 (net29_8 net29_11) resistor r=4.22001
    rnet29_20 (net29_8 net29_18) resistor r=0.57282
    rnet29_19 (net29_9 net29_11) resistor r=4.22001
    rnet29_18 (net29_9 net29) resistor r=0.57282
    rnet29_17 (MM12_ELT_d net29_11) resistor r=4.22001
    rnet29_16 (MM12_ELT_d net29_14) resistor r=15.1041
    rnet29_15 (MM12_ELT_d net29_14) resistor r=2.67027
    rnet29_14 (MM12_ELT_d net29_16) resistor r=12.1643
    rnet29_13 (MM12_ELT_d net29_16) resistor r=1.36649
    rnet29_12 (MM12_ELT_d net29_17) resistor r=18.0507
    rnet29_11 (MM12_ELT_d net29_18) resistor r=10.6787
    rnet29_10 (net29_12 net29_14) resistor r=15.1041
    rnet29_9 (net29_12 net29_17) resistor r=9.43134
    rnet29_8 (net29_15 net29_16) resistor r=12.1643
    rnet29_7 (net29_15 net29) resistor r=10.6787
    rnet17_37 (MM16_ELT_s net17_2) resistor r=18.0507
    rnet17_36 (MM16_ELT_s net17_5) resistor r=2.67027
    rnet17_35 (MM16_ELT_s net17_7) resistor r=12.8495
    rnet17_34 (MM16_ELT_s net17_7) resistor r=1.69926
    rnet17_33 (MM16_ELT_s net17_11) resistor r=4.22001
    rnet17_32 (net17_2 net17_4) resistor r=9.43134
    rnet17_31 (net17_3 net17_5) resistor r=15.1041
    rnet17_30 (net17_3 net17_20) resistor r=11.0157
    rnet17_29 (net17_4 net17_5) resistor r=15.1041
    rnet17_28 (net17_6 net17_7) resistor r=12.8495
    rnet17_27 (net17_6 net17) resistor r=10.6787
    rnet17_26 (net17_8 net17_11) resistor r=4.22001
    rnet17_25 (net17_8 net17_20) resistor r=0.762262
    rnet17_24 (net17_9 net17_11) resistor r=4.22001
    rnet17_23 (net17_9 net17) resistor r=0.57282
    rnet17_22 (MM17_ELT_d net17_11) resistor r=4.22001
    rnet17_21 (MM17_ELT_d net17_14) resistor r=2.67027
    rnet17_20 (MM17_ELT_d net17_16) resistor r=12.8495
    rnet17_19 (MM17_ELT_d net17_16) resistor r=1.69926
    rnet17_18 (MM17_ELT_d net17_19) resistor r=4.557
    rnet17_17 (MM17_ELT_d net17) resistor r=10.6787
    rnet17_16 (net17_12 net17_14) resistor r=15.1041
    rnet17_15 (net17_12 net17_17) resistor r=9.43134
    rnet17_14 (net17_13 net17_14) resistor r=15.1041
    rnet17_13 (net17_13 net17_20) resistor r=11.0157
    rnet17_12 (net17_15 net17_16) resistor r=12.8495
    rnet17_11 (net17_15 net17_18) resistor r=9.4369
    rnet17_10 (net17_17 net17_19) resistor r=21.1301
    rnet17_9 (net17_18 net17_19) resistor r=21.1301
    rnet72_36 (net72_1 net72_4) resistor r=20.2547
    rnet72_35 (net72_1 net72_5) resistor r=9.04595
    rnet72_34 (net72_2 net72_4) resistor r=20.2547
    rnet72_33 (net72_2 net72_8) resistor r=9.04062
    rnet72_32 (MM10_ELT_s net72_4) resistor r=4.36821
    rnet72_31 (MM10_ELT_s net72_6) resistor r=12.3172
    rnet72_30 (MM10_ELT_s net72_6) resistor r=1.62887
    rnet72_29 (MM10_ELT_s net72_9) resistor r=2.55965
    rnet72_28 (MM10_ELT_s net72_13) resistor r=4.04518
    rnet72_27 (MM10_ELT_s net72_20) resistor r=10.2363
    rnet72_26 (net72_5 net72_6) resistor r=12.3172
    rnet72_25 (net72_7 net72_9) resistor r=14.4784
    rnet72_24 (net72_7 net72) resistor r=10.5593
    rnet72_23 (net72_8 net72_9) resistor r=14.4784
    rnet72_22 (net72_10 net72_13) resistor r=4.04518
    rnet72_21 (net72_10 net72_20) resistor r=0.549089
    rnet72_20 (net72_11 net72_13) resistor r=4.04518
    rnet72_19 (net72_11 net72) resistor r=0.730683
    rnet72_18 (MM9_ELT_d net72_13) resistor r=4.04518
    rnet72_17 (MM9_ELT_d net72_15) resistor r=11.6604
    rnet72_16 (MM9_ELT_d net72_15) resistor r=1.30988
    rnet72_15 (MM9_ELT_d net72_18) resistor r=2.55965
    rnet72_14 (MM9_ELT_d net72_19) resistor r=17.3029
    rnet72_13 (net72_14 net72_15) resistor r=11.6604
    rnet72_12 (net72_14 net72_20) resistor r=10.2363
    rnet72_11 (net72_16 net72_18) resistor r=14.4784
    rnet72_10 (net72_16 net72_19) resistor r=9.04062
    rnet72_9 (net72_17 net72_18) resistor r=14.4784
    rnet72_8 (net72_17 net72) resistor r=10.5593
    rQ_130 (Q_22 Q_28) resistor r=58.3583
    rQ_129 (Q_22 Q_28) resistor r=4.16253
    rQ_128 (Q_22 Q_28) resistor r=58.3583
    rQ_127 (Q_22 Q_28) resistor r=4.16253
    rQ_126 (Q_25 Q_28) resistor r=58.3583
    rQ_125 (Q_25 Q_28) resistor r=4.16253
    rQ_124 (Q_25 Q_28) resistor r=58.3583
    rQ_123 (Q_25 Q_28) resistor r=4.16253
    rQ_122 (Q_28 Q_33) resistor r=22.35
    rQ_121 (Q_28 Q_30) resistor r=22.35
    rQ_120 (Q_28 Q_41) resistor r=24.8333
    rQ_119 (Q_28 Q_38) resistor r=24.8333
    rQ_118 (Q_28 Q_54) resistor r=11.175
    rQ_117 (Q_28 Q_76) resistor r=58.3583
    rQ_116 (Q_28 Q_79) resistor r=58.3583
    rQ_115 (Q_28 Q_33) resistor r=4.16253
    rQ_114 (Q_28 Q_41) resistor r=4.16253
    rQ_113 (Q_28 Q_76) resistor r=5.53947
    rQ_112 (Q_28 Q_54) resistor r=5.53947
    rQ_111 (Q_28 Q_30) resistor r=2.32428
    rQ_110 (Q_28 Q_38) resistor r=4.16253
    rQ_109 (Q_28 Q_79) resistor r=4.16253
    rQ_108 (Q_28 Q_33) resistor r=22.35
    rQ_107 (Q_28 Q_30) resistor r=22.35
    rQ_106 (Q_28 Q_41) resistor r=24.8333
    rQ_105 (Q_28 Q_38) resistor r=24.8333
    rQ_104 (Q_28 Q_199) resistor r=35.3875
    rQ_103 (Q_28 Q_54) resistor r=11.175
    rQ_102 (Q_28 Q_76) resistor r=58.3583
    rQ_101 (Q_28 MM9_ELT_g) resistor r=7.45
    rQ_100 (Q_28 Q_33) resistor r=4.16253
    rQ_99 (Q_28 Q_41) resistor r=4.16253
    rQ_98 (Q_28 Q_76) resistor r=5.53947
    rQ_97 (Q_28 Q_54) resistor r=5.53947
    rQ_96 (Q_28 Q_30) resistor r=2.32428
    rQ_95 (Q_28 Q_38) resistor r=4.16253
    rQ_94 (Q_28 Q_79) resistor r=4.16253
    rQ_93 (Q_46 Q_52) resistor r=58.3583
    rQ_92 (Q_46 Q_52) resistor r=4.16253
    rQ_91 (Q_46 Q_52) resistor r=58.3583
    rQ_90 (Q_46 Q_52) resistor r=4.16253
    rQ_89 (Q_49 Q_52) resistor r=58.3583
    rQ_88 (Q_49 Q_52) resistor r=4.16253
    rQ_87 (Q_49 Q_52) resistor r=58.3583
    rQ_86 (Q_49 Q_52) resistor r=4.16253
    rQ_85 (Q_52 Q_63) resistor r=24.8333
    rQ_84 (Q_52 Q_60) resistor r=24.8333
    rQ_83 (Q_52 Q_71) resistor r=22.35
    rQ_82 (Q_52 Q_68) resistor r=22.35
    rQ_81 (Q_52 Q_84) resistor r=11.175
    rQ_80 (Q_52 Q_90) resistor r=58.3583
    rQ_79 (Q_52 Q_93) resistor r=58.3583
    rQ_78 (Q_52 Q_63) resistor r=4.16253
    rQ_77 (Q_52 Q_71) resistor r=4.16253
    rQ_76 (Q_52 Q_84) resistor r=5.53947
    rQ_75 (Q_52 Q_93) resistor r=5.53947
    rQ_74 (Q_52 Q_68) resistor r=2.32428
    rQ_73 (Q_52 Q_60) resistor r=4.16253
    rQ_72 (Q_52 Q_90) resistor r=4.16253
    rQ_71 (Q_52 Q_63) resistor r=24.8333
    rQ_70 (Q_52 Q_60) resistor r=24.8333
    rQ_69 (Q_52 Q_71) resistor r=22.35
    rQ_68 (Q_52 Q_68) resistor r=22.35
    rQ_67 (Q_52 Q_84) resistor r=11.175
    rQ_66 (Q_52 Q_214) resistor r=30.7313
    rQ_65 (Q_52 Q_90) resistor r=58.3583
    rQ_64 (Q_52 MM12_ELT_g) resistor r=22.35
    rQ_63 (Q_52 Q_63) resistor r=4.16253
    rQ_62 (Q_52 Q_71) resistor r=4.16253
    rQ_61 (Q_52 Q_84) resistor r=5.53947
    rQ_60 (Q_52 Q_93) resistor r=5.53947
    rQ_59 (Q_52 Q_68) resistor r=2.32428
    rQ_58 (Q_52 Q_60) resistor r=4.16253
    rQ_57 (Q_52 Q_90) resistor r=4.16253
    rQ_56 (Q_79 MM9_ELT_g) resistor r=50.9083
    rQ_55 (Q_93 MM12_ELT_g) resistor r=36.0083
    rQ_54 (Q_131 Q_133) resistor r=0.796381
    rQ_53 (Q_131 Q_137) resistor r=0.0970345
    rQ_52 (Q_133 Q_134) resistor r=10
    rQ_51 (Q_134 Q_231) resistor r=0.677273
    rQ_50 (Q_136 Q_137) resistor r=1.25667
    rQ_49 (Q_136 Q_139) resistor r=0.0961132
    rQ_48 (Q_138 Q_139) resistor r=0.439996
    rQ_47 (Q_138 Q_164) resistor r=0.0466572
    rQ_46 (Q_140 Q_142) resistor r=0.303835
    rQ_45 (Q_140 Q_160) resistor r=0.0101026
    rQ_44 (Q_142 Q_143) resistor r=13
    rQ_43 (Q_143 MM7_ELT_d) resistor r=8.44
    rQ_42 (Q_145 Q_147) resistor r=0.442427
    rQ_41 (Q_145 Q_164) resistor r=0.0101026
    rQ_40 (Q_147 Q_148) resistor r=8.66667
    rQ_39 (Q_147 Q_150) resistor r=0.639653
    rQ_38 (Q_148 MM6_ELT_d) resistor r=32.3614
    rQ_37 (Q_150 Q_151) resistor r=8.66667
    rQ_36 (Q_150 Q_153) resistor r=0.426436
    rQ_35 (Q_151 MM6_ELT_d) resistor r=16.1807
    rQ_34 (Q_151 Q_154) resistor r=32.3614
    rQ_33 (Q_153 Q_154) resistor r=26
    rQ_32 (Q_156 Q) resistor r=0.156186
    rQ_31 (Q_156 Q_162) resistor r=0.0101026
    rQ_30 (Q_157 Q) resistor r=0.497975
    rQ_29 (Q_157 Q_165) resistor r=0.0101026
    rQ_28 (Q_160 Q_162) resistor r=0.151143
    rQ_27 (Q_164 Q_165) resistor r=0.155524
    rQ_26 (Q_199 Q_231) resistor r=3.1797
    rQ_25 (Q_214 Q_232) resistor r=3.1797
    rQ_24 (Q_231 Q_232) resistor r=25.7364
    rVDD_177 (MM28_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_176 (MM15_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_175 (MM14_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_174 (MM10_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_173 (MM9_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_172 (MM8_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_171 (MM6_ELT_b MM1_ELT_b) resistor r=0.01
    rVDD_170 (MM1_ELT_b VDD_39) resistor r=8.66667
    rVDD_169 (MM1_ELT_b VDD_49) resistor r=8.66667
    rVDD_168 (MM1_ELT_b VDD_64) resistor r=8.66667
    rVDD_167 (MM1_ELT_b VDD_67) resistor r=13
    rVDD_166 (MM1_ELT_b VDD_37) resistor r=22.5067
    rVDD_165 (VDD_2 VDD_7) resistor r=0.114619
    rVDD_164 (VDD_2 VDD_70) resistor r=0.0221516
    rVDD_163 (VDD VDD_7) resistor r=0.102761
    rVDD_162 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_161 (VDD_8 VDD_24) resistor r=67.52
    rVDD_160 (VDD_9 VDD_18) resistor r=0.538409
    rVDD_159 (VDD_9 VDD_70) resistor r=0.0882598
    rVDD_158 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_157 (VDD_11 VDD_15) resistor r=0.702272
    rVDD_156 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_155 (VDD_15 VDD_18) resistor r=0.468181
    rVDD_154 (VDD_18 VDD_19) resistor r=13
    rVDD_153 (VDD_19 MM28_ELT_s) resistor r=4.04518
    rVDD_152 (VDD_19 VDD_121) resistor r=4.04518
    rVDD_151 (VDD_19 MM1_ELT_s) resistor r=4.04518
    rVDD_150 (VDD_19 VDD_119) resistor r=4.04518
    rVDD_149 (VDD_20 VDD_23) resistor r=0.167975
    rVDD_148 (VDD_20 VDD_71) resistor r=0.0221516
    rVDD_147 (VDD_21 VDD_23) resistor r=0.086952
    rVDD_146 (VDD_21 VDD_70) resistor r=0.0221516
    rVDD_145 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_144 (VDD_24 VDD_34) resistor r=67.52
    rVDD_143 (VDD_25 VDD_27) resistor r=0.511723
    rVDD_142 (VDD_25 VDD_71) resistor r=0.0882598
    rVDD_141 (VDD_27 VDD_28) resistor r=8.66667
    rVDD_140 (VDD_28 VDD_124) resistor r=16.4995
    rVDD_139 (VDD_28 VDD_123) resistor r=16.4995
    rVDD_138 (VDD_28 MM14_ELT_s) resistor r=3.29107
    rVDD_137 (VDD_30 VDD_39) resistor r=0.0335951
    rVDD_136 (VDD_30 VDD_72) resistor r=0.0221516
    rVDD_135 (VDD_31 VDD_33) resistor r=0.0335951
    rVDD_134 (VDD_31 VDD_71) resistor r=0.0221516
    rVDD_133 (VDD_33 VDD_34) resistor r=8.66667
    rVDD_132 (VDD_33 VDD_36) resistor r=0.237142
    rVDD_131 (VDD_34 VDD_37) resistor r=67.52
    rVDD_130 (VDD_36 VDD_37) resistor r=8.66667
    rVDD_129 (VDD_36 VDD_39) resistor r=0.237142
    rVDD_128 (VDD_41 VDD_43) resistor r=0.566173
    rVDD_127 (VDD_41 VDD_72) resistor r=0.0882598
    rVDD_126 (VDD_43 VDD_44) resistor r=13
    rVDD_125 (VDD_44 MM9_ELT_s) resistor r=8.09035
    rVDD_124 (VDD_46 VDD_49) resistor r=0.167975
    rVDD_123 (VDD_46 VDD_73) resistor r=0.0221516
    rVDD_122 (VDD_47 VDD_49) resistor r=0.167975
    rVDD_121 (VDD_47 VDD_72) resistor r=0.0221516
    rVDD_120 (VDD_51 VDD_60) resistor r=0.538409
    rVDD_119 (VDD_51 VDD_73) resistor r=0.0882598
    rVDD_118 (VDD_53 VDD_54) resistor r=8.66667
    rVDD_117 (VDD_53 VDD_57) resistor r=0.850958
    rVDD_116 (VDD_54 MM6_ELT_s) resistor r=2.31356
    rVDD_115 (VDD_54 VDD_142) resistor r=15.7867
    rVDD_114 (VDD_57 VDD_58) resistor r=8.66667
    rVDD_113 (VDD_57 VDD_60) resistor r=0.468181
    rVDD_112 (VDD_58 MM6_ELT_s) resistor r=3.65427
    rVDD_111 (VDD_58 VDD_144) resistor r=3.65427
    rVDD_110 (VDD_58 VDD_108) resistor r=4.45033
    rVDD_109 (VDD_58 VDD_142) resistor r=4.45033
    rVDD_108 (VDD_60 VDD_61) resistor r=13
    rVDD_107 (VDD_61 MM6_ELT_s) resistor r=4.04518
    rVDD_106 (VDD_61 VDD_125) resistor r=4.04518
    rVDD_105 (VDD_61 MM8_ELT_s) resistor r=4.04518
    rVDD_104 (VDD_61 VDD_144) resistor r=4.04518
    rVDD_103 (VDD_62 VDD_64) resistor r=0.0335951
    rVDD_102 (VDD_62 VDD_73) resistor r=0.0221516
    rVDD_101 (VDD_64 VDD_67) resistor r=0.158095
    rVDD_100 (MM1_ELT_s VDD_77) resistor r=25.7298
    rVDD_99 (MM1_ELT_s VDD_80) resistor r=2.55965
    rVDD_98 (MM1_ELT_s VDD_82) resistor r=12.3172
    rVDD_97 (MM1_ELT_s VDD_82) resistor r=1.62887
    rVDD_96 (VDD_77 VDD_79) resistor r=9.04062
    rVDD_95 (VDD_78 VDD_80) resistor r=14.4784
    rVDD_94 (VDD_78 VDD_122) resistor r=10.5593
    rVDD_93 (VDD_79 VDD_80) resistor r=14.4784
    rVDD_92 (VDD_81 VDD_82) resistor r=12.3172
    rVDD_91 (VDD_81 VDD_120) resistor r=10.2363
    rVDD_90 (MM28_ELT_s VDD_86) resistor r=2.55965
    rVDD_89 (MM28_ELT_s VDD_88) resistor r=12.3172
    rVDD_88 (MM28_ELT_s VDD_88) resistor r=1.62887
    rVDD_87 (MM28_ELT_s VDD_91) resistor r=6.12113
    rVDD_86 (MM28_ELT_s VDD_120) resistor r=10.2363
    rVDD_85 (VDD_84 VDD_86) resistor r=14.4784
    rVDD_84 (VDD_84 VDD_90) resistor r=9.04062
    rVDD_83 (VDD_85 VDD_86) resistor r=14.4784
    rVDD_82 (VDD_85 VDD_122) resistor r=10.5593
    rVDD_81 (VDD_87 VDD_88) resistor r=12.3172
    rVDD_80 (VDD_87 VDD_89) resistor r=9.04595
    rVDD_79 (VDD_89 VDD_91) resistor r=31.2341
    rVDD_78 (VDD_90 VDD_91) resistor r=31.2341
    rVDD_77 (MM14_ELT_s VDD_94) resistor r=12.3172
    rVDD_76 (MM14_ELT_s VDD_94) resistor r=1.62887
    rVDD_75 (MM14_ELT_s VDD_97) resistor r=2.55965
    rVDD_74 (MM14_ELT_s VDD_98) resistor r=17.3029
    rVDD_73 (VDD_93 VDD_94) resistor r=12.3172
    rVDD_72 (VDD_93 VDD_123) resistor r=9.39461
    rVDD_71 (VDD_95 VDD_97) resistor r=14.4784
    rVDD_70 (VDD_95 VDD_98) resistor r=9.04062
    rVDD_69 (VDD_96 VDD_97) resistor r=14.4784
    rVDD_68 (VDD_96 VDD_124) resistor r=9.48555
    rVDD_67 (VDD_99 VDD_102) resistor r=20.2547
    rVDD_66 (VDD_99 VDD_103) resistor r=9.04595
    rVDD_65 (VDD_100 VDD_102) resistor r=20.2547
    rVDD_64 (VDD_100 VDD_106) resistor r=9.04062
    rVDD_63 (MM8_ELT_s VDD_102) resistor r=4.36821
    rVDD_62 (MM8_ELT_s VDD_104) resistor r=7.31976
    rVDD_61 (MM8_ELT_s VDD_104) resistor r=1.40052
    rVDD_60 (MM8_ELT_s VDD_107) resistor r=2.55965
    rVDD_59 (MM8_ELT_s VDD_109) resistor r=7.31976
    rVDD_58 (MM8_ELT_s VDD_109) resistor r=1.40052
    rVDD_57 (VDD_103 VDD_104) resistor r=7.31976
    rVDD_56 (VDD_105 VDD_107) resistor r=14.4784
    rVDD_55 (VDD_105 VDD_126) resistor r=10.5593
    rVDD_54 (VDD_106 VDD_107) resistor r=14.4784
    rVDD_53 (VDD_108 VDD_109) resistor r=7.31976
    rVDD_52 (MM6_ELT_s VDD_113) resistor r=2.55965
    rVDD_51 (MM6_ELT_s VDD_115) resistor r=11.6604
    rVDD_50 (MM6_ELT_s VDD_115) resistor r=1.30988
    rVDD_49 (MM6_ELT_s VDD_118) resistor r=6.12113
    rVDD_48 (VDD_111 VDD_113) resistor r=14.4784
    rVDD_47 (VDD_111 VDD_117) resistor r=9.04062
    rVDD_46 (VDD_112 VDD_113) resistor r=14.4784
    rVDD_45 (VDD_112 VDD_126) resistor r=10.5593
    rVDD_44 (VDD_114 VDD_115) resistor r=11.6604
    rVDD_43 (VDD_114 VDD_116) resistor r=9.04595
    rVDD_42 (VDD_116 VDD_118) resistor r=31.2341
    rVDD_41 (VDD_117 VDD_118) resistor r=31.2341
    rVDD_40 (VDD_119 VDD_120) resistor r=0.549089
    rVDD_39 (VDD_121 VDD_122) resistor r=0.730683
    rVDD_38 (VDD_125 VDD_126) resistor r=0.730683
    rVSS_144 (MM29_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_143 (MM16_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_142 (MM17_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_141 (MM11_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_140 (MM18_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_139 (MM12_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_138 (MM13_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_137 (MM7_ELT_b MM0_ELT_b) resistor r=0.01
    rVSS_136 (MM0_ELT_b VSS_26) resistor r=8.66667
    rVSS_135 (MM0_ELT_b VSS_36) resistor r=8.66667
    rVSS_134 (MM0_ELT_b VSS_48) resistor r=8.66667
    rVSS_133 (MM0_ELT_b VSS_51) resistor r=13
    rVSS_132 (MM0_ELT_b VSS_24) resistor r=21.5743
    rVSS_131 (VSS_2 VSS_7) resistor r=0.114619
    rVSS_130 (VSS_2 VSS_54) resistor r=0.0221516
    rVSS_129 (VSS VSS_7) resistor r=0.100785
    rVSS_128 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_127 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_126 (VSS_9 VSS_11) resistor r=0.43892
    rVSS_125 (VSS_9 VSS_54) resistor r=0.0882598
    rVSS_124 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_123 (VSS_12 MM29_ELT_s) resistor r=4.22001
    rVSS_122 (VSS_12 VSS_102) resistor r=4.22001
    rVSS_121 (VSS_12 MM0_ELT_s) resistor r=4.22001
    rVSS_120 (VSS_12 VSS_100) resistor r=4.22001
    rVSS_119 (VSS_14 VSS_26) resistor r=0.114619
    rVSS_118 (VSS_14 VSS_55) resistor r=0.0221516
    rVSS_117 (VSS_15 VSS_17) resistor r=0.086952
    rVSS_116 (VSS_15 VSS_54) resistor r=0.0221516
    rVSS_115 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_114 (VSS_17 VSS_20) resistor r=0.237142
    rVSS_113 (VSS_18 VSS_21) resistor r=64.7228
    rVSS_112 (VSS_20 VSS_21) resistor r=8.66667
    rVSS_111 (VSS_20 VSS_23) resistor r=0.237484
    rVSS_110 (VSS_21 VSS_24) resistor r=64.7228
    rVSS_109 (VSS_23 VSS_24) resistor r=8.66667
    rVSS_108 (VSS_23 VSS_26) resistor r=0.237142
    rVSS_107 (VSS_28 VSS_30) resistor r=0.43892
    rVSS_106 (VSS_28 VSS_55) resistor r=0.0882598
    rVSS_105 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_104 (VSS_31 MM13_ELT_s) resistor r=2.27123
    rVSS_103 (VSS_31 MM18_ELT_s) resistor r=2.27123
    rVSS_102 (VSS_31 VSS_104) resistor r=8.4738
    rVSS_101 (VSS_33 VSS_36) resistor r=0.167975
    rVSS_100 (VSS_33 VSS_56) resistor r=0.0221516
    rVSS_99 (VSS_34 VSS_36) resistor r=0.086952
    rVSS_98 (VSS_34 VSS_55) resistor r=0.0221516
    rVSS_97 (VSS_38 VSS_40) resistor r=0.399783
    rVSS_96 (VSS_38 VSS_56) resistor r=0.0882598
    rVSS_95 (VSS_40 VSS_44) resistor r=8.66667
    rVSS_94 (VSS_40 VSS_43) resistor r=0.426436
    rVSS_93 (VSS_43 VSS_44) resistor r=26
    rVSS_92 (VSS_44 MM7_ELT_s) resistor r=2.90692
    rVSS_91 (VSS_44 VSS_106) resistor r=12.1406
    rVSS_90 (VSS_46 VSS_48) resistor r=0.0335951
    rVSS_89 (VSS_46 VSS_56) resistor r=0.0221516
    rVSS_88 (VSS_48 VSS_51) resistor r=0.158095
    rVSS_87 (MM0_ELT_s VSS_58) resistor r=18.0507
    rVSS_86 (MM0_ELT_s VSS_61) resistor r=2.67027
    rVSS_85 (MM0_ELT_s VSS_63) resistor r=12.8495
    rVSS_84 (MM0_ELT_s VSS_63) resistor r=1.69926
    rVSS_83 (VSS_58 VSS_60) resistor r=9.43134
    rVSS_82 (VSS_59 VSS_61) resistor r=15.1041
    rVSS_81 (VSS_59 VSS_101) resistor r=11.0157
    rVSS_80 (VSS_60 VSS_61) resistor r=15.1041
    rVSS_79 (VSS_62 VSS_63) resistor r=12.8495
    rVSS_78 (VSS_62 VSS_103) resistor r=10.6787
    rVSS_77 (MM29_ELT_s VSS_67) resistor r=2.67027
    rVSS_76 (MM29_ELT_s VSS_69) resistor r=12.8495
    rVSS_75 (MM29_ELT_s VSS_69) resistor r=1.69926
    rVSS_74 (MM29_ELT_s VSS_72) resistor r=4.557
    rVSS_73 (MM29_ELT_s VSS_103) resistor r=10.6787
    rVSS_72 (VSS_65 VSS_67) resistor r=15.1041
    rVSS_71 (VSS_65 VSS_70) resistor r=9.43134
    rVSS_70 (VSS_66 VSS_67) resistor r=15.1041
    rVSS_69 (VSS_66 VSS_101) resistor r=11.0157
    rVSS_68 (VSS_68 VSS_69) resistor r=12.8495
    rVSS_67 (VSS_68 VSS_71) resistor r=9.4369
    rVSS_66 (VSS_70 VSS_72) resistor r=21.1301
    rVSS_65 (VSS_71 VSS_72) resistor r=21.1301
    rVSS_64 (VSS_73 VSS_76) resistor r=21.1301
    rVSS_63 (VSS_73 VSS_78) resistor r=9.43134
    rVSS_62 (VSS_74 VSS_76) resistor r=21.1301
    rVSS_61 (VSS_74 VSS_80) resistor r=9.4369
    rVSS_60 (MM18_ELT_s VSS_76) resistor r=4.557
    rVSS_59 (MM18_ELT_s VSS_79) resistor r=2.67027
    rVSS_58 (MM18_ELT_s VSS_81) resistor r=12.8495
    rVSS_57 (MM18_ELT_s VSS_81) resistor r=1.69926
    rVSS_56 (VSS_77 VSS_79) resistor r=15.1041
    rVSS_55 (VSS_77 VSS_105) resistor r=11.0157
    rVSS_54 (VSS_78 VSS_79) resistor r=15.1041
    rVSS_53 (VSS_80 VSS_81) resistor r=12.8495
    rVSS_52 (MM13_ELT_s VSS_85) resistor r=2.67027
    rVSS_51 (MM13_ELT_s VSS_87) resistor r=12.8495
    rVSS_50 (MM13_ELT_s VSS_87) resistor r=1.69926
    rVSS_49 (MM13_ELT_s VSS_90) resistor r=4.557
    rVSS_48 (VSS_83 VSS_85) resistor r=15.1041
    rVSS_47 (VSS_83 VSS_88) resistor r=9.43134
    rVSS_46 (VSS_84 VSS_85) resistor r=15.1041
    rVSS_45 (VSS_84 VSS_105) resistor r=11.0157
    rVSS_44 (VSS_86 VSS_87) resistor r=12.8495
    rVSS_43 (VSS_86 VSS_89) resistor r=9.4369
    rVSS_42 (VSS_88 VSS_90) resistor r=21.1301
    rVSS_41 (VSS_89 VSS_90) resistor r=21.1301
    rVSS_40 (MM7_ELT_s VSS_94) resistor r=2.67027
    rVSS_39 (MM7_ELT_s VSS_96) resistor r=12.1643
    rVSS_38 (MM7_ELT_s VSS_96) resistor r=1.36649
    rVSS_37 (MM7_ELT_s VSS_99) resistor r=4.557
    rVSS_36 (VSS_92 VSS_94) resistor r=15.1041
    rVSS_35 (VSS_92 VSS_97) resistor r=9.43134
    rVSS_34 (VSS_93 VSS_94) resistor r=15.1041
    rVSS_33 (VSS_93 VSS_106) resistor r=9.89549
    rVSS_32 (VSS_95 VSS_96) resistor r=12.1643
    rVSS_31 (VSS_95 VSS_98) resistor r=9.4369
    rVSS_30 (VSS_97 VSS_99) resistor r=21.1301
    rVSS_29 (VSS_98 VSS_99) resistor r=21.1301
    rVSS_28 (VSS_100 VSS_101) resistor r=0.762262
    rVSS_27 (VSS_102 VSS_103) resistor r=0.57282
    rVSS_26 (VSS_104 VSS_105) resistor r=0.762262
    rnet25_21 (MM13_ELT_d net25) resistor r=0.01
    rnet25_20 (net25_1 net25_3) resistor r=0.170828
    rnet25_19 (net25_1 net25_7) resistor r=0.0961132
    rnet25_18 (net25_3 net25_4) resistor r=13
    rnet25_17 (net25_4 MM12_ELT_s) resistor r=8.44
    rnet25_16 (net25_6 net25_7) resistor r=0.127248
    rnet25_15 (net25_6 net25_9) resistor r=0.0961132
    rnet25_14 (net25_8 net25_9) resistor r=0.705469
    rnet25_13 (net25_8 net25_15) resistor r=0.0101026
    rnet25_12 (net25_10 net25_12) resistor r=0.399783
    rnet25_11 (net25_10 net25_17) resistor r=0.0101026
    rnet25_10 (net25_12 net25_13) resistor r=13
    rnet25_9 (net25_13 net25) resistor r=8.44
    rnet25_8 (net25_15 net25_17) resistor r=0.0780929
    rnet20_18 (MM18_ELT_d net20) resistor r=0.01
    rnet20_17 (net20_1 net20_3) resistor r=0.0593537
    rnet20_16 (net20_1 net20_17) resistor r=0.0728416
    rnet20_15 (net20_3 net20_4) resistor r=13
    rnet20_14 (net20_4 MM17_ELT_s) resistor r=8.44
    rnet20_13 (net20_8 net20_9) resistor r=0.592392
    rnet20_12 (net20_8 net20_18) resistor r=0.0189303
    rnet20_11 (net20_9 net20_17) resistor r=0.0189303
    rnet20_10 (net20_10 net20_12) resistor r=0.0586349
    rnet20_9 (net20_10 net20_18) resistor r=0.0728416
    rnet20_8 (net20_12 net20_13) resistor r=13
    rnet20_7 (net20_13 net20) resistor r=8.44
    rCDN_158 (CDN_34 CDN_40) resistor r=58.3583
    rCDN_157 (CDN_34 CDN_40) resistor r=4.16253
    rCDN_156 (CDN_34 CDN_40) resistor r=58.3583
    rCDN_155 (CDN_34 CDN_40) resistor r=4.16253
    rCDN_154 (CDN_37 CDN_40) resistor r=58.3583
    rCDN_153 (CDN_37 CDN_40) resistor r=4.16253
    rCDN_152 (CDN_37 CDN_40) resistor r=58.3583
    rCDN_151 (CDN_37 CDN_40) resistor r=4.16253
    rCDN_150 (CDN_40 CDN_45) resistor r=24.8333
    rCDN_149 (CDN_40 CDN_42) resistor r=24.8333
    rCDN_148 (CDN_40 CDN_53) resistor r=24.8333
    rCDN_147 (CDN_40 CDN_50) resistor r=24.8333
    rCDN_146 (CDN_40 CDN_58) resistor r=58.3583
    rCDN_145 (CDN_40 CDN_61) resistor r=58.3583
    rCDN_144 (CDN_40 CDN_66) resistor r=14.9
    rCDN_143 (CDN_40 CDN_45) resistor r=4.16253
    rCDN_142 (CDN_40 CDN_53) resistor r=4.16253
    rCDN_141 (CDN_40 CDN_42) resistor r=4.16253
    rCDN_140 (CDN_40 CDN_58) resistor r=4.16253
    rCDN_139 (CDN_40 CDN_66) resistor r=6.30933
    rCDN_138 (CDN_40 CDN_61) resistor r=6.30933
    rCDN_137 (CDN_40 CDN_50) resistor r=1.63969
    rCDN_136 (CDN_40 CDN_45) resistor r=24.8333
    rCDN_135 (CDN_40 CDN_42) resistor r=24.8333
    rCDN_134 (CDN_40 CDN_53) resistor r=24.8333
    rCDN_133 (CDN_40 CDN_50) resistor r=24.8333
    rCDN_132 (CDN_40 CDN_58) resistor r=58.3583
    rCDN_131 (CDN_40 MM18_ELT_g) resistor r=22.35
    rCDN_130 (CDN_40 CDN_66) resistor r=14.9
    rCDN_129 (CDN_40 CDN_263) resistor r=39.7333
    rCDN_128 (CDN_40 CDN_45) resistor r=4.16253
    rCDN_127 (CDN_40 CDN_53) resistor r=4.16253
    rCDN_126 (CDN_40 CDN_42) resistor r=4.16253
    rCDN_125 (CDN_40 CDN_58) resistor r=4.16253
    rCDN_124 (CDN_40 CDN_66) resistor r=6.30933
    rCDN_123 (CDN_40 CDN_61) resistor r=6.30933
    rCDN_122 (CDN_40 CDN_50) resistor r=1.63969
    rCDN_121 (CDN_61 MM18_ELT_g) resistor r=36.0083
    rCDN_120 (CDN_72 CDN_78) resistor r=58.3583
    rCDN_119 (CDN_72 CDN_78) resistor r=4.16253
    rCDN_118 (CDN_72 CDN_78) resistor r=58.3583
    rCDN_117 (CDN_72 CDN_78) resistor r=4.16253
    rCDN_116 (CDN_75 CDN_78) resistor r=58.3583
    rCDN_115 (CDN_75 CDN_78) resistor r=6.30933
    rCDN_114 (CDN_75 CDN_78) resistor r=58.3583
    rCDN_113 (CDN_75 CDN_78) resistor r=6.30933
    rCDN_112 (CDN_78 CDN_80) resistor r=14.9
    rCDN_111 (CDN_78 CDN_89) resistor r=24.8333
    rCDN_110 (CDN_78 CDN_86) resistor r=24.8333
    rCDN_109 (CDN_78 CDN_97) resistor r=24.8333
    rCDN_108 (CDN_78 CDN_94) resistor r=24.8333
    rCDN_107 (CDN_78 CDN_110) resistor r=58.3583
    rCDN_106 (CDN_78 CDN_113) resistor r=58.3583
    rCDN_105 (CDN_78 CDN_89) resistor r=4.16253
    rCDN_104 (CDN_78 CDN_80) resistor r=6.30933
    rCDN_103 (CDN_78 CDN_97) resistor r=1.63969
    rCDN_102 (CDN_78 CDN_86) resistor r=4.16253
    rCDN_101 (CDN_78 CDN_110) resistor r=4.16253
    rCDN_100 (CDN_78 CDN_94) resistor r=4.16253
    rCDN_99 (CDN_78 CDN_113) resistor r=4.16253
    rCDN_98 (CDN_78 CDN_80) resistor r=14.9
    rCDN_97 (CDN_78 CDN_271) resistor r=39.7333
    rCDN_96 (CDN_78 CDN_89) resistor r=24.8333
    rCDN_95 (CDN_78 CDN_86) resistor r=24.8333
    rCDN_94 (CDN_78 CDN_97) resistor r=24.8333
    rCDN_93 (CDN_78 CDN_94) resistor r=24.8333
    rCDN_92 (CDN_78 CDN_110) resistor r=58.3583
    rCDN_91 (CDN_78 MM13_ELT_g) resistor r=7.45
    rCDN_90 (CDN_78 CDN_89) resistor r=4.16253
    rCDN_89 (CDN_78 CDN_80) resistor r=6.30933
    rCDN_88 (CDN_78 CDN_97) resistor r=1.63969
    rCDN_87 (CDN_78 CDN_86) resistor r=4.16253
    rCDN_86 (CDN_78 CDN_110) resistor r=4.16253
    rCDN_85 (CDN_78 CDN_94) resistor r=4.16253
    rCDN_84 (CDN_78 CDN_113) resistor r=4.16253
    rCDN_83 (CDN_102 CDN_108) resistor r=58.3583
    rCDN_82 (CDN_102 CDN_108) resistor r=4.16253
    rCDN_81 (CDN_102 CDN_108) resistor r=58.3583
    rCDN_80 (CDN_102 CDN_108) resistor r=4.16253
    rCDN_79 (CDN_105 CDN_108) resistor r=58.3583
    rCDN_78 (CDN_105 CDN_108) resistor r=4.16253
    rCDN_77 (CDN_105 CDN_108) resistor r=58.3583
    rCDN_76 (CDN_105 CDN_108) resistor r=4.16253
    rCDN_75 (CDN_108 CDN_121) resistor r=8.69167
    rCDN_74 (CDN_108 CDN_118) resistor r=8.69167
    rCDN_73 (CDN_108 CDN_129) resistor r=24.8333
    rCDN_72 (CDN_108 CDN_126) resistor r=24.8333
    rCDN_71 (CDN_108 CDN_134) resistor r=14.9
    rCDN_70 (CDN_108 CDN_143) resistor r=8.69167
    rCDN_69 (CDN_108 CDN_140) resistor r=8.69167
    rCDN_68 (CDN_108 CDN_148) resistor r=58.3583
    rCDN_67 (CDN_108 CDN_151) resistor r=58.3583
    rCDN_66 (CDN_108 CDN_121) resistor r=4.16253
    rCDN_65 (CDN_108 CDN_129) resistor r=4.16253
    rCDN_64 (CDN_108 CDN_143) resistor r=6.30933
    rCDN_63 (CDN_108 CDN_118) resistor r=6.30933
    rCDN_62 (CDN_108 CDN_134) resistor r=1.63969
    rCDN_61 (CDN_108 CDN_140) resistor r=4.16253
    rCDN_60 (CDN_108 CDN_148) resistor r=4.16253
    rCDN_59 (CDN_108 CDN_126) resistor r=4.16253
    rCDN_58 (CDN_108 CDN_151) resistor r=4.16253
    rCDN_57 (CDN_108 CDN_121) resistor r=8.69167
    rCDN_56 (CDN_108 CDN_118) resistor r=8.69167
    rCDN_55 (CDN_108 CDN_129) resistor r=24.8333
    rCDN_54 (CDN_108 CDN_126) resistor r=24.8333
    rCDN_53 (CDN_108 CDN_295) resistor r=330.283
    rCDN_52 (CDN_108 CDN_134) resistor r=14.9
    rCDN_51 (CDN_108 CDN_143) resistor r=8.69167
    rCDN_50 (CDN_108 CDN_140) resistor r=8.69167
    rCDN_49 (CDN_108 CDN_148) resistor r=58.3583
    rCDN_48 (CDN_108 MM8_ELT_g) resistor r=7.45
    rCDN_47 (CDN_108 CDN_121) resistor r=4.16253
    rCDN_46 (CDN_108 CDN_129) resistor r=4.16253
    rCDN_45 (CDN_108 CDN_143) resistor r=6.30933
    rCDN_44 (CDN_108 CDN_118) resistor r=6.30933
    rCDN_43 (CDN_108 CDN_134) resistor r=1.63969
    rCDN_42 (CDN_108 CDN_140) resistor r=4.16253
    rCDN_41 (CDN_108 CDN_148) resistor r=4.16253
    rCDN_40 (CDN_108 CDN_126) resistor r=4.16253
    rCDN_39 (CDN_108 CDN_151) resistor r=4.16253
    rCDN_38 (CDN_113 MM13_ELT_g) resistor r=50.9083
    rCDN_37 (CDN_151 MM8_ELT_g) resistor r=50.9083
    rCDN_36 (CDN CDN_214) resistor r=10
    rCDN_35 (CDN_214 CDN_310) resistor r=11.5136
    rCDN_34 (CDN_263 CDN_311) resistor r=4.38767
    rCDN_33 (CDN_265 CDN_266) resistor r=27.0909
    rCDN_32 (CDN_265 CDN_314) resistor r=3.71511
    rCDN_31 (CDN_266 CDN_311) resistor r=3.71511
    rCDN_30 (CDN_271 CDN_314) resistor r=4.38767
    rCDN_29 (CDN_279 CDN_280) resistor r=38.6045
    rCDN_28 (CDN_279 CDN_295) resistor r=9.29775
    rCDN_27 (CDN_280 CDN_314) resistor r=3.71511
    rCDN_26 (CDN_310 CDN_311) resistor r=3.71511
    rD_102 (D_22 D_28) resistor r=58.3583
    rD_101 (D_22 D_28) resistor r=4.16253
    rD_100 (D_22 D_28) resistor r=58.3583
    rD_99 (D_22 D_28) resistor r=4.16253
    rD_98 (D_25 D_28) resistor r=58.3583
    rD_97 (D_25 D_28) resistor r=4.16253
    rD_96 (D_25 D_28) resistor r=58.3583
    rD_95 (D_25 D_28) resistor r=4.16253
    rD_94 (D_28 D_33) resistor r=24.8333
    rD_93 (D_28 D_30) resistor r=24.8333
    rD_92 (D_28 D_41) resistor r=24.8333
    rD_91 (D_28 D_38) resistor r=24.8333
    rD_90 (D_28 D_46) resistor r=14.9
    rD_89 (D_28 D_52) resistor r=58.3583
    rD_88 (D_28 D_55) resistor r=58.3583
    rD_87 (D_28 D_33) resistor r=4.16253
    rD_86 (D_28 D_41) resistor r=4.16253
    rD_85 (D_28 D_52) resistor r=6.30933
    rD_84 (D_28 D_46) resistor r=6.30933
    rD_83 (D_28 D_30) resistor r=1.63969
    rD_82 (D_28 D_38) resistor r=4.16253
    rD_81 (D_28 D_55) resistor r=4.16253
    rD_80 (D_28 D_33) resistor r=24.8333
    rD_79 (D_28 D_30) resistor r=24.8333
    rD_78 (D_28 D_41) resistor r=24.8333
    rD_77 (D_28 D_38) resistor r=24.8333
    rD_76 (D_28 D_166) resistor r=47.1833
    rD_75 (D_28 D_46) resistor r=14.9
    rD_74 (D_28 D_52) resistor r=58.3583
    rD_73 (D_28 MM14_ELT_g) resistor r=7.45
    rD_72 (D_28 D_33) resistor r=4.16253
    rD_71 (D_28 D_41) resistor r=4.16253
    rD_70 (D_28 D_52) resistor r=6.30933
    rD_69 (D_28 D_46) resistor r=6.30933
    rD_68 (D_28 D_30) resistor r=1.63969
    rD_67 (D_28 D_38) resistor r=4.16253
    rD_66 (D_28 D_55) resistor r=4.16253
    rD_65 (D_55 MM14_ELT_g) resistor r=50.9083
    rD_64 (D_60 D_66) resistor r=58.3583
    rD_63 (D_60 D_66) resistor r=4.16253
    rD_62 (D_60 D_66) resistor r=58.3583
    rD_61 (D_60 D_66) resistor r=4.16253
    rD_60 (D_63 D_66) resistor r=58.3583
    rD_59 (D_63 D_66) resistor r=6.30933
    rD_58 (D_63 D_66) resistor r=58.3583
    rD_57 (D_63 D_66) resistor r=6.30933
    rD_56 (D_66 D_68) resistor r=14.9
    rD_55 (D_66 D_77) resistor r=24.8333
    rD_54 (D_66 D_74) resistor r=24.8333
    rD_53 (D_66 D_85) resistor r=24.8333
    rD_52 (D_66 D_82) resistor r=24.8333
    rD_51 (D_66 D_90) resistor r=58.3583
    rD_50 (D_66 D_93) resistor r=58.3583
    rD_49 (D_66 D_77) resistor r=4.16253
    rD_48 (D_66 D_68) resistor r=6.30933
    rD_47 (D_66 D_85) resistor r=1.63969
    rD_46 (D_66 D_74) resistor r=4.16253
    rD_45 (D_66 D_90) resistor r=4.16253
    rD_44 (D_66 D_82) resistor r=4.16253
    rD_43 (D_66 D_93) resistor r=4.16253
    rD_42 (D_66 D_68) resistor r=14.9
    rD_41 (D_66 D_180) resistor r=39.7333
    rD_40 (D_66 D_77) resistor r=24.8333
    rD_39 (D_66 D_74) resistor r=24.8333
    rD_38 (D_66 D_85) resistor r=24.8333
    rD_37 (D_66 D_82) resistor r=24.8333
    rD_36 (D_66 D_90) resistor r=58.3583
    rD_35 (D_66 MM17_ELT_g) resistor r=7.45
    rD_34 (D_66 D_77) resistor r=4.16253
    rD_33 (D_66 D_68) resistor r=6.30933
    rD_32 (D_66 D_85) resistor r=1.63969
    rD_31 (D_66 D_74) resistor r=4.16253
    rD_30 (D_66 D_90) resistor r=4.16253
    rD_29 (D_66 D_82) resistor r=4.16253
    rD_28 (D_66 D_93) resistor r=4.16253
    rD_27 (D_93 MM17_ELT_g) resistor r=50.9083
    rD_26 (D D_135) resistor r=10
    rD_25 (D_135 D_201) resistor r=16.9318
    rD_24 (D_166 D_175) resistor r=9.29775
    rD_23 (D_174 D_175) resistor r=22.35
    rD_22 (D_174 D_183) resistor r=9.29775
    rD_21 (D_180 D_202) resistor r=10.0997
    rD_20 (D_182 D_183) resistor r=255.783
    rD_19 (D_182 D_202) resistor r=10.0997
    rD_18 (D_201 D_202) resistor r=0.877078
    rnet49_20 (MM14_ELT_d net49) resistor r=0.01
    rnet49_19 (net49_1 net49_3) resistor r=0.458825
    rnet49_18 (net49_1 net49_13) resistor r=0.0101026
    rnet49_17 (net49_3 net49_4) resistor r=13
    rnet49_16 (net49_4 MM15_ELT_s) resistor r=8.09035
    rnet49_15 (net49_6 net49_8) resistor r=0.266522
    rnet49_14 (net49_6 net49_17) resistor r=0.0101026
    rnet49_13 (net49_8 net49_9) resistor r=13
    rnet49_12 (net49_9 net49) resistor r=8.09035
    rnet49_11 (net49_11 net49_12) resistor r=0.402211
    rnet49_10 (net49_11 net49_15) resistor r=0.0101026
    rnet49_9 (net49_12 net49_19) resistor r=0.0101026
    rnet49_8 (net49_13 net49_15) resistor r=0.0927353
    rnet49_7 (net49_17 net49_19) resistor r=0.0927353
    rnet67_190 (MM8_ELT_d net67) resistor r=0.01
    rnet67_189 (net67_22 net67_28) resistor r=58.3583
    rnet67_188 (net67_22 net67_28) resistor r=4.16253
    rnet67_187 (net67_22 net67_28) resistor r=58.3583
    rnet67_186 (net67_22 net67_28) resistor r=4.16253
    rnet67_185 (net67_25 net67_28) resistor r=58.3583
    rnet67_184 (net67_25 net67_28) resistor r=5.53947
    rnet67_183 (net67_25 net67_28) resistor r=58.3583
    rnet67_182 (net67_25 net67_28) resistor r=5.53947
    rnet67_181 (net67_28 net67_30) resistor r=11.175
    rnet67_180 (net67_28 net67_53) resistor r=24.8333
    rnet67_179 (net67_28 net67_50) resistor r=24.8333
    rnet67_178 (net67_28 net67_69) resistor r=22.35
    rnet67_177 (net67_28 net67_66) resistor r=22.35
    rnet67_176 (net67_28 net67_82) resistor r=58.3583
    rnet67_175 (net67_28 net67_85) resistor r=58.3583
    rnet67_174 (net67_28 net67_53) resistor r=4.16253
    rnet67_173 (net67_28 net67_30) resistor r=5.53947
    rnet67_172 (net67_28 net67_69) resistor r=2.32428
    rnet67_171 (net67_28 net67_50) resistor r=4.16253
    rnet67_170 (net67_28 net67_82) resistor r=4.16253
    rnet67_169 (net67_28 net67_66) resistor r=4.16253
    rnet67_168 (net67_28 net67_85) resistor r=4.16253
    rnet67_167 (net67_28 net67_30) resistor r=11.175
    rnet67_166 (net67_28 net67_218) resistor r=29.8
    rnet67_165 (net67_28 net67_53) resistor r=24.8333
    rnet67_164 (net67_28 net67_50) resistor r=24.8333
    rnet67_163 (net67_28 net67_69) resistor r=22.35
    rnet67_162 (net67_28 net67_66) resistor r=22.35
    rnet67_161 (net67_28 net67_82) resistor r=58.3583
    rnet67_160 (net67_28 MM7_ELT_g) resistor r=7.45
    rnet67_159 (net67_28 net67_53) resistor r=4.16253
    rnet67_158 (net67_28 net67_30) resistor r=5.53947
    rnet67_157 (net67_28 net67_69) resistor r=2.32428
    rnet67_156 (net67_28 net67_50) resistor r=4.16253
    rnet67_155 (net67_28 net67_82) resistor r=4.16253
    rnet67_154 (net67_28 net67_66) resistor r=4.16253
    rnet67_153 (net67_28 net67_85) resistor r=4.16253
    rnet67_152 (net67_36 net67_39) resistor r=11.175
    rnet67_151 (net67_36 net67_39) resistor r=5.53947
    rnet67_150 (net67_36 net67_39) resistor r=11.175
    rnet67_149 (net67_36 net67_39) resistor r=5.53947
    rnet67_148 (net67_39 net67_42) resistor r=202.392
    rnet67_147 (net67_39 net67_45) resistor r=202.392
    rnet67_146 (net67_39 net67_61) resistor r=24.8333
    rnet67_145 (net67_39 net67_58) resistor r=24.8333
    rnet67_144 (net67_39 net67_77) resistor r=22.35
    rnet67_143 (net67_39 net67_74) resistor r=22.35
    rnet67_142 (net67_39 net67_90) resistor r=202.392
    rnet67_141 (net67_39 net67_93) resistor r=202.392
    rnet67_140 (net67_39 net67_42) resistor r=5.53947
    rnet67_139 (net67_39 net67_77) resistor r=2.32428
    rnet67_138 (net67_39 net67_61) resistor r=4.16253
    rnet67_137 (net67_39 net67_45) resistor r=4.16253
    rnet67_136 (net67_39 net67_74) resistor r=4.16253
    rnet67_135 (net67_39 net67_90) resistor r=4.16253
    rnet67_134 (net67_39 net67_58) resistor r=4.16253
    rnet67_133 (net67_39 net67_93) resistor r=4.16253
    rnet67_132 (net67_39 net67_220) resistor r=31.6625
    rnet67_131 (net67_39 net67_42) resistor r=202.392
    rnet67_130 (net67_39 net67_45) resistor r=202.392
    rnet67_129 (net67_39 net67_61) resistor r=24.8333
    rnet67_128 (net67_39 net67_58) resistor r=24.8333
    rnet67_127 (net67_39 net67_77) resistor r=22.35
    rnet67_126 (net67_39 net67_74) resistor r=22.35
    rnet67_125 (net67_39 net67_90) resistor r=202.392
    rnet67_124 (net67_39 MM6_ELT_g) resistor r=7.45
    rnet67_123 (net67_39 net67_42) resistor r=5.53947
    rnet67_122 (net67_39 net67_77) resistor r=2.32428
    rnet67_121 (net67_39 net67_61) resistor r=4.16253
    rnet67_120 (net67_39 net67_45) resistor r=4.16253
    rnet67_119 (net67_39 net67_74) resistor r=4.16253
    rnet67_118 (net67_39 net67_90) resistor r=4.16253
    rnet67_117 (net67_39 net67_58) resistor r=4.16253
    rnet67_116 (net67_39 net67_93) resistor r=4.16253
    rnet67_115 (net67_85 MM7_ELT_g) resistor r=50.9083
    rnet67_114 (net67_93 MM6_ELT_g) resistor r=194.942
    rnet67_113 (net67_133 net67_134) resistor r=1.02157
    rnet67_112 (net67_133 net67_135) resistor r=0.0961132
    rnet67_111 (net67_134 net67_183) resistor r=0.0964599
    rnet67_110 (net67_135 net67_136) resistor r=0.580816
    rnet67_109 (net67_136 net67_138) resistor r=0.0961132
    rnet67_108 (net67_137 net67_138) resistor r=0.389814
    rnet67_107 (net67_137 net67_177) resistor r=0.0728416
    rnet67_106 (net67_139 net67_141) resistor r=0.209875
    rnet67_105 (net67_139 net67_145) resistor r=0.0961132
    rnet67_104 (net67_141 net67_142) resistor r=13
    rnet67_103 (net67_142 MM10_ELT_d) resistor r=8.09035
    rnet67_102 (net67_144 net67_145) resistor r=0.385689
    rnet67_101 (net67_144 net67_179) resistor r=0.0728416
    rnet67_100 (net67_146 net67_148) resistor r=0.414868
    rnet67_99 (net67_146 net67_177) resistor r=0.0189303
    rnet67_98 (net67_148 net67_149) resistor r=13
    rnet67_97 (net67_149 MM11_ELT_d) resistor r=8.44
    rnet67_96 (net67_151 net67_152) resistor r=0.167063
    rnet67_95 (net67_151 net67_178) resistor r=0.0728416
    rnet67_94 (net67_152 net67_177) resistor r=0.0728416
    rnet67_93 (net67_153 net67_154) resistor r=0.617512
    rnet67_92 (net67_153 net67_178) resistor r=0.0189303
    rnet67_91 (net67_154 net67_179) resistor r=0.0189303
    rnet67_90 (net67_155 net67_156) resistor r=0.865145
    rnet67_89 (net67_155 net67_160) resistor r=0.0961132
    rnet67_88 (net67_156 net67_178) resistor r=0.0728416
    rnet67_87 (net67_157 net67_158) resistor r=0.980501
    rnet67_86 (net67_157 net67_166) resistor r=0.0961132
    rnet67_85 (net67_158 net67_179) resistor r=0.0728416
    rnet67_84 (net67_159 net67_160) resistor r=1.40102
    rnet67_83 (net67_159 net67_161) resistor r=0.101284
    rnet67_82 (net67_161 net67_163) resistor r=0.330019
    rnet67_81 (net67_163 net67_164) resistor r=10
    rnet67_80 (net67_164 net67_250) resistor r=12.8682
    rnet67_79 (net67_166 net67_168) resistor r=0.229209
    rnet67_78 (net67_168 net67_169) resistor r=13
    rnet67_77 (net67_169 net67) resistor r=8.09035
    rnet67_76 (net67_172 net67_174) resistor r=0.0371033
    rnet67_75 (net67_172 net67_183) resistor r=0.318169
    rnet67_74 (net67_174 net67_175) resistor r=8.66667
    rnet67_73 (net67_175 MM15_ELT_d) resistor r=2.78649
    rnet67_72 (net67_175 net67_267) resistor r=11.6377
    rnet67_71 (net67_180 net67_182) resistor r=0.646478
    rnet67_70 (net67_180 net67_190) resistor r=0.00804152
    rnet67_69 (net67_182 net67_183) resistor r=0.75
    rnet67_68 (net67_185 net67_187) resistor r=0.166964
    rnet67_67 (net67_185 net67_192) resistor r=0.00804152
    rnet67_66 (net67_187 net67_272) resistor r=0.75
    rnet67_65 (net67_190 net67_192) resistor r=0.155751
    rnet67_64 (net67_218 net67_251) resistor r=8.1518
    rnet67_63 (net67_220 net67_251) resistor r=8.1518
    rnet67_62 (net67_250 net67_251) resistor r=0.275023
    rnet67_61 (MM15_ELT_d net67_261) resistor r=2.55965
    rnet67_60 (MM15_ELT_d net67_263) resistor r=12.3172
    rnet67_59 (MM15_ELT_d net67_263) resistor r=1.62887
    rnet67_58 (MM15_ELT_d net67_266) resistor r=4.36821
    rnet67_57 (net67_259 net67_261) resistor r=14.4784
    rnet67_56 (net67_259 net67_264) resistor r=9.04062
    rnet67_55 (net67_260 net67_261) resistor r=14.4784
    rnet67_54 (net67_260 net67_267) resistor r=9.48555
    rnet67_53 (net67_262 net67_263) resistor r=12.3172
    rnet67_52 (net67_262 net67_265) resistor r=9.04595
    rnet67_51 (net67_264 net67_266) resistor r=20.2547
    rnet67_50 (net67_265 net67_266) resistor r=20.2547
    rnet67_49 (net67_271 net67_272) resistor r=13
    rnet67_48 (net67_271 MM16_ELT_d) resistor r=8.44
    rENN_144 (MM28_ELT_d ENN) resistor r=0.01
    rENN_143 (ENN_22 ENN_28) resistor r=58.3583
    rENN_142 (ENN_22 ENN_28) resistor r=4.16253
    rENN_141 (ENN_22 ENN_28) resistor r=58.3583
    rENN_140 (ENN_22 ENN_28) resistor r=4.16253
    rENN_139 (ENN_25 ENN_28) resistor r=58.3583
    rENN_138 (ENN_25 ENN_28) resistor r=6.30933
    rENN_137 (ENN_25 ENN_28) resistor r=58.3583
    rENN_136 (ENN_25 ENN_28) resistor r=6.30933
    rENN_135 (ENN_28 ENN_30) resistor r=14.9
    rENN_134 (ENN_28 ENN_39) resistor r=24.8333
    rENN_133 (ENN_28 ENN_36) resistor r=24.8333
    rENN_132 (ENN_28 ENN_47) resistor r=24.8333
    rENN_131 (ENN_28 ENN_44) resistor r=24.8333
    rENN_130 (ENN_28 ENN_52) resistor r=58.3583
    rENN_129 (ENN_28 ENN_55) resistor r=58.3583
    rENN_128 (ENN_28 ENN_39) resistor r=4.16253
    rENN_127 (ENN_28 ENN_30) resistor r=6.30933
    rENN_126 (ENN_28 ENN_47) resistor r=1.63969
    rENN_125 (ENN_28 ENN_36) resistor r=4.16253
    rENN_124 (ENN_28 ENN_52) resistor r=4.16253
    rENN_123 (ENN_28 ENN_44) resistor r=4.16253
    rENN_122 (ENN_28 ENN_55) resistor r=4.16253
    rENN_121 (ENN_28 ENN_30) resistor r=14.9
    rENN_120 (ENN_28 ENN_195) resistor r=40.975
    rENN_119 (ENN_28 ENN_39) resistor r=24.8333
    rENN_118 (ENN_28 ENN_36) resistor r=24.8333
    rENN_117 (ENN_28 ENN_47) resistor r=24.8333
    rENN_116 (ENN_28 ENN_44) resistor r=24.8333
    rENN_115 (ENN_28 ENN_52) resistor r=58.3583
    rENN_114 (ENN_28 MM16_ELT_g) resistor r=7.45
    rENN_113 (ENN_28 ENN_39) resistor r=4.16253
    rENN_112 (ENN_28 ENN_30) resistor r=6.30933
    rENN_111 (ENN_28 ENN_47) resistor r=1.63969
    rENN_110 (ENN_28 ENN_36) resistor r=4.16253
    rENN_109 (ENN_28 ENN_52) resistor r=4.16253
    rENN_108 (ENN_28 ENN_44) resistor r=4.16253
    rENN_107 (ENN_28 ENN_55) resistor r=4.16253
    rENN_106 (ENN_55 MM16_ELT_g) resistor r=50.9083
    rENN_105 (ENN_60 ENN_66) resistor r=58.3583
    rENN_104 (ENN_60 ENN_66) resistor r=4.16253
    rENN_103 (ENN_60 ENN_66) resistor r=58.3583
    rENN_102 (ENN_60 ENN_66) resistor r=4.16253
    rENN_101 (ENN_63 ENN_66) resistor r=58.3583
    rENN_100 (ENN_63 ENN_66) resistor r=4.16253
    rENN_99 (ENN_63 ENN_66) resistor r=58.3583
    rENN_98 (ENN_63 ENN_66) resistor r=4.16253
    rENN_97 (ENN_66 ENN_71) resistor r=24.8333
    rENN_96 (ENN_66 ENN_68) resistor r=24.8333
    rENN_95 (ENN_66 ENN_79) resistor r=24.8333
    rENN_94 (ENN_66 ENN_76) resistor r=24.8333
    rENN_93 (ENN_66 ENN_84) resistor r=14.9
    rENN_92 (ENN_66 ENN_90) resistor r=58.3583
    rENN_91 (ENN_66 ENN_93) resistor r=58.3583
    rENN_90 (ENN_66 ENN_71) resistor r=4.16253
    rENN_89 (ENN_66 ENN_79) resistor r=4.16253
    rENN_88 (ENN_66 ENN_90) resistor r=6.30933
    rENN_87 (ENN_66 ENN_84) resistor r=6.30933
    rENN_86 (ENN_66 ENN_68) resistor r=1.63969
    rENN_85 (ENN_66 ENN_76) resistor r=4.16253
    rENN_84 (ENN_66 ENN_93) resistor r=4.16253
    rENN_83 (ENN_66 ENN_71) resistor r=24.8333
    rENN_82 (ENN_66 ENN_68) resistor r=24.8333
    rENN_81 (ENN_66 ENN_79) resistor r=24.8333
    rENN_80 (ENN_66 ENN_76) resistor r=24.8333
    rENN_79 (ENN_66 ENN_217) resistor r=47.1833
    rENN_78 (ENN_66 ENN_84) resistor r=14.9
    rENN_77 (ENN_66 ENN_90) resistor r=58.3583
    rENN_76 (ENN_66 MM10_ELT_g) resistor r=7.45
    rENN_75 (ENN_66 ENN_71) resistor r=4.16253
    rENN_74 (ENN_66 ENN_79) resistor r=4.16253
    rENN_73 (ENN_66 ENN_90) resistor r=6.30933
    rENN_72 (ENN_66 ENN_84) resistor r=6.30933
    rENN_71 (ENN_66 ENN_68) resistor r=1.63969
    rENN_70 (ENN_66 ENN_76) resistor r=4.16253
    rENN_69 (ENN_66 ENN_93) resistor r=4.16253
    rENN_68 (ENN_93 MM10_ELT_g) resistor r=50.9083
    rENN_67 (ENN_131 ENN_133) resistor r=0.399783
    rENN_66 (ENN_131 ENN_148) resistor r=0.0961132
    rENN_65 (ENN_133 ENN_134) resistor r=13
    rENN_64 (ENN_134 MM29_ELT_d) resistor r=8.44
    rENN_63 (ENN_136 ENN_138) resistor r=0.399783
    rENN_62 (ENN_136 ENN_150) resistor r=0.0961132
    rENN_61 (ENN_138 ENN_139) resistor r=8.66667
    rENN_60 (ENN_138 ENN_141) resistor r=0.693294
    rENN_59 (ENN_139 ENN) resistor r=32.3614
    rENN_58 (ENN_141 ENN_142) resistor r=8.66667
    rENN_57 (ENN_141 ENN_144) resistor r=0.462196
    rENN_56 (ENN_142 ENN) resistor r=16.1807
    rENN_55 (ENN_142 ENN_145) resistor r=32.3614
    rENN_54 (ENN_144 ENN_145) resistor r=26
    rENN_53 (ENN_147 ENN_148) resistor r=0.207679
    rENN_52 (ENN_147 ENN_158) resistor r=0.0964599
    rENN_51 (ENN_149 ENN_150) resistor r=0.178863
    rENN_50 (ENN_149 ENN_152) resistor r=0.0964599
    rENN_49 (ENN_151 ENN_152) resistor r=0.242046
    rENN_48 (ENN_151 ENN_160) resistor r=0.110225
    rENN_47 (ENN_153 ENN_155) resistor r=0.0126958
    rENN_46 (ENN_153 ENN_160) resistor r=0.0072217
    rENN_45 (ENN_155 ENN_156) resistor r=10
    rENN_44 (ENN_156 ENN_229) resistor r=25.0591
    rENN_43 (ENN_158 ENN_164) resistor r=0.105414
    rENN_42 (ENN_159 ENN_160) resistor r=0.110225
    rENN_41 (ENN_159 ENN_164) resistor r=0.0143746
    rENN_40 (ENN_161 ENN_163) resistor r=1.16072
    rENN_39 (ENN_161 ENN_166) resistor r=0.0765047
    rENN_38 (ENN_163 ENN_164) resistor r=0.75
    rENN_37 (ENN_166 ENN_168) resistor r=0.844949
    rENN_36 (ENN_168 ENN_169) resistor r=0.75
    rENN_35 (ENN_169 ENN_241) resistor r=10
    rENN_34 (ENN_195 ENN_229) resistor r=9.29775
    rENN_33 (ENN_217 ENN_235) resistor r=4.38767
    rENN_32 (ENN_234 ENN_235) resistor r=3.71511
    rENN_31 (ENN_234 ENN_241) resistor r=14.9
    rEN_266 (MM1_ELT_d EN) resistor r=0.01
    rEN_265 (EN_42 EN_48) resistor r=58.3583
    rEN_264 (EN_42 EN_48) resistor r=4.16253
    rEN_263 (EN_42 EN_48) resistor r=58.3583
    rEN_262 (EN_42 EN_48) resistor r=4.16253
    rEN_261 (EN_45 EN_48) resistor r=58.3583
    rEN_260 (EN_45 EN_48) resistor r=6.30933
    rEN_259 (EN_45 EN_48) resistor r=58.3583
    rEN_258 (EN_45 EN_48) resistor r=6.30933
    rEN_257 (EN_48 EN_50) resistor r=14.9
    rEN_256 (EN_48 EN_73) resistor r=24.8333
    rEN_255 (EN_48 EN_70) resistor r=24.8333
    rEN_254 (EN_48 EN_81) resistor r=24.8333
    rEN_253 (EN_48 EN_78) resistor r=24.8333
    rEN_252 (EN_48 EN_102) resistor r=58.3583
    rEN_251 (EN_48 EN_105) resistor r=58.3583
    rEN_250 (EN_48 EN_73) resistor r=4.16253
    rEN_249 (EN_48 EN_50) resistor r=6.30933
    rEN_248 (EN_48 EN_81) resistor r=1.63969
    rEN_247 (EN_48 EN_70) resistor r=4.16253
    rEN_246 (EN_48 EN_102) resistor r=4.16253
    rEN_245 (EN_48 EN_78) resistor r=4.16253
    rEN_244 (EN_48 EN_105) resistor r=4.16253
    rEN_243 (EN_48 EN_50) resistor r=14.9
    rEN_242 (EN_48 EN_373) resistor r=40.975
    rEN_241 (EN_48 EN_73) resistor r=24.8333
    rEN_240 (EN_48 EN_70) resistor r=24.8333
    rEN_239 (EN_48 EN_81) resistor r=24.8333
    rEN_238 (EN_48 EN_78) resistor r=24.8333
    rEN_237 (EN_48 EN_102) resistor r=58.3583
    rEN_236 (EN_48 MM29_ELT_g) resistor r=7.45
    rEN_235 (EN_48 EN_73) resistor r=4.16253
    rEN_234 (EN_48 EN_50) resistor r=6.30933
    rEN_233 (EN_48 EN_81) resistor r=1.63969
    rEN_232 (EN_48 EN_70) resistor r=4.16253
    rEN_231 (EN_48 EN_102) resistor r=4.16253
    rEN_230 (EN_48 EN_78) resistor r=4.16253
    rEN_229 (EN_48 EN_105) resistor r=4.16253
    rEN_228 (EN_56 EN_59) resistor r=14.9
    rEN_227 (EN_56 EN_59) resistor r=6.30933
    rEN_226 (EN_56 EN_59) resistor r=14.9
    rEN_225 (EN_56 EN_59) resistor r=6.30933
    rEN_224 (EN_59 EN_62) resistor r=202.392
    rEN_223 (EN_59 EN_65) resistor r=202.392
    rEN_222 (EN_59 EN_89) resistor r=24.8333
    rEN_221 (EN_59 EN_86) resistor r=24.8333
    rEN_220 (EN_59 EN_97) resistor r=24.8333
    rEN_219 (EN_59 EN_94) resistor r=24.8333
    rEN_218 (EN_59 EN_110) resistor r=202.392
    rEN_217 (EN_59 EN_113) resistor r=202.392
    rEN_216 (EN_59 EN_62) resistor r=6.30933
    rEN_215 (EN_59 EN_89) resistor r=1.63969
    rEN_214 (EN_59 EN_97) resistor r=4.16253
    rEN_213 (EN_59 EN_65) resistor r=4.16253
    rEN_212 (EN_59 EN_86) resistor r=4.16253
    rEN_211 (EN_59 EN_110) resistor r=4.16253
    rEN_210 (EN_59 EN_94) resistor r=4.16253
    rEN_209 (EN_59 EN_113) resistor r=4.16253
    rEN_208 (EN_59 EN_375) resistor r=40.975
    rEN_207 (EN_59 EN_62) resistor r=202.392
    rEN_206 (EN_59 EN_65) resistor r=202.392
    rEN_205 (EN_59 EN_89) resistor r=24.8333
    rEN_204 (EN_59 EN_86) resistor r=24.8333
    rEN_203 (EN_59 EN_97) resistor r=24.8333
    rEN_202 (EN_59 EN_94) resistor r=24.8333
    rEN_201 (EN_59 EN_110) resistor r=202.392
    rEN_200 (EN_59 MM28_ELT_g) resistor r=7.45
    rEN_199 (EN_59 EN_62) resistor r=6.30933
    rEN_198 (EN_59 EN_89) resistor r=1.63969
    rEN_197 (EN_59 EN_97) resistor r=4.16253
    rEN_196 (EN_59 EN_65) resistor r=4.16253
    rEN_195 (EN_59 EN_86) resistor r=4.16253
    rEN_194 (EN_59 EN_110) resistor r=4.16253
    rEN_193 (EN_59 EN_94) resistor r=4.16253
    rEN_192 (EN_59 EN_113) resistor r=4.16253
    rEN_191 (EN_105 MM29_ELT_g) resistor r=50.9083
    rEN_190 (EN_113 MM28_ELT_g) resistor r=194.942
    rEN_189 (EN_118 EN_124) resistor r=58.3583
    rEN_188 (EN_118 EN_124) resistor r=4.16253
    rEN_187 (EN_118 EN_124) resistor r=58.3583
    rEN_186 (EN_118 EN_124) resistor r=4.16253
    rEN_185 (EN_121 EN_124) resistor r=58.3583
    rEN_184 (EN_121 EN_124) resistor r=6.30933
    rEN_183 (EN_121 EN_124) resistor r=58.3583
    rEN_182 (EN_121 EN_124) resistor r=6.30933
    rEN_181 (EN_124 EN_126) resistor r=14.9
    rEN_180 (EN_124 EN_135) resistor r=24.8333
    rEN_179 (EN_124 EN_132) resistor r=24.8333
    rEN_178 (EN_124 EN_143) resistor r=24.8333
    rEN_177 (EN_124 EN_140) resistor r=24.8333
    rEN_176 (EN_124 EN_148) resistor r=58.3583
    rEN_175 (EN_124 EN_151) resistor r=58.3583
    rEN_174 (EN_124 EN_135) resistor r=4.16253
    rEN_173 (EN_124 EN_126) resistor r=6.30933
    rEN_172 (EN_124 EN_143) resistor r=1.63969
    rEN_171 (EN_124 EN_132) resistor r=4.16253
    rEN_170 (EN_124 EN_148) resistor r=4.16253
    rEN_169 (EN_124 EN_140) resistor r=4.16253
    rEN_168 (EN_124 EN_151) resistor r=4.16253
    rEN_167 (EN_124 EN_126) resistor r=14.9
    rEN_166 (EN_124 EN_407) resistor r=39.7333
    rEN_165 (EN_124 EN_135) resistor r=24.8333
    rEN_164 (EN_124 EN_132) resistor r=24.8333
    rEN_163 (EN_124 EN_143) resistor r=24.8333
    rEN_162 (EN_124 EN_140) resistor r=24.8333
    rEN_161 (EN_124 EN_148) resistor r=58.3583
    rEN_160 (EN_124 MM15_ELT_g) resistor r=7.45
    rEN_159 (EN_124 EN_135) resistor r=4.16253
    rEN_158 (EN_124 EN_126) resistor r=6.30933
    rEN_157 (EN_124 EN_143) resistor r=1.63969
    rEN_156 (EN_124 EN_132) resistor r=4.16253
    rEN_155 (EN_124 EN_148) resistor r=4.16253
    rEN_154 (EN_124 EN_140) resistor r=4.16253
    rEN_153 (EN_124 EN_151) resistor r=4.16253
    rEN_152 (EN_151 MM15_ELT_g) resistor r=50.9083
    rEN_151 (EN_156 EN_159) resistor r=14.9
    rEN_150 (EN_156 EN_159) resistor r=6.30933
    rEN_149 (EN_156 EN_159) resistor r=14.9
    rEN_148 (EN_156 EN_159) resistor r=6.30933
    rEN_147 (EN_159 EN_162) resistor r=58.3583
    rEN_146 (EN_159 EN_165) resistor r=58.3583
    rEN_145 (EN_159 EN_173) resistor r=24.8333
    rEN_144 (EN_159 EN_170) resistor r=24.8333
    rEN_143 (EN_159 EN_181) resistor r=24.8333
    rEN_142 (EN_159 EN_178) resistor r=24.8333
    rEN_141 (EN_159 EN_186) resistor r=58.3583
    rEN_140 (EN_159 EN_189) resistor r=58.3583
    rEN_139 (EN_159 EN_162) resistor r=6.30933
    rEN_138 (EN_159 EN_173) resistor r=1.63969
    rEN_137 (EN_159 EN_181) resistor r=4.16253
    rEN_136 (EN_159 EN_165) resistor r=4.16253
    rEN_135 (EN_159 EN_170) resistor r=4.16253
    rEN_134 (EN_159 EN_186) resistor r=4.16253
    rEN_133 (EN_159 EN_178) resistor r=4.16253
    rEN_132 (EN_159 EN_189) resistor r=4.16253
    rEN_131 (EN_159 EN_420) resistor r=39.7333
    rEN_130 (EN_159 EN_162) resistor r=58.3583
    rEN_129 (EN_159 EN_165) resistor r=58.3583
    rEN_128 (EN_159 EN_173) resistor r=24.8333
    rEN_127 (EN_159 EN_170) resistor r=24.8333
    rEN_126 (EN_159 EN_181) resistor r=24.8333
    rEN_125 (EN_159 EN_178) resistor r=24.8333
    rEN_124 (EN_159 EN_186) resistor r=58.3583
    rEN_123 (EN_159 MM11_ELT_g) resistor r=7.45
    rEN_122 (EN_159 EN_162) resistor r=6.30933
    rEN_121 (EN_159 EN_173) resistor r=1.63969
    rEN_120 (EN_159 EN_181) resistor r=4.16253
    rEN_119 (EN_159 EN_165) resistor r=4.16253
    rEN_118 (EN_159 EN_170) resistor r=4.16253
    rEN_117 (EN_159 EN_186) resistor r=4.16253
    rEN_116 (EN_159 EN_178) resistor r=4.16253
    rEN_115 (EN_159 EN_189) resistor r=4.16253
    rEN_114 (EN_189 MM11_ELT_g) resistor r=50.9083
    rEN_113 (EN_261 EN_263) resistor r=0.399783
    rEN_112 (EN_261 EN_278) resistor r=0.0961132
    rEN_111 (EN_263 EN_264) resistor r=13
    rEN_110 (EN_264 MM0_ELT_d) resistor r=8.44
    rEN_109 (EN_266 EN_268) resistor r=0.399783
    rEN_108 (EN_266 EN_280) resistor r=0.0961132
    rEN_107 (EN_268 EN_269) resistor r=8.66667
    rEN_106 (EN_268 EN_271) resistor r=0.639653
    rEN_105 (EN_269 EN) resistor r=32.3614
    rEN_104 (EN_271 EN_272) resistor r=8.66667
    rEN_103 (EN_271 EN_274) resistor r=0.426436
    rEN_102 (EN_272 EN) resistor r=16.1807
    rEN_101 (EN_272 EN_275) resistor r=32.3614
    rEN_100 (EN_274 EN_275) resistor r=26
    rEN_99 (EN_277 EN_278) resistor r=0.342808
    rEN_98 (EN_277 EN_299) resistor r=0.0964599
    rEN_97 (EN_279 EN_280) resistor r=0.289956
    rEN_96 (EN_279 EN_282) resistor r=0.0964599
    rEN_95 (EN_281 EN_282) resistor r=0.196453
    rEN_94 (EN_281 EN_301) resistor r=0.110225
    rEN_93 (EN_283 EN_285) resistor r=0.00423195
    rEN_92 (EN_283 EN_301) resistor r=0.0072217
    rEN_91 (EN_285 EN_286) resistor r=10
    rEN_90 (EN_286 EN_464) resistor r=3.38636
    rEN_89 (EN_288 EN_290) resistor r=0.0878545
    rEN_88 (EN_288 EN_302) resistor r=0.0964599
    rEN_87 (EN_290 EN_291) resistor r=10
    rEN_86 (EN_291 EN_449) resistor r=22.35
    rEN_85 (EN_293 EN_294) resistor r=0.539387
    rEN_84 (EN_293 EN_295) resistor r=0.0961132
    rEN_83 (EN_294 EN_303) resistor r=0.0964599
    rEN_82 (EN_295 EN_296) resistor r=0.191876
    rEN_81 (EN_296 EN_305) resistor r=0.0480566
    rEN_80 (EN_299 EN_311) resistor r=0.105414
    rEN_79 (EN_300 EN_301) resistor r=0.110225
    rEN_78 (EN_300 EN_311) resistor r=0.0143746
    rEN_77 (EN_302 EN_319) resistor r=0.230762
    rEN_76 (EN_303 EN_328) resistor r=0.72646
    rEN_75 (EN_305 EN_306) resistor r=10
    rEN_74 (EN_306 EN_452) resistor r=5.41818
    rEN_73 (EN_307 EN_310) resistor r=0.580172
    rEN_72 (EN_307 EN_313) resistor r=0.0765047
    rEN_71 (EN_308 EN_310) resistor r=1.21486
    rEN_70 (EN_308 EN_315) resistor r=0.0765047
    rEN_69 (EN_310 EN_311) resistor r=0.75
    rEN_68 (EN_312 EN_313) resistor r=1.04707
    rEN_67 (EN_312 EN_327) resistor r=0.0382523
    rEN_66 (EN_314 EN_315) resistor r=0.295927
    rEN_65 (EN_314 EN_325) resistor r=0.0150682
    rEN_64 (EN_316 EN_318) resistor r=0.0389377
    rEN_63 (EN_316 EN_325) resistor r=0.0579808
    rEN_62 (EN_318 EN_319) resistor r=0.75
    rEN_61 (EN_327 EN_328) resistor r=0.75
    rEN_60 (EN_373 EN_464) resistor r=5.23411
    rEN_59 (EN_375 EN_464) resistor r=5.23411
    rEN_58 (EN_407 EN_449) resistor r=9.29775
    rEN_57 (EN_420 EN_453) resistor r=4.38767
    rEN_56 (EN_452 EN_453) resistor r=3.71511
    rE_93 (E_22 E_28) resistor r=58.3583
    rE_92 (E_22 E_28) resistor r=4.16253
    rE_91 (E_22 E_28) resistor r=58.3583
    rE_90 (E_22 E_28) resistor r=4.16253
    rE_89 (E_25 E_28) resistor r=58.3583
    rE_88 (E_25 E_28) resistor r=6.30933
    rE_87 (E_25 E_28) resistor r=58.3583
    rE_86 (E_25 E_28) resistor r=6.30933
    rE_85 (E_28 E_30) resistor r=14.9
    rE_84 (E_28 E_53) resistor r=24.8333
    rE_83 (E_28 E_50) resistor r=24.8333
    rE_82 (E_28 E_61) resistor r=24.8333
    rE_81 (E_28 E_58) resistor r=24.8333
    rE_80 (E_28 E_82) resistor r=58.3583
    rE_79 (E_28 E_85) resistor r=58.3583
    rE_78 (E_28 E_53) resistor r=4.16253
    rE_77 (E_28 E_30) resistor r=6.30933
    rE_76 (E_28 E_61) resistor r=1.63969
    rE_75 (E_28 E_50) resistor r=4.16253
    rE_74 (E_28 E_82) resistor r=4.16253
    rE_73 (E_28 E_58) resistor r=4.16253
    rE_72 (E_28 E_85) resistor r=4.16253
    rE_71 (E_28 E_30) resistor r=14.9
    rE_70 (E_28 E_161) resistor r=40.975
    rE_69 (E_28 E_53) resistor r=24.8333
    rE_68 (E_28 E_50) resistor r=24.8333
    rE_67 (E_28 E_61) resistor r=24.8333
    rE_66 (E_28 E_58) resistor r=24.8333
    rE_65 (E_28 E_82) resistor r=58.3583
    rE_64 (E_28 MM0_ELT_g) resistor r=7.45
    rE_63 (E_28 E_53) resistor r=4.16253
    rE_62 (E_28 E_30) resistor r=6.30933
    rE_61 (E_28 E_61) resistor r=1.63969
    rE_60 (E_28 E_50) resistor r=4.16253
    rE_59 (E_28 E_82) resistor r=4.16253
    rE_58 (E_28 E_58) resistor r=4.16253
    rE_57 (E_28 E_85) resistor r=4.16253
    rE_56 (E_36 E_39) resistor r=14.9
    rE_55 (E_36 E_39) resistor r=6.30933
    rE_54 (E_36 E_39) resistor r=14.9
    rE_53 (E_36 E_39) resistor r=6.30933
    rE_52 (E_39 E_42) resistor r=202.392
    rE_51 (E_39 E_45) resistor r=202.392
    rE_50 (E_39 E_69) resistor r=24.8333
    rE_49 (E_39 E_66) resistor r=24.8333
    rE_48 (E_39 E_77) resistor r=24.8333
    rE_47 (E_39 E_74) resistor r=24.8333
    rE_46 (E_39 E_90) resistor r=202.392
    rE_45 (E_39 E_93) resistor r=202.392
    rE_44 (E_39 E_42) resistor r=6.30933
    rE_43 (E_39 E_69) resistor r=1.63969
    rE_42 (E_39 E_77) resistor r=4.16253
    rE_41 (E_39 E_45) resistor r=4.16253
    rE_40 (E_39 E_66) resistor r=4.16253
    rE_39 (E_39 E_90) resistor r=4.16253
    rE_38 (E_39 E_74) resistor r=4.16253
    rE_37 (E_39 E_93) resistor r=4.16253
    rE_36 (E_39 E_163) resistor r=40.975
    rE_35 (E_39 E_42) resistor r=202.392
    rE_34 (E_39 E_45) resistor r=202.392
    rE_33 (E_39 E_69) resistor r=24.8333
    rE_32 (E_39 E_66) resistor r=24.8333
    rE_31 (E_39 E_77) resistor r=24.8333
    rE_30 (E_39 E_74) resistor r=24.8333
    rE_29 (E_39 E_90) resistor r=202.392
    rE_28 (E_39 MM1_ELT_g) resistor r=7.45
    rE_27 (E_39 E_42) resistor r=6.30933
    rE_26 (E_39 E_69) resistor r=1.63969
    rE_25 (E_39 E_77) resistor r=4.16253
    rE_24 (E_39 E_45) resistor r=4.16253
    rE_23 (E_39 E_66) resistor r=4.16253
    rE_22 (E_39 E_90) resistor r=4.16253
    rE_21 (E_39 E_74) resistor r=4.16253
    rE_20 (E_39 E_93) resistor r=4.16253
    rE_19 (E_85 MM0_ELT_g) resistor r=50.9083
    rE_18 (E_93 MM1_ELT_g) resistor r=194.942
    rE_17 (E_133 E) resistor r=10
    rE_16 (E_133 E_201) resistor r=0.677273
    rE_15 (E_161 E_201) resistor r=5.23411
    rE_14 (E_163 E_201) resistor r=5.23411
ends LHCNQD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DFCNQD1_LVT_ELT
// View name: calibre
subckt DFCNQD1_LVT_ELT D CP CDN Q VDD VSS
    MM2 (MM2_d MM2_g MM2_s MM2_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 ps=4.76e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM1 (MM1_d MM1_g MM1_s MM1_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 ps=3.835e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM4 (MM4_d MM4_g MM4_s MM4_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM0 (MM0_d MM0_g MM0_s MM0_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 ps=3.835e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM6 (MM6_d MM6_g MM6_s MM6_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 ps=3.815e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM3 (MM3_d MM3_g MM3_s MM3_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM5 (MM5_d MM5_g MM5_s MM5_b) nch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 ps=3.835e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 \
        ps=4.76e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM16_ELT (MM16_ELT_d MM16_ELT_g MM16_ELT_s MM16_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM29_ELT (MM29_ELT_d MM29_ELT_g MM29_ELT_s MM29_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9 (MM9_d MM9_g MM9_s MM9_b) pch_lvt l=6e-08 w=3.74e-06 m=1 nf=1 \
        ad=3.26e-13 as=5.68868e-13 pd=3.66e-06 ps=8.52312e-06 nrd=0.026738 \
        nrs=0.026738 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM11 (MM11_d MM11_g MM11_s MM11_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.50082e-13 pd=1.34e-06 ps=3.74688e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM12 (MM12_d MM12_g MM12_s MM12_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM8 (MM8_d MM8_g MM8_s MM8_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 ps=3.815e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM10 (MM10_d MM10_g MM10_s MM10_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 ps=4.8e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM7 (MM7_d MM7_g MM7_s MM7_b) pch_lvt l=6e-08 w=1.42e-06 m=1 nf=1 \
        ad=3.03125e-13 as=9.4e-14 pd=4.8e-06 ps=1.34e-06 nrd=0.0704225 \
        nrs=0.0704225 sa=175.00n sb=175.00n sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.96387e-13 pd=1.34e-06 \
        ps=5.4e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.96387e-13 pd=1.34e-06 \
        ps=5.4e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=3.03125e-13 as=9.4e-14 pd=4.8e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM28_ELT (MM28_ELT_d MM28_ELT_g MM28_ELT_s MM28_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet299_6 (net299_4 VSS) capacitor c=5.40265e-18
    cinet299_5 (net299_5 VSS) capacitor c=2.81807e-18
    cinet299_4 (MM4_d VSS) capacitor c=5.0554e-18
    cinet299_3 (net299_12 VSS) capacitor c=1.21784e-18
    cinet299_2 (net299_14 VSS) capacitor c=5.5301e-18
    cinet299_1 (net299_16 VSS) capacitor c=4.71508e-18
    cinet299_0 (net299 VSS) capacitor c=9.51159e-18
    cinet177_6 (MM5_s VSS) capacitor c=3.02564e-18
    cinet177_5 (net177_7 VSS) capacitor c=3.68513e-18
    cinet177_4 (net177_11 VSS) capacitor c=7.3818e-18
    cinet177_3 (net177_15 VSS) capacitor c=7.62461e-19
    cinet177_2 (net177_16 VSS) capacitor c=4.92223e-18
    cinet177_1 (net177_19 VSS) capacitor c=8.05696e-18
    cinet177_0 (net177 VSS) capacitor c=2.26447e-18
    cinet29_6 (net29_4 VSS) capacitor c=5.47935e-18
    cinet29_5 (net29_5 VSS) capacitor c=2.81534e-18
    cinet29_4 (MM12_ELT_d VSS) capacitor c=5.49052e-18
    cinet29_3 (net29_12 VSS) capacitor c=1.20107e-18
    cinet29_2 (net29_14 VSS) capacitor c=5.60885e-18
    cinet29_1 (net29_16 VSS) capacitor c=4.71508e-18
    cinet29_0 (net29 VSS) capacitor c=9.46668e-18
    cinet17_9 (MM16_ELT_s VSS) capacitor c=9.50486e-18
    cinet17_8 (net17_4 VSS) capacitor c=1.41789e-18
    cinet17_7 (net17_5 VSS) capacitor c=3.54406e-18
    cinet17_6 (net17_7 VSS) capacitor c=3.89656e-18
    cinet17_5 (net17_11 VSS) capacitor c=2.02832e-17
    cinet17_4 (net17_15 VSS) capacitor c=3.69062e-18
    cinet17_3 (net17_16 VSS) capacitor c=7.11498e-18
    cinet17_2 (net17_19 VSS) capacitor c=8.48874e-18
    cinet17_1 (net17_20 VSS) capacitor c=5.08484e-18
    cinet17_0 (net17 VSS) capacitor c=2.85078e-18
    cinet722_7 (net722_4 VSS) capacitor c=5.08287e-18
    cinet722_6 (net722_6 VSS) capacitor c=6.21964e-18
    cinet722_5 (net722_9 VSS) capacitor c=1.71175e-18
    cinet722_4 (MM12_d VSS) capacitor c=1.08186e-17
    cinet722_3 (net722_13 VSS) capacitor c=4.91492e-18
    cinet722_2 (net722_15 VSS) capacitor c=7.62742e-18
    cinet722_1 (net722_18 VSS) capacitor c=1.18424e-17
    cinet722_0 (net722_20 VSS) capacitor c=1.15496e-17
    cinet72_8 (net72_4 VSS) capacitor c=6.34479e-18
    cinet72_7 (net72_5 VSS) capacitor c=9.45182e-19
    cinet72_6 (net72_6 VSS) capacitor c=6.89942e-18
    cinet72_5 (net72_9 VSS) capacitor c=1.71175e-18
    cinet72_4 (MM9_ELT_d VSS) capacitor c=1.07796e-17
    cinet72_3 (net72_13 VSS) capacitor c=6.96016e-18
    cinet72_2 (net72_15 VSS) capacitor c=1.01076e-17
    cinet72_1 (net72_18 VSS) capacitor c=1.18424e-17
    cinet72_0 (net72_20 VSS) capacitor c=9.4365e-18
    ciQ_23 (Q_22 VSS) capacitor c=6.89598e-18
    ciQ_22 (Q_25 VSS) capacitor c=4.27597e-18
    ciQ_21 (Q_28 VSS) capacitor c=1.70465e-16
    ciQ_20 (Q_30 VSS) capacitor c=2.08995e-17
    ciQ_19 (Q_38 VSS) capacitor c=2.30316e-17
    ciQ_18 (Q_46 VSS) capacitor c=6.31515e-18
    ciQ_17 (Q_49 VSS) capacitor c=4.47573e-18
    ciQ_16 (Q_52 VSS) capacitor c=1.67777e-16
    ciQ_15 (Q_60 VSS) capacitor c=3.15108e-17
    ciQ_14 (Q_68 VSS) capacitor c=1.77129e-17
    ciQ_13 (Q_79 VSS) capacitor c=2.80371e-18
    ciQ_12 (Q_90 VSS) capacitor c=9.31494e-18
    ciQ_11 (Q_131 VSS) capacitor c=1.53385e-16
    ciQ_10 (Q_137 VSS) capacitor c=1.51099e-16
    ciQ_9 (Q_138 VSS) capacitor c=5.22185e-17
    ciQ_8 (Q_139 VSS) capacitor c=1.87819e-17
    ciQ_7 (Q_142 VSS) capacitor c=4.47405e-17
    ciQ_6 (Q_143 VSS) capacitor c=1.11627e-16
    ciQ_5 (Q_147 VSS) capacitor c=1.75094e-16
    ciQ_4 (Q_148 VSS) capacitor c=3.23187e-16
    ciQ_3 (Q VSS) capacitor c=6.18868e-17
    ciQ_2 (Q_162 VSS) capacitor c=2.65549e-17
    ciQ_1 (Q_165 VSS) capacitor c=2.86513e-17
    ciQ_0 (Q_232 VSS) capacitor c=5.19169e-17
    ciVDD_63 (VDD_2 VSS) capacitor c=6.33971e-17
    ciVDD_62 (VDD_11 VSS) capacitor c=2.40338e-16
    ciVDD_61 (VDD_19 VSS) capacitor c=3.76352e-16
    ciVDD_60 (VDD_20 VSS) capacitor c=4.73324e-17
    ciVDD_59 (VDD_27 VSS) capacitor c=7.20504e-17
    ciVDD_58 (VDD_28 VSS) capacitor c=8.72357e-17
    ciVDD_57 (VDD_30 VSS) capacitor c=1.08744e-16
    ciVDD_56 (VDD_43 VSS) capacitor c=5.80584e-17
    ciVDD_55 (VDD_44 VSS) capacitor c=1.18497e-16
    ciVDD_54 (VDD_46 VSS) capacitor c=6.3421e-17
    ciVDD_53 (VDD_53 VSS) capacitor c=9.37219e-17
    ciVDD_52 (VDD_54 VSS) capacitor c=1.4846e-16
    ciVDD_51 (VDD_56 VSS) capacitor c=4.71203e-17
    ciVDD_50 (VDD_63 VSS) capacitor c=6.6419e-17
    ciVDD_49 (VDD_64 VSS) capacitor c=8.56235e-17
    ciVDD_48 (VDD_66 VSS) capacitor c=1.08163e-16
    ciVDD_47 (VDD_76 VSS) capacitor c=5.80686e-17
    ciVDD_46 (VDD_77 VSS) capacitor c=1.18497e-16
    ciVDD_45 (VDD_79 VSS) capacitor c=6.28991e-17
    ciVDD_44 (VDD_86 VSS) capacitor c=2.49857e-16
    ciVDD_43 (VDD_94 VSS) capacitor c=1.97212e-16
    ciVDD_42 (VDD_97 VSS) capacitor c=6.80659e-17
    ciVDD_41 (VDD_100 VSS) capacitor c=3.58509e-18
    ciVDD_40 (VDD_101 VSS) capacitor c=3.58509e-18
    ciVDD_39 (VDD_102 VSS) capacitor c=3.58509e-18
    ciVDD_38 (VDD_103 VSS) capacitor c=3.58509e-18
    ciVDD_37 (VDD_105 VSS) capacitor c=3.58509e-18
    ciVDD_36 (VDD_107 VSS) capacitor c=3.58509e-18
    ciVDD_35 (VDD_109 VSS) capacitor c=3.58509e-18
    ciVDD_34 (MM28_ELT_s VSS) capacitor c=1.32762e-17
    ciVDD_33 (VDD_117 VSS) capacitor c=1.11099e-18
    ciVDD_32 (VDD_119 VSS) capacitor c=1.07074e-18
    ciVDD_31 (VDD_123 VSS) capacitor c=1.11099e-18
    ciVDD_30 (VDD_124 VSS) capacitor c=1.23625e-18
    ciVDD_29 (VDD_125 VSS) capacitor c=1.07074e-18
    ciVDD_28 (VDD_128 VSS) capacitor c=3.49723e-17
    ciVDD_27 (MM14_ELT_s VSS) capacitor c=7.23193e-18
    ciVDD_26 (VDD_130 VSS) capacitor c=1.26426e-18
    ciVDD_25 (VDD_131 VSS) capacitor c=8.11848e-18
    ciVDD_24 (VDD_134 VSS) capacitor c=1.71175e-18
    ciVDD_23 (VDD_139 VSS) capacitor c=5.14689e-18
    ciVDD_22 (VDD_140 VSS) capacitor c=5.91271e-18
    ciVDD_21 (VDD_141 VSS) capacitor c=4.67919e-18
    ciVDD_20 (VDD_144 VSS) capacitor c=1.71175e-18
    ciVDD_19 (VDD_145 VSS) capacitor c=4.37347e-17
    ciVDD_18 (MM6_ELT_s VSS) capacitor c=1.04202e-17
    ciVDD_17 (VDD_150 VSS) capacitor c=1.71175e-18
    ciVDD_16 (VDD_151 VSS) capacitor c=1.64542e-17
    ciVDD_15 (VDD_152 VSS) capacitor c=7.38856e-18
    ciVDD_14 (VDD_157 VSS) capacitor c=5.21599e-18
    ciVDD_13 (MM10_s VSS) capacitor c=5.08287e-18
    ciVDD_12 (VDD_160 VSS) capacitor c=7.29904e-18
    ciVDD_11 (VDD_163 VSS) capacitor c=1.71175e-18
    ciVDD_10 (VDD_168 VSS) capacitor c=3.97088e-18
    ciVDD_9 (VDD_169 VSS) capacitor c=7.12773e-18
    ciVDD_8 (VDD_170 VSS) capacitor c=4.39784e-18
    ciVDD_7 (VDD_173 VSS) capacitor c=1.71175e-18
    ciVDD_6 (VDD_175 VSS) capacitor c=3.37872e-18
    ciVDD_5 (VDD_179 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_180 VSS) capacitor c=5.85144e-18
    ciVDD_3 (VDD_181 VSS) capacitor c=6.51184e-18
    ciVDD_2 (VDD_184 VSS) capacitor c=1.56668e-17
    ciVDD_1 (VDD_186 VSS) capacitor c=1.70056e-18
    ciVDD_0 (VDD_229 VSS) capacitor c=1.39488e-17
    ciVSS_41 (VSS_2 VSS) capacitor c=6.13481e-17
    ciVSS_40 (VSS_11 VSS) capacitor c=8.86922e-17
    ciVSS_39 (VSS_12 VSS) capacitor c=1.23613e-16
    ciVSS_38 (VSS_14 VSS) capacitor c=2.45776e-16
    ciVSS_37 (VSS_30 VSS) capacitor c=7.22473e-17
    ciVSS_36 (VSS_31 VSS) capacitor c=1.18573e-16
    ciVSS_35 (VSS_33 VSS) capacitor c=4.69302e-17
    ciVSS_34 (VSS_40 VSS) capacitor c=8.80502e-17
    ciVSS_33 (VSS_46 VSS) capacitor c=1.89634e-16
    ciVSS_32 (VSS_62 VSS) capacitor c=7.16586e-17
    ciVSS_31 (VSS_63 VSS) capacitor c=1.13402e-16
    ciVSS_30 (VSS_65 VSS) capacitor c=4.56727e-17
    ciVSS_29 (VSS_72 VSS) capacitor c=7.70465e-17
    ciVSS_28 (VSS_80 VSS) capacitor c=6.59067e-17
    ciVSS_27 (VSS_83 VSS) capacitor c=3.58509e-18
    ciVSS_26 (VSS_84 VSS) capacitor c=3.58509e-18
    ciVSS_25 (VSS_85 VSS) capacitor c=3.58509e-18
    ciVSS_24 (VSS_86 VSS) capacitor c=3.58509e-18
    ciVSS_23 (VSS_88 VSS) capacitor c=3.58509e-18
    ciVSS_22 (VSS_96 VSS) capacitor c=2.47056e-18
    ciVSS_21 (VSS_98 VSS) capacitor c=1.41789e-18
    ciVSS_20 (VSS_100 VSS) capacitor c=3.46252e-18
    ciVSS_19 (VSS_101 VSS) capacitor c=1.56128e-18
    ciVSS_18 (VSS_102 VSS) capacitor c=2.86014e-18
    ciVSS_17 (VSS_105 VSS) capacitor c=8.05039e-18
    ciVSS_16 (VSS_109 VSS) capacitor c=8.25279e-18
    ciVSS_15 (VSS_119 VSS) capacitor c=9.95238e-19
    ciVSS_14 (VSS_120 VSS) capacitor c=6.76881e-18
    ciVSS_13 (VSS_123 VSS) capacitor c=1.21888e-18
    ciVSS_12 (VSS_128 VSS) capacitor c=2.65263e-18
    ciVSS_11 (VSS_129 VSS) capacitor c=3.50743e-18
    ciVSS_10 (VSS_132 VSS) capacitor c=5.34552e-18
    ciVSS_9 (VSS_136 VSS) capacitor c=8.05456e-18
    ciVSS_8 (VSS_140 VSS) capacitor c=8.88806e-19
    ciVSS_7 (VSS_141 VSS) capacitor c=1.91494e-18
    ciVSS_6 (VSS_147 VSS) capacitor c=4.36885e-18
    ciVSS_5 (VSS_155 VSS) capacitor c=5.9471e-18
    ciVSS_4 (VSS_156 VSS) capacitor c=2.33552e-18
    ciVSS_3 (VSS_159 VSS) capacitor c=2.63325e-18
    ciVSS_2 (VSS_163 VSS) capacitor c=4.06582e-18
    ciVSS_1 (VSS_166 VSS) capacitor c=8.11737e-17
    ciVSS_0 (VSS_169 VSS) capacitor c=7.77889e-17
    cinet68_47 (net68_22 VSS) capacitor c=4.28147e-18
    cinet68_46 (net68_28 VSS) capacitor c=1.95098e-16
    cinet68_45 (net68_39 VSS) capacitor c=5.65699e-16
    cinet68_44 (net68_45 VSS) capacitor c=5.13601e-18
    cinet68_43 (net68_50 VSS) capacitor c=2.23559e-17
    cinet68_42 (net68_58 VSS) capacitor c=1.51948e-17
    cinet68_41 (net68_66 VSS) capacitor c=1.92647e-17
    cinet68_40 (net68_74 VSS) capacitor c=1.60938e-17
    cinet68_39 (net68_82 VSS) capacitor c=2.11871e-18
    cinet68_38 (net68_85 VSS) capacitor c=4.66991e-18
    cinet68_37 (net68_90 VSS) capacitor c=7.42966e-18
    cinet68_36 (net68_93 VSS) capacitor c=2.22299e-18
    cinet68_35 (net68_133 VSS) capacitor c=1.10535e-16
    cinet68_34 (net68_136 VSS) capacitor c=9.33489e-17
    cinet68_33 (net68_137 VSS) capacitor c=1.32415e-17
    cinet68_32 (net68_140 VSS) capacitor c=3.83756e-17
    cinet68_31 (net68_141 VSS) capacitor c=1.07008e-16
    cinet68_30 (net68_143 VSS) capacitor c=1.00134e-16
    cinet68_29 (net68_144 VSS) capacitor c=1.79891e-17
    cinet68_28 (net68_146 VSS) capacitor c=6.78252e-17
    cinet68_27 (net68_148 VSS) capacitor c=4.71044e-17
    cinet68_26 (net68_149 VSS) capacitor c=4.10789e-17
    cinet68_25 (net68_150 VSS) capacitor c=1.36171e-17
    cinet68_24 (net68_153 VSS) capacitor c=4.07381e-17
    cinet68_23 (net68_154 VSS) capacitor c=1.1901e-16
    cinet68_22 (net68_156 VSS) capacitor c=4.53199e-17
    cinet68_21 (net68_157 VSS) capacitor c=1.26624e-17
    cinet68_20 (net68_160 VSS) capacitor c=3.3158e-17
    cinet68_19 (net68_161 VSS) capacitor c=1.0705e-16
    cinet68_18 (net68_163 VSS) capacitor c=8.47807e-18
    cinet68_17 (net68_166 VSS) capacitor c=3.28253e-17
    cinet68_16 (net68_167 VSS) capacitor c=1.14388e-16
    cinet68_15 (net68_169 VSS) capacitor c=1.24621e-16
    cinet68_14 (net68_172 VSS) capacitor c=1.3735e-16
    cinet68_13 (net68_173 VSS) capacitor c=2.59751e-17
    cinet68_12 (net68_175 VSS) capacitor c=9.17464e-17
    cinet68_11 (net68_180 VSS) capacitor c=5.87435e-17
    cinet68_10 (net68_181 VSS) capacitor c=1.49533e-16
    cinet68_9 (net68_183 VSS) capacitor c=8.49537e-18
    cinet68_8 (net68_184 VSS) capacitor c=8.49237e-18
    cinet68_7 (net68_185 VSS) capacitor c=5.4647e-18
    cinet68_6 (net68_186 VSS) capacitor c=6.81208e-18
    cinet68_5 (net68_243 VSS) capacitor c=3.24768e-17
    cinet68_4 (net68_244 VSS) capacitor c=1.52335e-17
    cinet68_3 (net68_254 VSS) capacitor c=1.71175e-18
    cinet68_2 (net68_256 VSS) capacitor c=7.91446e-18
    cinet68_1 (net68_259 VSS) capacitor c=3.97088e-18
    cinet68_0 (net68_260 VSS) capacitor c=9.99572e-17
    cinet255_7 (net255_3 VSS) capacitor c=4.4775e-17
    cinet255_6 (net255_4 VSS) capacitor c=1.09485e-16
    cinet255_5 (net255_6 VSS) capacitor c=2.66568e-17
    cinet255_4 (net255_7 VSS) capacitor c=1.32688e-17
    cinet255_3 (net255_9 VSS) capacitor c=7.62621e-17
    cinet255_2 (net255_12 VSS) capacitor c=5.4076e-17
    cinet255_1 (net255_13 VSS) capacitor c=1.12958e-16
    cinet255_0 (net255_17 VSS) capacitor c=2.35668e-17
    cinet200_6 (net200_3 VSS) capacitor c=1.0754e-17
    cinet200_5 (net200_4 VSS) capacitor c=1.15779e-16
    cinet200_4 (net200_8 VSS) capacitor c=7.737e-17
    cinet200_3 (net200_12 VSS) capacitor c=1.59971e-17
    cinet200_2 (net200_13 VSS) capacitor c=1.20847e-16
    cinet200_1 (net200_17 VSS) capacitor c=1.7133e-17
    cinet200_0 (net200_18 VSS) capacitor c=2.13992e-17
    cinet499_6 (net499_3 VSS) capacitor c=6.74133e-17
    cinet499_5 (net499_4 VSS) capacitor c=1.27446e-16
    cinet499_4 (net499_8 VSS) capacitor c=6.5597e-17
    cinet499_3 (net499_9 VSS) capacitor c=1.26315e-16
    cinet499_2 (net499_12 VSS) capacitor c=5.7048e-17
    cinet499_1 (net499_15 VSS) capacitor c=1.97731e-17
    cinet499_0 (net499_19 VSS) capacitor c=2.04683e-17
    cinet5_46 (net5_42 VSS) capacitor c=9.2116e-18
    cinet5_45 (net5_45 VSS) capacitor c=4.27597e-18
    cinet5_44 (net5_48 VSS) capacitor c=1.71472e-16
    cinet5_43 (net5_50 VSS) capacitor c=2.48575e-17
    cinet5_42 (net5_58 VSS) capacitor c=2.31602e-17
    cinet5_41 (net5_66 VSS) capacitor c=6.31515e-18
    cinet5_40 (net5_69 VSS) capacitor c=4.47573e-18
    cinet5_39 (net5_72 VSS) capacitor c=1.68138e-16
    cinet5_38 (net5_80 VSS) capacitor c=3.15199e-17
    cinet5_37 (net5_88 VSS) capacitor c=1.77129e-17
    cinet5_36 (net5_99 VSS) capacitor c=2.80371e-18
    cinet5_35 (net5_110 VSS) capacitor c=9.31837e-18
    cinet5_34 (net5_118 VSS) capacitor c=4.98683e-18
    cinet5_33 (net5_121 VSS) capacitor c=3.25905e-18
    cinet5_32 (net5_124 VSS) capacitor c=2.15606e-16
    cinet5_31 (net5_126 VSS) capacitor c=2.58986e-17
    cinet5_30 (net5_134 VSS) capacitor c=2.23851e-17
    cinet5_29 (net5_151 VSS) capacitor c=4.11003e-18
    cinet5_28 (net5_156 VSS) capacitor c=5.54274e-18
    cinet5_27 (net5_162 VSS) capacitor c=1.76941e-16
    cinet5_26 (net5_170 VSS) capacitor c=2.2354e-17
    cinet5_25 (net5_178 VSS) capacitor c=2.70562e-17
    cinet5_24 (net5_186 VSS) capacitor c=3.98759e-18
    cinet5_23 (net5_189 VSS) capacitor c=5.42358e-18
    cinet5_22 (net5_261 VSS) capacitor c=1.80904e-16
    cinet5_21 (net5_267 VSS) capacitor c=3.98565e-18
    cinet5_20 (net5_269 VSS) capacitor c=1.11996e-16
    cinet5_19 (net5_270 VSS) capacitor c=8.23421e-17
    cinet5_18 (net5_271 VSS) capacitor c=1.32176e-17
    cinet5_17 (net5_272 VSS) capacitor c=5.93267e-17
    cinet5_16 (net5_273 VSS) capacitor c=1.93643e-17
    cinet5_15 (net5_276 VSS) capacitor c=3.95529e-17
    cinet5_14 (net5_277 VSS) capacitor c=1.12739e-16
    cinet5_13 (net5_281 VSS) capacitor c=7.88302e-17
    cinet5_12 (net5_282 VSS) capacitor c=1.28057e-16
    cinet5_11 (net5_285 VSS) capacitor c=2.66634e-17
    cinet5_10 (net5_287 VSS) capacitor c=1.96908e-17
    cinet5_9 (net5_290 VSS) capacitor c=2.23263e-16
    cinet5_8 (net5_293 VSS) capacitor c=1.36974e-17
    cinet5_7 (net5_296 VSS) capacitor c=3.55613e-17
    cinet5_6 (net5_298 VSS) capacitor c=2.41281e-17
    cinet5_5 (net5_390 VSS) capacitor c=3.15579e-17
    cinet5_4 (net5_391 VSS) capacitor c=2.10517e-17
    cinet5_3 (net5_399 VSS) capacitor c=1.26449e-16
    cinet5_2 (net5_425 VSS) capacitor c=5.37838e-17
    cinet5_1 (net5_426 VSS) capacitor c=1.33345e-17
    cinet5_0 (net5_434 VSS) capacitor c=5.10534e-17
    cinet67_46 (net67_22 VSS) capacitor c=2.98735e-18
    cinet67_45 (net67_28 VSS) capacitor c=2.10869e-16
    cinet67_44 (net67_39 VSS) capacitor c=3.71209e-16
    cinet67_43 (net67_45 VSS) capacitor c=3.83244e-18
    cinet67_42 (net67_50 VSS) capacitor c=2.24052e-17
    cinet67_41 (net67_58 VSS) capacitor c=2.24576e-17
    cinet67_40 (net67_66 VSS) capacitor c=2.17791e-17
    cinet67_39 (net67_74 VSS) capacitor c=2.69022e-17
    cinet67_38 (net67_82 VSS) capacitor c=4.04637e-18
    cinet67_37 (net67_85 VSS) capacitor c=6.2992e-18
    cinet67_36 (net67_90 VSS) capacitor c=5.17301e-18
    cinet67_35 (net67_93 VSS) capacitor c=3.8335e-18
    cinet67_34 (net67_132 VSS) capacitor c=6.4409e-17
    cinet67_33 (net67_135 VSS) capacitor c=7.18643e-17
    cinet67_32 (net67_138 VSS) capacitor c=2.61153e-17
    cinet67_31 (net67_139 VSS) capacitor c=1.48668e-17
    cinet67_30 (net67_140 VSS) capacitor c=9.23799e-17
    cinet67_29 (net67_144 VSS) capacitor c=5.74087e-17
    cinet67_28 (net67_145 VSS) capacitor c=1.10806e-16
    cinet67_27 (net67_148 VSS) capacitor c=4.59291e-17
    cinet67_26 (net67_149 VSS) capacitor c=4.07303e-17
    cinet67_25 (net67_150 VSS) capacitor c=1.36312e-17
    cinet67_24 (net67_153 VSS) capacitor c=4.44551e-17
    cinet67_23 (net67_154 VSS) capacitor c=1.1901e-16
    cinet67_22 (net67_156 VSS) capacitor c=4.93716e-17
    cinet67_21 (net67_157 VSS) capacitor c=1.38951e-17
    cinet67_20 (net67_160 VSS) capacitor c=3.28677e-17
    cinet67_19 (net67_161 VSS) capacitor c=1.07086e-16
    cinet67_18 (net67_163 VSS) capacitor c=9.37529e-18
    cinet67_17 (net67_166 VSS) capacitor c=3.77549e-17
    cinet67_16 (net67_167 VSS) capacitor c=1.13458e-16
    cinet67_15 (net67_169 VSS) capacitor c=1.35076e-16
    cinet67_14 (net67_172 VSS) capacitor c=1.12827e-16
    cinet67_13 (net67_173 VSS) capacitor c=2.81491e-17
    cinet67_12 (net67_175 VSS) capacitor c=1.03292e-16
    cinet67_11 (net67_180 VSS) capacitor c=6.41124e-17
    cinet67_10 (net67_181 VSS) capacitor c=1.52763e-16
    cinet67_9 (net67_183 VSS) capacitor c=7.65729e-18
    cinet67_8 (net67_184 VSS) capacitor c=8.49237e-18
    cinet67_7 (net67_185 VSS) capacitor c=5.45269e-18
    cinet67_6 (net67_186 VSS) capacitor c=1.19686e-17
    cinet67_5 (net67_243 VSS) capacitor c=3.18092e-17
    cinet67_4 (net67_244 VSS) capacitor c=1.91381e-17
    cinet67_3 (net67_254 VSS) capacitor c=1.71175e-18
    cinet67_2 (net67_256 VSS) capacitor c=8.43533e-18
    cinet67_1 (net67_259 VSS) capacitor c=3.97088e-18
    cinet67_0 (net67_260 VSS) capacitor c=9.3984e-17
    cinet25_7 (net25_3 VSS) capacitor c=4.56009e-17
    cinet25_6 (net25_4 VSS) capacitor c=1.09459e-16
    cinet25_5 (net25_6 VSS) capacitor c=3.19895e-17
    cinet25_4 (net25_7 VSS) capacitor c=1.34182e-17
    cinet25_3 (net25_9 VSS) capacitor c=7.83273e-17
    cinet25_2 (net25_12 VSS) capacitor c=5.5317e-17
    cinet25_1 (net25_13 VSS) capacitor c=1.12958e-16
    cinet25_0 (net25_17 VSS) capacitor c=2.89914e-17
    cinet20_6 (net20_3 VSS) capacitor c=1.59971e-17
    cinet20_5 (net20_4 VSS) capacitor c=1.19112e-16
    cinet20_4 (net20_8 VSS) capacitor c=7.55678e-17
    cinet20_3 (net20_12 VSS) capacitor c=1.59971e-17
    cinet20_2 (net20_13 VSS) capacitor c=1.20843e-16
    cinet20_1 (net20_17 VSS) capacitor c=2.59442e-17
    cinet20_0 (net20_18 VSS) capacitor c=2.11371e-17
    ciCDN_57 (CDN_66 VSS) capacitor c=3.98759e-18
    ciCDN_56 (CDN_69 VSS) capacitor c=2.81125e-18
    ciCDN_55 (CDN_72 VSS) capacitor c=1.95495e-16
    ciCDN_54 (CDN_74 VSS) capacitor c=2.23316e-17
    ciCDN_53 (CDN_82 VSS) capacitor c=1.57811e-17
    ciCDN_52 (CDN_90 VSS) capacitor c=3.00043e-18
    ciCDN_51 (CDN_104 VSS) capacitor c=2.96645e-18
    ciCDN_50 (CDN_110 VSS) capacitor c=1.90519e-16
    ciCDN_49 (CDN_118 VSS) capacitor c=2.23977e-17
    ciCDN_48 (CDN_126 VSS) capacitor c=2.2006e-17
    ciCDN_47 (CDN_134 VSS) capacitor c=5.75798e-18
    ciCDN_46 (CDN_137 VSS) capacitor c=4.17526e-18
    ciCDN_45 (CDN_140 VSS) capacitor c=3.68486e-16
    ciCDN_44 (CDN_142 VSS) capacitor c=3.32208e-18
    ciCDN_43 (CDN_145 VSS) capacitor c=1.74211e-18
    ciCDN_42 (CDN_150 VSS) capacitor c=1.70177e-17
    ciCDN_41 (CDN_158 VSS) capacitor c=2.24618e-17
    ciCDN_40 (CDN_172 VSS) capacitor c=1.63457e-17
    ciCDN_39 (CDN_180 VSS) capacitor c=7.94903e-18
    ciCDN_38 (CDN_183 VSS) capacitor c=3.84103e-18
