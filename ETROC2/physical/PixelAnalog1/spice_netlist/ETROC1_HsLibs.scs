    ciU_26 (U_45 VSS) capacitor c=5.13601e-18
    ciU_25 (U_50 VSS) capacitor c=2.23559e-17
    ciU_24 (U_58 VSS) capacitor c=1.51948e-17
    ciU_23 (U_66 VSS) capacitor c=1.88601e-17
    ciU_22 (U_74 VSS) capacitor c=9.56216e-18
    ciU_21 (U_82 VSS) capacitor c=2.11871e-18
    ciU_20 (U_85 VSS) capacitor c=2.742e-18
    ciU_19 (U_90 VSS) capacitor c=2.43312e-19
    ciU_18 (U_93 VSS) capacitor c=2.22299e-18
    ciU_17 (U_133 VSS) capacitor c=1.13127e-16
    ciU_16 (U_134 VSS) capacitor c=1.15884e-16
    ciU_15 (U_136 VSS) capacitor c=1.23263e-16
    ciU_14 (U_137 VSS) capacitor c=1.91786e-17
    ciU_13 (U_140 VSS) capacitor c=3.35897e-17
    ciU_12 (U_141 VSS) capacitor c=1.36256e-16
    ciU_11 (U_143 VSS) capacitor c=7.98509e-17
    ciU_10 (U_144 VSS) capacitor c=8.08484e-18
    ciU_9 (U_146 VSS) capacitor c=1.1198e-16
    ciU_8 (U_148 VSS) capacitor c=1.75176e-16
    ciU_7 (U_149 VSS) capacitor c=7.75523e-17
    ciU_6 (U_150 VSS) capacitor c=1.90487e-17
    ciU_5 (U_151 VSS) capacitor c=1.71298e-17
    ciU_4 (U_152 VSS) capacitor c=7.32261e-18
    ciU_3 (U_155 VSS) capacitor c=1.35226e-17
    ciU_2 (U_157 VSS) capacitor c=2.13321e-17
    ciU_1 (U_217 VSS) capacitor c=2.95293e-17
    ciU_0 (U_218 VSS) capacitor c=1.65792e-17
    ciVDD_38 (VDD_4 VSS) capacitor c=1.30826e-16
    ciVDD_37 (VDD_13 VSS) capacitor c=4.72261e-17
    ciVDD_36 (VDD_14 VSS) capacitor c=2.63453e-17
    ciVDD_35 (VDD_20 VSS) capacitor c=6.40666e-17
    ciVDD_34 (VDD_23 VSS) capacitor c=6.37447e-17
    ciVDD_33 (VDD_30 VSS) capacitor c=6.45066e-17
    ciVDD_32 (VDD_31 VSS) capacitor c=1.21446e-16
    ciVDD_31 (VDD_33 VSS) capacitor c=7.45153e-17
    ciVDD_30 (VDD_43 VSS) capacitor c=8.80528e-17
    ciVDD_29 (VDD_44 VSS) capacitor c=9.3734e-17
    ciVDD_28 (VDD_46 VSS) capacitor c=1.07797e-16
    ciVDD_27 (VDD_56 VSS) capacitor c=2.40807e-16
    ciVDD_26 (VDD_64 VSS) capacitor c=3.64928e-16
    ciVDD_25 (VDD_70 VSS) capacitor c=7.74034e-17
    ciVDD_24 (VDD_78 VSS) capacitor c=3.58509e-18
    ciVDD_23 (VDD_80 VSS) capacitor c=3.58509e-18
    ciVDD_22 (VDD_81 VSS) capacitor c=3.58509e-18
    ciVDD_21 (VDD_82 VSS) capacitor c=3.58509e-18
    ciVDD_20 (VDD_88 VSS) capacitor c=1.11099e-18
    ciVDD_19 (VDD_89 VSS) capacitor c=2.96445e-18
    ciVDD_18 (VDD_90 VSS) capacitor c=2.31893e-18
    ciVDD_17 (VDD_93 VSS) capacitor c=1.87448e-17
    ciVDD_16 (VDD_97 VSS) capacitor c=1.71175e-18
    ciVDD_15 (VDD_98 VSS) capacitor c=6.92659e-18
    ciVDD_14 (VDD_99 VSS) capacitor c=1.64973e-18
    ciVDD_13 (VDD_102 VSS) capacitor c=9.2188e-18
    ciVDD_12 (VDD_103 VSS) capacitor c=1.66627e-17
    ciVDD_11 (VDD_107 VSS) capacitor c=1.71175e-18
    ciVDD_10 (VDD_109 VSS) capacitor c=9.73151e-18
    ciVDD_9 (MM17_ELT_s VSS) capacitor c=5.37432e-17
    ciVDD_8 (VDD_114 VSS) capacitor c=1.11099e-18
    ciVDD_7 (VDD_116 VSS) capacitor c=8.10776e-18
    ciVDD_6 (VDD_120 VSS) capacitor c=1.11099e-18
    ciVDD_5 (VDD_121 VSS) capacitor c=8.79289e-18
    ciVDD_4 (VDD_122 VSS) capacitor c=1.07074e-18
    ciVDD_3 (VDD_125 VSS) capacitor c=2.18215e-17
    ciVDD_2 (VDD_126 VSS) capacitor c=2.16736e-16
    ciVDD_1 (VDD_127 VSS) capacitor c=8.41531e-17
    ciVDD_0 (VDD_131 VSS) capacitor c=1.23039e-17
    ciVSS_38 (VSS_4 VSS) capacitor c=5.35035e-17
    ciVSS_37 (VSS_10 VSS) capacitor c=4.54487e-17
    ciVSS_36 (VSS_11 VSS) capacitor c=2.63453e-17
    ciVSS_35 (VSS_17 VSS) capacitor c=7.8512e-17
    ciVSS_34 (VSS_18 VSS) capacitor c=7.92333e-19
    ciVSS_33 (VSS_23 VSS) capacitor c=4.60942e-17
    ciVSS_32 (VSS_30 VSS) capacitor c=7.94507e-17
    ciVSS_31 (VSS_31 VSS) capacitor c=7.92333e-19
    ciVSS_30 (VSS_36 VSS) capacitor c=8.81627e-17
    ciVSS_29 (VSS_46 VSS) capacitor c=9.55712e-17
    ciVSS_28 (VSS_47 VSS) capacitor c=1.25484e-16
    ciVSS_27 (VSS_49 VSS) capacitor c=1.01895e-16
    ciVSS_26 (VSS_59 VSS) capacitor c=1.00933e-16
    ciVSS_25 (VSS_63 VSS) capacitor c=1.36362e-16
    ciVSS_24 (VSS_70 VSS) capacitor c=7.56238e-17
    ciVSS_23 (VSS_78 VSS) capacitor c=3.58509e-18
    ciVSS_22 (VSS_80 VSS) capacitor c=3.58509e-18
    ciVSS_21 (VSS_81 VSS) capacitor c=3.58509e-18
    ciVSS_20 (VSS_82 VSS) capacitor c=3.58509e-18
    ciVSS_19 (VSS_87 VSS) capacitor c=2.61063e-18
    ciVSS_18 (VSS_88 VSS) capacitor c=1.95946e-18
    ciVSS_17 (VSS_91 VSS) capacitor c=2.55032e-18
    ciVSS_16 (MM1_ELT_s VSS) capacitor c=5.08702e-18
    ciVSS_15 (VSS_97 VSS) capacitor c=6.34106e-18
    ciVSS_14 (VSS_105 VSS) capacitor c=1.27885e-18
    ciVSS_13 (VSS_106 VSS) capacitor c=9.00521e-19
    ciVSS_12 (VSS_109 VSS) capacitor c=9.63361e-18
    ciVSS_11 (MM3_ELT_s VSS) capacitor c=3.18658e-18
    ciVSS_10 (VSS_116 VSS) capacitor c=2.91606e-18
    ciVSS_9 (VSS_121 VSS) capacitor c=3.05113e-18
    ciVSS_8 (VSS_122 VSS) capacitor c=3.58595e-18
    ciVSS_7 (VSS_125 VSS) capacitor c=7.71031e-18
    ciVSS_6 (MM19_ELT_s VSS) capacitor c=2.49855e-18
    ciVSS_5 (VSS_137 VSS) capacitor c=7.41651e-18
    ciVSS_4 (VSS_141 VSS) capacitor c=6.23788e-18
    ciVSS_3 (VSS_142 VSS) capacitor c=6.9763e-17
    ciVSS_2 (VSS_148 VSS) capacitor c=3.59239e-18
    ciVSS_1 (VSS_156 VSS) capacitor c=7.71817e-17
    ciVSS_0 (VSS_158 VSS) capacitor c=7.18053e-17
    ciCDN_13 (CDN_22 VSS) capacitor c=3.47556e-18
    ciCDN_12 (CDN_28 VSS) capacitor c=2.16149e-16
    ciCDN_11 (CDN_39 VSS) capacitor c=6.60007e-16
    ciCDN_10 (CDN_45 VSS) capacitor c=3.49893e-18
    ciCDN_9 (CDN_50 VSS) capacitor c=2.20514e-17
    ciCDN_8 (CDN_58 VSS) capacitor c=1.57254e-17
    ciCDN_7 (CDN_66 VSS) capacitor c=1.12515e-17
    ciCDN_6 (CDN_74 VSS) capacitor c=1.51948e-17
    ciCDN_5 (CDN_82 VSS) capacitor c=3.00043e-18
    ciCDN_4 (CDN_85 VSS) capacitor c=2.4816e-18
    ciCDN_3 (CDN_90 VSS) capacitor c=5.15427e-18
    ciCDN_2 (CDN_93 VSS) capacitor c=3.85496e-18
    ciCDN_1 (CDN VSS) capacitor c=6.00442e-17
    ciCDN_0 (CDN_203 VSS) capacitor c=4.06785e-17
    cinet027_13 (net027_3 VSS) capacitor c=6.76837e-17
    cinet027_12 (net027_4 VSS) capacitor c=1.14369e-16
    cinet027_11 (net027_6 VSS) capacitor c=1.60827e-16
    cinet027_10 (net027_7 VSS) capacitor c=1.63791e-17
    cinet027_9 (net027_10 VSS) capacitor c=6.81743e-17
    cinet027_8 (net027_13 VSS) capacitor c=4.97638e-17
    cinet027_7 (net027_14 VSS) capacitor c=1.1332e-17
    cinet027_6 (net027_16 VSS) capacitor c=5.23262e-17
    cinet027_5 (net027_20 VSS) capacitor c=1.48334e-17
    cinet027_4 (net027_22 VSS) capacitor c=1.47573e-18
    cinet027_3 (net027_23 VSS) capacitor c=7.65531e-18
    cinet027_2 (net027_24 VSS) capacitor c=4.84428e-18
    cinet027_1 (net027_25 VSS) capacitor c=3.46955e-18
    cinet027_0 (net027_26 VSS) capacitor c=1.11523e-16
    ciCDNN_41 (CDNN_22 VSS) capacitor c=4.09792e-18
    ciCDNN_40 (CDNN_25 VSS) capacitor c=5.80296e-18
    ciCDNN_39 (CDNN_28 VSS) capacitor c=1.80707e-16
    ciCDNN_38 (CDNN_30 VSS) capacitor c=1.9207e-17
    ciCDNN_37 (CDNN_38 VSS) capacitor c=2.2395e-17
    ciCDNN_36 (CDNN_55 VSS) capacitor c=3.77138e-18
    ciCDNN_35 (CDNN_60 VSS) capacitor c=2.96436e-18
    ciCDNN_34 (CDNN_66 VSS) capacitor c=2.18891e-16
    ciCDNN_33 (CDNN_74 VSS) capacitor c=2.20514e-17
    ciCDNN_32 (CDNN_82 VSS) capacitor c=1.99129e-17
    ciCDNN_31 (CDNN_90 VSS) capacitor c=3.48049e-18
    ciCDNN_30 (CDNN_93 VSS) capacitor c=5.65999e-18
    ciCDNN_29 (CDNN_131 VSS) capacitor c=6.13821e-17
    ciCDNN_28 (CDNN_139 VSS) capacitor c=8.31075e-18
    ciCDNN_27 (CDNN_140 VSS) capacitor c=4.87102e-17
    ciCDNN_26 (CDNN_141 VSS) capacitor c=2.09112e-17
    ciCDNN_25 (CDNN_143 VSS) capacitor c=1.18007e-17
    ciCDNN_24 (CDNN_144 VSS) capacitor c=1.54622e-17
    ciCDNN_23 (CDNN_146 VSS) capacitor c=5.75605e-17
    ciCDNN_22 (CDNN_147 VSS) capacitor c=4.27194e-17
    ciCDNN_21 (CDNN_153 VSS) capacitor c=1.57648e-16
    ciCDNN_20 (CDNN_159 VSS) capacitor c=8.39812e-18
    ciCDNN_19 (CDNN_160 VSS) capacitor c=7.11517e-17
    ciCDNN_18 (CDNN_162 VSS) capacitor c=8.51642e-18
    ciCDNN_17 (CDNN_166 VSS) capacitor c=1.05695e-17
    ciCDNN_16 (CDNN_169 VSS) capacitor c=5.38286e-17
    ciCDNN_15 (CDNN_172 VSS) capacitor c=9.39297e-17
    ciCDNN_14 (CDNN_173 VSS) capacitor c=3.00501e-17
    ciCDNN_13 (CDNN_174 VSS) capacitor c=1.07909e-17
    ciCDNN_12 (CDNN_175 VSS) capacitor c=3.69533e-17
    ciCDNN_11 (CDNN_179 VSS) capacitor c=9.63813e-18
    ciCDNN_10 (CDNN_180 VSS) capacitor c=7.93616e-17
    ciCDNN_9 (CDNN_187 VSS) capacitor c=2.68394e-17
    ciCDNN_8 (CDNN_188 VSS) capacitor c=4.54567e-17
    ciCDNN_7 (CDNN_189 VSS) capacitor c=5.54143e-18
    ciCDNN_6 (CDNN_190 VSS) capacitor c=1.17397e-17
    ciCDNN_5 (CDNN_192 VSS) capacitor c=2.53969e-17
    ciCDNN_4 (CDNN_193 VSS) capacitor c=7.90512e-17
    ciCDNN_3 (CDNN_235 VSS) capacitor c=1.45816e-17
    ciCDNN_2 (CDNN_252 VSS) capacitor c=5.34489e-17
    ciCDNN_1 (CDNN_263 VSS) capacitor c=1.07921e-16
    ciCDNN_0 (CDNN_270 VSS) capacitor c=3.70223e-16
    ciY_36 (Y_22 VSS) capacitor c=4.06555e-18
    ciY_35 (Y_28 VSS) capacitor c=2.00912e-16
    ciY_34 (Y_36 VSS) capacitor c=2.23438e-17
    ciY_33 (Y_44 VSS) capacitor c=2.17311e-17
    ciY_32 (Y_52 VSS) capacitor c=2.96436e-18
    ciY_31 (Y_55 VSS) capacitor c=8.13032e-18
    ciY_30 (Y_60 VSS) capacitor c=4.21118e-18
    ciY_29 (Y_63 VSS) capacitor c=3.2371e-18
    ciY_28 (Y_66 VSS) capacitor c=1.90514e-16
    ciY_27 (Y_68 VSS) capacitor c=1.98618e-17
    ciY_26 (Y_76 VSS) capacitor c=2.2351e-17
    ciY_25 (Y_87 VSS) capacitor c=3.36897e-18
    ciY_24 (Y_131 VSS) capacitor c=4.71627e-17
    ciY_23 (Y_133 VSS) capacitor c=1.03228e-17
    ciY_22 (Y_134 VSS) capacitor c=1.32871e-17
    ciY_21 (Y_137 VSS) capacitor c=5.33082e-17
    ciY_20 (Y_138 VSS) capacitor c=1.22065e-16
    ciY_19 (Y_140 VSS) capacitor c=1.91803e-17
    ciY_18 (Y_141 VSS) capacitor c=5.35385e-17
    ciY_17 (Y_142 VSS) capacitor c=1.80725e-16
    ciY_16 (Y_148 VSS) capacitor c=5.316e-17
    ciY_15 (Y_149 VSS) capacitor c=5.28663e-17
    ciY_14 (Y_154 VSS) capacitor c=1.21756e-16
    ciY_13 (Y_156 VSS) capacitor c=8.06407e-18
    ciY_12 (Y_158 VSS) capacitor c=5.24547e-17
    ciY_11 (Y_159 VSS) capacitor c=2.83734e-17
    ciY_10 (Y_162 VSS) capacitor c=1.86053e-16
    ciY_9 (Y_163 VSS) capacitor c=4.32177e-17
    ciY_8 (Y_166 VSS) capacitor c=3.22844e-17
    ciY_7 (Y_168 VSS) capacitor c=6.66044e-17
    ciY_6 (Y_169 VSS) capacitor c=9.91609e-18
    ciY_5 (Y_172 VSS) capacitor c=9.44285e-18
    ciY_4 (Y_173 VSS) capacitor c=9.62381e-17
    ciY_3 (Y_177 VSS) capacitor c=2.39782e-17
    ciY_2 (Y_202 VSS) capacitor c=1.41708e-17
    ciY_1 (Y_231 VSS) capacitor c=8.1431e-18
    ciY_0 (Y_252 VSS) capacitor c=1.11366e-16
    cinet026_11 (net026_3 VSS) capacitor c=1.11717e-16
    cinet026_10 (net026_8 VSS) capacitor c=4.24439e-17
    cinet026_9 (net026_9 VSS) capacitor c=1.37932e-16
    cinet026_8 (net026_11 VSS) capacitor c=7.82636e-17
    cinet026_7 (net026_12 VSS) capacitor c=1.40427e-17
    cinet026_6 (net026_13 VSS) capacitor c=4.88653e-17
    cinet026_5 (net026_14 VSS) capacitor c=1.54197e-17
    cinet026_4 (net026_16 VSS) capacitor c=6.49782e-17
    cinet026_3 (net026_20 VSS) capacitor c=6.52499e-19
    cinet026_2 (net026_22 VSS) capacitor c=2.36596e-18
    cinet026_1 (net026_25 VSS) capacitor c=7.30039e-18
    cinet026_0 (net026_26 VSS) capacitor c=8.85041e-17
    ciX_20 (X_14 VSS) capacitor c=3.00043e-18
    ciX_19 (X_17 VSS) capacitor c=2.05848e-18
    ciX_18 (X_20 VSS) capacitor c=2.2337e-16
    ciX_17 (X_22 VSS) capacitor c=2.23559e-17
    ciX_16 (X_30 VSS) capacitor c=1.3338e-17
    ciX_15 (X_44 VSS) capacitor c=1.34086e-17
    ciX_14 (X_52 VSS) capacitor c=4.04637e-18
    ciX_13 (X_55 VSS) capacitor c=3.95367e-18
    ciX_12 (X_82 VSS) capacitor c=5.02712e-17
    ciX_11 (X_83 VSS) capacitor c=1.25471e-16
    ciX_10 (X_87 VSS) capacitor c=4.13218e-17
    ciX_9 (X_88 VSS) capacitor c=1.13426e-16
    ciX_8 (X_90 VSS) capacitor c=2.67326e-17
    ciX_7 (X_91 VSS) capacitor c=1.50894e-17
    ciX_6 (X_93 VSS) capacitor c=4.859e-17
    ciX_5 (X_95 VSS) capacitor c=4.47871e-17
    ciX_4 (X_98 VSS) capacitor c=1.18935e-16
    ciX_3 (X_103 VSS) capacitor c=2.91668e-17
    ciX_2 (X_105 VSS) capacitor c=1.17442e-17
    ciX_1 (X_143 VSS) capacitor c=2.01281e-17
    ciX_0 (X_144 VSS) capacitor c=4.06295e-17
    cinet29_10 (net29_3 VSS) capacitor c=4.49036e-17
    cinet29_9 (net29_4 VSS) capacitor c=1.26373e-16
    cinet29_8 (net29_6 VSS) capacitor c=2.26664e-17
    cinet29_7 (net29_7 VSS) capacitor c=1.48651e-17
    cinet29_6 (net29_10 VSS) capacitor c=1.50491e-16
    cinet29_5 (net29_11 VSS) capacitor c=5.71583e-18
    cinet29_4 (MM10_ELT_s VSS) capacitor c=3.97088e-18
    cinet29_3 (net29_15 VSS) capacitor c=1.1046e-16
    cinet29_2 (net29_17 VSS) capacitor c=1.71175e-18
    cinet29_1 (net29_18 VSS) capacitor c=2.96186e-18
    cinet29_0 (net29_19 VSS) capacitor c=8.46013e-18
    ciCPNN_53 (CPNN_45 VSS) capacitor c=1.85695e-16
    ciCPNN_52 (CPNN_51 VSS) capacitor c=5.31198e-18
    ciCPNN_51 (CPNN_56 VSS) capacitor c=2.37143e-17
    ciCPNN_50 (CPNN_64 VSS) capacitor c=2.76145e-17
    ciCPNN_49 (CPNN_72 VSS) capacitor c=9.00885e-18
    ciCPNN_48 (CPNN_75 VSS) capacitor c=5.8276e-18
    ciCPNN_47 (CPNN_80 VSS) capacitor c=1.78348e-18
    ciCPNN_46 (CPNN_83 VSS) capacitor c=2.79328e-18
    ciCPNN_45 (CPNN_86 VSS) capacitor c=1.5978e-16
    ciCPNN_44 (CPNN_88 VSS) capacitor c=1.57718e-17
    ciCPNN_43 (CPNN_96 VSS) capacitor c=2.17037e-17
    ciCPNN_42 (CPNN_104 VSS) capacitor c=9.83896e-18
    ciCPNN_41 (CPNN_110 VSS) capacitor c=2.06938e-16
    ciCPNN_40 (CPNN_127 VSS) capacitor c=4.26554e-18
    ciCPNN_39 (CPNN_132 VSS) capacitor c=3.21652e-17
    ciCPNN_38 (CPNN_140 VSS) capacitor c=1.9725e-17
    ciCPNN_37 (CPNN_148 VSS) capacitor c=4.09251e-18
    ciCPNN_36 (CPNN_151 VSS) capacitor c=1.7885e-18
    ciCPNN_35 (CPNN_156 VSS) capacitor c=1.02225e-17
    ciCPNN_34 (CPNN_159 VSS) capacitor c=4.39198e-18
    ciCPNN_33 (CPNN_162 VSS) capacitor c=2.24246e-16
    ciCPNN_32 (CPNN_164 VSS) capacitor c=3.01078e-17
    ciCPNN_31 (CPNN_172 VSS) capacitor c=2.28928e-17
    ciCPNN_30 (CPNN_180 VSS) capacitor c=3.07359e-17
    ciCPNN_29 (CPNN_263 VSS) capacitor c=4.07359e-17
    ciCPNN_28 (CPNN_264 VSS) capacitor c=1.13565e-16
    ciCPNN_27 (CPNN_268 VSS) capacitor c=1.57628e-16
    ciCPNN_26 (CPNN_269 VSS) capacitor c=3.32732e-16
    ciCPNN_25 (CPNN_278 VSS) capacitor c=2.8661e-17
    ciCPNN_24 (CPNN_280 VSS) capacitor c=2.2882e-17
    ciCPNN_23 (CPNN_281 VSS) capacitor c=6.43325e-17
    ciCPNN_22 (CPNN_286 VSS) capacitor c=1.08976e-17
    ciCPNN_21 (CPNN_288 VSS) capacitor c=4.81911e-17
    ciCPNN_20 (CPNN_293 VSS) capacitor c=2.87162e-17
    ciCPNN_19 (CPNN_297 VSS) capacitor c=1.97347e-17
    ciCPNN_18 (CPNN_299 VSS) capacitor c=1.54859e-17
    ciCPNN_17 (CPNN_304 VSS) capacitor c=1.42054e-17
    ciCPNN_16 (CPNN_305 VSS) capacitor c=1.93859e-17
    ciCPNN_15 (CPNN_307 VSS) capacitor c=4.23986e-17
    ciCPNN_14 (CPNN_308 VSS) capacitor c=7.21114e-18
    ciCPNN_13 (CPNN_309 VSS) capacitor c=9.76661e-18
    ciCPNN_12 (CPNN_310 VSS) capacitor c=1.2739e-16
    ciCPNN_11 (CPNN_311 VSS) capacitor c=9.53366e-17
    ciCPNN_10 (CPNN_312 VSS) capacitor c=1.12041e-17
    ciCPNN_9 (CPNN_313 VSS) capacitor c=5.56131e-18
    ciCPNN_8 (CPNN_314 VSS) capacitor c=6.82633e-17
    ciCPNN_7 (CPNN_319 VSS) capacitor c=1.6112e-16
    ciCPNN_6 (CPNN_321 VSS) capacitor c=2.23335e-17
    ciCPNN_5 (CPNN_443 VSS) capacitor c=2.36158e-17
    ciCPNN_4 (CPNN_444 VSS) capacitor c=2.29644e-17
    ciCPNN_3 (CPNN_453 VSS) capacitor c=2.38263e-17
    ciCPNN_2 (CPNN_454 VSS) capacitor c=3.40575e-17
    ciCPNN_1 (CPNN_459 VSS) capacitor c=1.27641e-16
    ciCPNN_0 (CPNN_463 VSS) capacitor c=5.27823e-17
    ciD_18 (D_22 VSS) capacitor c=2.9802e-18
    ciD_17 (D_25 VSS) capacitor c=4.94686e-18
    ciD_16 (D_28 VSS) capacitor c=2.19766e-16
    ciD_15 (D_33 VSS) capacitor c=2.09606e-16
    ciD_14 (D_39 VSS) capacitor c=3.25905e-18
    ciD_13 (D_44 VSS) capacitor c=2.23446e-17
    ciD_12 (D_52 VSS) capacitor c=2.62617e-17
    ciD_11 (D_60 VSS) capacitor c=1.92912e-17
    ciD_10 (D_68 VSS) capacitor c=2.23559e-17
    ciD_9 (D_76 VSS) capacitor c=3.24866e-18
    ciD_8 (D_90 VSS) capacitor c=4.2875e-18
    ciD_7 (D_93 VSS) capacitor c=4.11871e-18
    ciD_6 (D VSS) capacitor c=4.33816e-17
    ciD_5 (D_173 VSS) capacitor c=7.02654e-17
    ciD_4 (D_194 VSS) capacitor c=3.11323e-17
    ciD_3 (D_195 VSS) capacitor c=1.05112e-17
    ciD_2 (D_197 VSS) capacitor c=1.93089e-16
    ciD_1 (D_200 VSS) capacitor c=2.72615e-17
    ciD_0 (D_201 VSS) capacitor c=4.44047e-18
    ciCPN_14 (CPN_22 VSS) capacitor c=3.00043e-18
    ciCPN_13 (CPN_28 VSS) capacitor c=2.08988e-16
    ciCPN_12 (CPN_39 VSS) capacitor c=6.27523e-16
    ciCPN_11 (CPN_45 VSS) capacitor c=3.44142e-18
    ciCPN_10 (CPN_50 VSS) capacitor c=2.23559e-17
    ciCPN_9 (CPN_58 VSS) capacitor c=2.02821e-17
    ciCPN_8 (CPN_66 VSS) capacitor c=1.21265e-17
    ciCPN_7 (CPN_74 VSS) capacitor c=1.51948e-17
    ciCPN_6 (CPN_82 VSS) capacitor c=3.24866e-18
    ciCPN_5 (CPN_85 VSS) capacitor c=4.86502e-18
    ciCPN_4 (CPN_90 VSS) capacitor c=5.55466e-18
    ciCPN_3 (CPN_93 VSS) capacitor c=3.86639e-18
    ciCPN_2 (CPN VSS) capacitor c=4.38362e-17
    ciCPN_1 (CPN_196 VSS) capacitor c=3.13771e-17
    ciCPN_0 (CPN_197 VSS) capacitor c=1.36032e-17
    rnet031_37 (net031_1 net031_4) resistor r=20.2547
    rnet031_36 (net031_1 net031_5) resistor r=9.04595
    rnet031_35 (net031_2 net031_4) resistor r=20.2547
    rnet031_34 (net031_2 net031_8) resistor r=9.04062
    rnet031_33 (MM9_ELT_d net031_4) resistor r=4.36821
    rnet031_32 (MM9_ELT_d net031_6) resistor r=12.3172
    rnet031_31 (MM9_ELT_d net031_6) resistor r=1.62887
    rnet031_30 (MM9_ELT_d net031_9) resistor r=2.55965
    rnet031_29 (MM9_ELT_d net031_13) resistor r=4.04518
    rnet031_28 (MM9_ELT_d net031_20) resistor r=10.2363
    rnet031_27 (net031_5 net031_6) resistor r=12.3172
    rnet031_26 (net031_7 net031_9) resistor r=14.4784
    rnet031_25 (net031_7 net031) resistor r=10.5593
    rnet031_24 (net031_8 net031_9) resistor r=14.4784
    rnet031_23 (net031_10 net031_13) resistor r=4.04518
    rnet031_22 (net031_10 net031_20) resistor r=0.549089
    rnet031_21 (net031_11 net031_13) resistor r=4.04518
    rnet031_20 (net031_11 net031) resistor r=0.730683
    rnet031_19 (MM20_ELT_s net031_13) resistor r=4.04518
    rnet031_18 (MM20_ELT_s net031_15) resistor r=12.3172
    rnet031_17 (MM20_ELT_s net031_15) resistor r=1.62887
    rnet031_16 (MM20_ELT_s net031_18) resistor r=2.55965
    rnet031_15 (MM20_ELT_s net031_19) resistor r=17.3029
    rnet031_14 (net031_14 net031_15) resistor r=12.3172
    rnet031_13 (net031_14 net031_20) resistor r=10.2363
    rnet031_12 (net031_16 net031_18) resistor r=14.4784
    rnet031_11 (net031_16 net031_19) resistor r=9.04062
    rnet031_10 (net031_17 net031_18) resistor r=14.4784
    rnet031_9 (net031_17 net031) resistor r=10.5593
    rQ_28 (Q_1 Q_3) resistor r=0.303776
    rQ_27 (Q_1 Q_18) resistor r=0.0960945
    rQ_26 (Q_3 Q_4) resistor r=13
    rQ_25 (Q_4 MM4_ELT_d) resistor r=8.44
    rQ_24 (Q_6 Q_8) resistor r=0.341082
    rQ_23 (Q_6 Q_20) resistor r=0.0960945
    rQ_22 (Q_8 Q_9) resistor r=8.66667
    rQ_21 (Q_8 Q_11) resistor r=0.639529
    rQ_20 (Q_9 MM7_ELT_d) resistor r=32.3614
    rQ_19 (Q_11 Q_12) resistor r=8.66667
    rQ_18 (Q_11 Q_14) resistor r=0.426353
    rQ_17 (Q_12 MM7_ELT_d) resistor r=16.1807
    rQ_16 (Q_12 Q_15) resistor r=32.3614
    rQ_15 (Q_14 Q_15) resistor r=26
    rQ_14 (Q_17 Q_18) resistor r=0.136636
    rQ_13 (Q_17 Q_21) resistor r=0.0960945
    rQ_12 (Q_19 Q_20) resistor r=0.136636
    rQ_11 (Q_19 Q_22) resistor r=0.0960945
    rQ_10 (Q_21 Q) resistor r=0.156155
    rQ_9 (Q_22 Q) resistor r=0.536277
    rU_132 (MM8_ELT_d U) resistor r=0.01
    rU_131 (U_22 U_28) resistor r=58.3583
    rU_130 (U_22 U_28) resistor r=4.16253
    rU_129 (U_22 U_28) resistor r=58.3583
    rU_128 (U_22 U_28) resistor r=4.16253
    rU_127 (U_25 U_28) resistor r=58.3583
    rU_126 (U_25 U_28) resistor r=5.53947
    rU_125 (U_25 U_28) resistor r=58.3583
    rU_124 (U_25 U_28) resistor r=5.53947
    rU_123 (U_28 U_30) resistor r=11.175
    rU_122 (U_28 U_53) resistor r=24.8333
    rU_121 (U_28 U_50) resistor r=24.8333
    rU_120 (U_28 U_69) resistor r=22.35
    rU_119 (U_28 U_66) resistor r=22.35
    rU_118 (U_28 U_82) resistor r=58.3583
    rU_117 (U_28 U_85) resistor r=58.3583
    rU_116 (U_28 U_53) resistor r=4.16253
    rU_115 (U_28 U_30) resistor r=5.53947
    rU_114 (U_28 U_69) resistor r=2.32428
    rU_113 (U_28 U_50) resistor r=4.16253
    rU_112 (U_28 U_82) resistor r=4.16253
    rU_111 (U_28 U_66) resistor r=4.16253
    rU_110 (U_28 U_85) resistor r=4.16253
    rU_109 (U_28 U_30) resistor r=11.175
    rU_108 (U_28 U_183) resistor r=29.8
    rU_107 (U_28 U_53) resistor r=24.8333
    rU_106 (U_28 U_50) resistor r=24.8333
    rU_105 (U_28 U_69) resistor r=22.35
    rU_104 (U_28 U_66) resistor r=22.35
    rU_103 (U_28 U_82) resistor r=58.3583
    rU_102 (U_28 MM4_ELT_g) resistor r=7.45
    rU_101 (U_28 U_53) resistor r=4.16253
    rU_100 (U_28 U_30) resistor r=5.53947
    rU_99 (U_28 U_69) resistor r=2.32428
    rU_98 (U_28 U_50) resistor r=4.16253
    rU_97 (U_28 U_82) resistor r=4.16253
    rU_96 (U_28 U_66) resistor r=4.16253
    rU_95 (U_28 U_85) resistor r=4.16253
    rU_94 (U_36 U_39) resistor r=11.175
    rU_93 (U_36 U_39) resistor r=5.53947
    rU_92 (U_36 U_39) resistor r=11.175
    rU_91 (U_36 U_39) resistor r=5.53947
    rU_90 (U_39 U_42) resistor r=202.392
    rU_89 (U_39 U_45) resistor r=202.392
    rU_88 (U_39 U_61) resistor r=24.8333
    rU_87 (U_39 U_58) resistor r=24.8333
    rU_86 (U_39 U_77) resistor r=22.35
    rU_85 (U_39 U_74) resistor r=22.35
    rU_84 (U_39 U_90) resistor r=202.392
    rU_83 (U_39 U_93) resistor r=202.392
    rU_82 (U_39 U_42) resistor r=5.53947
    rU_81 (U_39 U_77) resistor r=2.32428
    rU_80 (U_39 U_61) resistor r=4.16253
    rU_79 (U_39 U_45) resistor r=4.16253
    rU_78 (U_39 U_74) resistor r=4.16253
    rU_77 (U_39 U_90) resistor r=4.16253
    rU_76 (U_39 U_58) resistor r=4.16253
    rU_75 (U_39 U_93) resistor r=4.16253
    rU_74 (U_39 U_185) resistor r=31.6625
    rU_73 (U_39 U_42) resistor r=202.392
    rU_72 (U_39 U_45) resistor r=202.392
    rU_71 (U_39 U_61) resistor r=24.8333
    rU_70 (U_39 U_58) resistor r=24.8333
    rU_69 (U_39 U_77) resistor r=22.35
    rU_68 (U_39 U_74) resistor r=22.35
    rU_67 (U_39 U_90) resistor r=202.392
    rU_66 (U_39 MM7_ELT_g) resistor r=7.45
    rU_65 (U_39 U_42) resistor r=5.53947
    rU_64 (U_39 U_77) resistor r=2.32428
    rU_63 (U_39 U_61) resistor r=4.16253
    rU_62 (U_39 U_45) resistor r=4.16253
    rU_61 (U_39 U_74) resistor r=4.16253
    rU_60 (U_39 U_90) resistor r=4.16253
    rU_59 (U_39 U_58) resistor r=4.16253
    rU_58 (U_39 U_93) resistor r=4.16253
    rU_57 (U_85 MM4_ELT_g) resistor r=50.9083
    rU_56 (U_93 MM7_ELT_g) resistor r=194.942
    rU_55 (U_131 U_133) resistor r=0.560068
    rU_54 (U_131 U_137) resistor r=0.0973497
    rU_53 (U_133 U_134) resistor r=13
    rU_52 (U_134 MM5_ELT_d) resistor r=8.44
    rU_51 (U_136 U_137) resistor r=1.40923
    rU_50 (U_136 U_155) resistor r=0.0189266
    rU_49 (U_138 U_140) resistor r=0.207847
    rU_48 (U_138 U_144) resistor r=0.0960945
    rU_47 (U_140 U_141) resistor r=13
    rU_46 (U_141 U) resistor r=8.09035
    rU_45 (U_143 U_144) resistor r=0.694829
    rU_44 (U_143 U_148) resistor r=0.0960945
    rU_43 (U_145 U_146) resistor r=0.767344
    rU_42 (U_145 U_150) resistor r=0.0960945
    rU_41 (U_146 U_155) resistor r=0.0728274
    rU_40 (U_147 U_148) resistor r=1.43877
    rU_39 (U_147 U_155) resistor r=0.0728274
    rU_38 (U_149 U_150) resistor r=0.575519
    rU_37 (U_149 U_152) resistor r=0.0960945
    rU_36 (U_151 U_152) resistor r=0.102553
    rU_35 (U_151 U_157) resistor r=0.0708955
    rU_34 (U_157 U_158) resistor r=10
    rU_33 (U_158 U_217) resistor r=7.45
    rU_32 (U_183 U_218) resistor r=3.725
    rU_31 (U_185 U_218) resistor r=3.725
    rU_30 (U_217 U_218) resistor r=3.725
    rVDD_174 (MM10_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_173 (MM11_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_172 (MM9_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_171 (MM20_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_170 (MM8_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_169 (MM17_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_168 (MM7_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_167 (MM21_ELT_b VDD_39) resistor r=8.66667
    rVDD_166 (MM21_ELT_b VDD_49) resistor r=8.66667
    rVDD_165 (MM21_ELT_b VDD_52) resistor r=8.66667
    rVDD_164 (MM21_ELT_b VDD_67) resistor r=8.66667
    rVDD_163 (MM21_ELT_b VDD_70) resistor r=26
    rVDD_162 (MM21_ELT_b VDD_37) resistor r=45.0133
    rVDD_161 (VDD_2 VDD_11) resistor r=0.490305
    rVDD_160 (VDD_2 VDD_76) resistor r=0.119224
    rVDD_159 (VDD_4 VDD_12) resistor r=8.66667
    rVDD_158 (VDD_4 VDD_8) resistor r=0.639529
    rVDD_157 (VDD_8 VDD_12) resistor r=8.66667
    rVDD_156 (VDD_8 VDD_11) resistor r=0.639529
    rVDD_155 (VDD_11 VDD_12) resistor r=8.66667
    rVDD_154 (VDD_12 MM21_ELT_s) resistor r=1.847
    rVDD_153 (VDD_12 VDD_126) resistor r=20.317
    rVDD_152 (VDD_13 VDD_16) resistor r=0.221413
    rVDD_151 (VDD_13 VDD_78) resistor r=0.0221596
    rVDD_150 (VDD_14 VDD_16) resistor r=0.0336073
    rVDD_149 (VDD_14 VDD_76) resistor r=0.0177921
    rVDD_148 (VDD_16 VDD_17) resistor r=8.66667
    rVDD_147 (VDD_17 VDD_79) resistor r=67.52
    rVDD_146 (VDD_18 VDD_20) resistor r=0.511623
    rVDD_145 (VDD_18 VDD_78) resistor r=0.0882365
    rVDD_144 (VDD_20 VDD_21) resistor r=8.66667
    rVDD_143 (VDD_21 MM11_ELT_s) resistor r=2.78649
    rVDD_142 (VDD_21 VDD_127) resistor r=11.6377
    rVDD_141 (VDD_23 VDD_26) resistor r=0.118614
    rVDD_140 (VDD_23 VDD_80) resistor r=0.0221596
    rVDD_139 (VDD_24 VDD_26) resistor r=0.217459
    rVDD_138 (VDD_24 VDD_78) resistor r=0.0221596
    rVDD_137 (VDD_26 VDD_27) resistor r=8.66667
    rVDD_136 (VDD_27 VDD_79) resistor r=67.52
    rVDD_135 (VDD_27 VDD_37) resistor r=67.52
    rVDD_134 (VDD_28 VDD_30) resistor r=0.641321
    rVDD_133 (VDD_28 VDD_80) resistor r=0.0882365
    rVDD_132 (VDD_30 VDD_31) resistor r=13
    rVDD_131 (VDD_31 MM9_ELT_s) resistor r=8.09035
    rVDD_130 (VDD_33 VDD_39) resistor r=0.0375611
    rVDD_129 (VDD_33 VDD_81) resistor r=0.0221596
    rVDD_128 (VDD_34 VDD_36) resistor r=0.0830297
    rVDD_127 (VDD_34 VDD_80) resistor r=0.0221596
    rVDD_126 (VDD_36 VDD_37) resistor r=8.66667
    rVDD_125 (VDD_36 VDD_39) resistor r=0.237228
    rVDD_124 (VDD_41 VDD_43) resistor r=0.511623
    rVDD_123 (VDD_41 VDD_81) resistor r=0.0882365
    rVDD_122 (VDD_43 VDD_44) resistor r=8.66667
    rVDD_121 (VDD_44 VDD_129) resistor r=16.4995
    rVDD_120 (VDD_44 VDD_128) resistor r=16.4995
    rVDD_119 (VDD_44 MM8_ELT_s) resistor r=3.29107
    rVDD_118 (VDD_46 VDD_52) resistor r=0.0948911
    rVDD_117 (VDD_46 VDD_82) resistor r=0.0221596
    rVDD_116 (VDD_47 VDD_49) resistor r=0.164083
    rVDD_115 (VDD_47 VDD_81) resistor r=0.0221596
    rVDD_114 (VDD_49 VDD_52) resistor r=0.237228
    rVDD_113 (VDD_54 VDD_63) resistor r=0.538304
    rVDD_112 (VDD_54 VDD_82) resistor r=0.0882365
    rVDD_111 (VDD_56 VDD_64) resistor r=8.66667
    rVDD_110 (VDD_56 VDD_60) resistor r=0.720563
    rVDD_109 (VDD_60 VDD_64) resistor r=8.66667
    rVDD_108 (VDD_60 VDD_63) resistor r=0.46809
    rVDD_107 (VDD_63 VDD_64) resistor r=13
    rVDD_106 (VDD_64 MM7_ELT_s) resistor r=4.04518
    rVDD_105 (VDD_64 VDD_132) resistor r=4.04518
    rVDD_104 (VDD_64 MM17_ELT_s) resistor r=4.04518
    rVDD_103 (VDD_64 VDD_130) resistor r=4.04518
    rVDD_102 (VDD_65 VDD_67) resistor r=0.106753
    rVDD_101 (VDD_65 VDD_82) resistor r=0.0221596
    rVDD_100 (VDD_67 VDD_70) resistor r=0.158152
    rVDD_99 (VDD VDD_76) resistor r=0.0513994
    rVDD_98 (VDD_78 VDD_79) resistor r=8.66667
    rVDD_97 (MM21_ELT_s VDD_88) resistor r=2.55965
    rVDD_96 (MM21_ELT_s VDD_90) resistor r=12.3172
    rVDD_95 (MM21_ELT_s VDD_90) resistor r=1.62887
    rVDD_94 (MM21_ELT_s VDD_93) resistor r=6.12113
    rVDD_93 (VDD_86 VDD_88) resistor r=14.4784
    rVDD_92 (VDD_86 VDD_92) resistor r=9.04062
    rVDD_91 (VDD_87 VDD_88) resistor r=14.4784
    rVDD_90 (VDD_87 VDD_126) resistor r=9.48555
    rVDD_89 (VDD_89 VDD_90) resistor r=12.3172
    rVDD_88 (VDD_89 VDD_91) resistor r=9.04595
    rVDD_87 (VDD_91 VDD_93) resistor r=31.2341
    rVDD_86 (VDD_92 VDD_93) resistor r=31.2341
    rVDD_85 (MM11_ELT_s VDD_97) resistor r=2.55965
    rVDD_84 (MM11_ELT_s VDD_99) resistor r=12.3172
    rVDD_83 (MM11_ELT_s VDD_99) resistor r=1.62887
    rVDD_82 (MM11_ELT_s VDD_102) resistor r=4.36821
    rVDD_81 (VDD_95 VDD_97) resistor r=14.4784
    rVDD_80 (VDD_95 VDD_101) resistor r=9.04062
    rVDD_79 (VDD_96 VDD_97) resistor r=14.4784
    rVDD_78 (VDD_96 VDD_127) resistor r=9.48555
    rVDD_77 (VDD_98 VDD_99) resistor r=12.3172
    rVDD_76 (VDD_98 VDD_100) resistor r=9.04595
    rVDD_75 (VDD_100 VDD_102) resistor r=20.2547
    rVDD_74 (VDD_101 VDD_102) resistor r=20.2547
    rVDD_73 (VDD_103 MM8_ELT_s) resistor r=13.564
    rVDD_72 (VDD_103 VDD_128) resistor r=9.39461
    rVDD_71 (MM8_ELT_s VDD_107) resistor r=2.55965
    rVDD_70 (MM8_ELT_s VDD_109) resistor r=18.4228
    rVDD_69 (MM8_ELT_s VDD_109) resistor r=3.88377
    rVDD_68 (VDD_105 VDD_107) resistor r=14.4784
    rVDD_67 (VDD_105 VDD_108) resistor r=9.04595
    rVDD_66 (VDD_106 VDD_107) resistor r=14.4784
    rVDD_65 (VDD_106 VDD_129) resistor r=9.48555
    rVDD_64 (VDD_108 VDD_109) resistor r=18.4228
    rVDD_63 (MM17_ELT_s VDD_111) resistor r=25.7298
    rVDD_62 (MM17_ELT_s VDD_114) resistor r=2.55965
    rVDD_61 (MM17_ELT_s VDD_116) resistor r=12.3172
    rVDD_60 (MM17_ELT_s VDD_116) resistor r=1.62887
    rVDD_59 (VDD_111 VDD_113) resistor r=9.04062
    rVDD_58 (VDD_112 VDD_114) resistor r=14.4784
    rVDD_57 (VDD_112 VDD_133) resistor r=10.5593
    rVDD_56 (VDD_113 VDD_114) resistor r=14.4784
    rVDD_55 (VDD_115 VDD_116) resistor r=12.3172
    rVDD_54 (VDD_115 VDD_131) resistor r=10.2363
    rVDD_53 (MM7_ELT_s VDD_120) resistor r=2.55965
    rVDD_52 (MM7_ELT_s VDD_122) resistor r=11.6604
    rVDD_51 (MM7_ELT_s VDD_122) resistor r=1.30988
    rVDD_50 (MM7_ELT_s VDD_125) resistor r=6.12113
    rVDD_49 (MM7_ELT_s VDD_131) resistor r=10.2363
    rVDD_48 (VDD_118 VDD_120) resistor r=14.4784
    rVDD_47 (VDD_118 VDD_124) resistor r=9.04062
    rVDD_46 (VDD_119 VDD_120) resistor r=14.4784
    rVDD_45 (VDD_119 VDD_133) resistor r=10.5593
    rVDD_44 (VDD_121 VDD_122) resistor r=11.6604
    rVDD_43 (VDD_121 VDD_123) resistor r=9.04595
    rVDD_42 (VDD_123 VDD_125) resistor r=31.2341
    rVDD_41 (VDD_124 VDD_125) resistor r=31.2341
    rVDD_40 (VDD_130 VDD_131) resistor r=0.549089
    rVDD_39 (VDD_132 VDD_133) resistor r=0.730683
    rVSS_210 (MM1_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_209 (MM2_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_208 (MM6_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_207 (MM3_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_206 (MM5_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_205 (MM18_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_204 (MM19_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_203 (MM4_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_202 (MM22_ELT_b VSS_42) resistor r=8.66667
    rVSS_201 (MM22_ELT_b VSS_52) resistor r=8.66667
    rVSS_200 (MM22_ELT_b VSS_55) resistor r=8.66667
    rVSS_199 (MM22_ELT_b VSS_67) resistor r=8.66667
    rVSS_198 (MM22_ELT_b VSS_70) resistor r=26
    rVSS_197 (MM22_ELT_b VSS_40) resistor r=43.1485
    rVSS_196 (VSS_2 VSS_4) resistor r=0.399705
    rVSS_195 (VSS_2 VSS_76) resistor r=0.119224
    rVSS_194 (VSS_4 VSS_8) resistor r=8.66667
    rVSS_193 (VSS_4 VSS_7) resistor r=0.426353
    rVSS_192 (VSS_7 VSS_8) resistor r=26
    rVSS_191 (VSS_8 MM22_ELT_s) resistor r=2.90692
    rVSS_190 (VSS_8 VSS_142) resistor r=12.1406
    rVSS_189 (VSS_10 VSS_13) resistor r=0.221413
    rVSS_188 (VSS_10 VSS_78) resistor r=0.0221596
    rVSS_187 (VSS_11 VSS_13) resistor r=0.0336073
    rVSS_186 (VSS_11 VSS_76) resistor r=0.0177921
    rVSS_185 (VSS_13 VSS_14) resistor r=8.66667
    rVSS_184 (VSS_14 VSS_79) resistor r=64.7228
    rVSS_183 (VSS_15 VSS_17) resistor r=0.405035
    rVSS_182 (VSS_15 VSS_78) resistor r=0.0882365
    rVSS_181 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_180 (VSS_17 VSS_20) resistor r=0.432737
    rVSS_179 (VSS_18 VSS_156) resistor r=17.2126
    rVSS_178 (VSS_18 VSS_143) resistor r=17.2126
    rVSS_177 (VSS_18 MM1_ELT_s) resistor r=3.43331
    rVSS_176 (VSS_20 VSS_21) resistor r=26
    rVSS_175 (VSS_21 VSS_96) resistor r=5.7452
    rVSS_174 (VSS_21 VSS_156) resistor r=4.05543
    rVSS_173 (VSS_23 VSS_26) resistor r=0.0375611
    rVSS_172 (VSS_23 VSS_80) resistor r=0.0221596
    rVSS_171 (VSS_24 VSS_26) resistor r=0.217459
    rVSS_170 (VSS_24 VSS_78) resistor r=0.0221596
    rVSS_169 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_168 (VSS_27 VSS_79) resistor r=64.7228
    rVSS_167 (VSS_27 VSS_40) resistor r=64.7228
    rVSS_166 (VSS_28 VSS_30) resistor r=0.405035
    rVSS_165 (VSS_28 VSS_80) resistor r=0.0882365
    rVSS_164 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_163 (VSS_30 VSS_33) resistor r=0.431128
    rVSS_162 (VSS_31 VSS_158) resistor r=17.2126
    rVSS_161 (VSS_31 VSS_144) resistor r=17.2126
    rVSS_160 (VSS_31 MM2_ELT_s) resistor r=3.43331
    rVSS_159 (VSS_33 VSS_34) resistor r=26
    rVSS_158 (VSS_34 VSS_103) resistor r=5.7452
    rVSS_157 (VSS_34 VSS_158) resistor r=4.05543
    rVSS_156 (VSS_36 VSS_42) resistor r=0.0375611
    rVSS_155 (VSS_36 VSS_81) resistor r=0.0221596
    rVSS_154 (VSS_37 VSS_39) resistor r=0.164083
    rVSS_153 (VSS_37 VSS_80) resistor r=0.0221596
    rVSS_152 (VSS_39 VSS_40) resistor r=8.66667
    rVSS_151 (VSS_39 VSS_42) resistor r=0.237228
    rVSS_150 (VSS_44 VSS_46) resistor r=0.502933
    rVSS_149 (VSS_44 VSS_81) resistor r=0.0882365
    rVSS_148 (VSS_46 VSS_47) resistor r=8.66667
    rVSS_147 (VSS_47 MM18_ELT_s) resistor r=4.22001
    rVSS_146 (VSS_47 VSS_147) resistor r=4.22001
    rVSS_145 (VSS_47 MM3_ELT_s) resistor r=4.22001
    rVSS_144 (VSS_47 VSS_145) resistor r=4.22001
    rVSS_143 (VSS_49 VSS_55) resistor r=0.0948911
    rVSS_142 (VSS_49 VSS_82) resistor r=0.0221596
    rVSS_141 (VSS_50 VSS_52) resistor r=0.164083
    rVSS_140 (VSS_50 VSS_81) resistor r=0.0221596
    rVSS_139 (VSS_52 VSS_55) resistor r=0.237228
    rVSS_138 (VSS_57 VSS_59) resistor r=0.502933
    rVSS_137 (VSS_57 VSS_82) resistor r=0.0882365
    rVSS_136 (VSS_59 VSS_60) resistor r=8.66667
    rVSS_135 (VSS_59 VSS_62) resistor r=0.536462
    rVSS_134 (VSS_60 MM4_ELT_s) resistor r=4.22001
    rVSS_133 (VSS_60 VSS_161) resistor r=4.22001
    rVSS_132 (VSS_60 MM19_ELT_s) resistor r=4.22001
    rVSS_131 (VSS_60 VSS_149) resistor r=4.22001
    rVSS_130 (VSS_62 VSS_63) resistor r=26
    rVSS_129 (VSS_63 MM4_ELT_s) resistor r=10.6787
    rVSS_128 (VSS_63 VSS_131) resistor r=10.6787
    rVSS_127 (VSS_63 VSS_161) resistor r=0.57282
    rVSS_126 (VSS_65 VSS_67) resistor r=0.106753
    rVSS_125 (VSS_65 VSS_82) resistor r=0.0221596
    rVSS_124 (VSS_67 VSS_70) resistor r=0.158152
    rVSS_123 (VSS VSS_76) resistor r=0.0494225
    rVSS_122 (VSS_78 VSS_79) resistor r=8.66667
    rVSS_121 (MM22_ELT_s VSS_86) resistor r=2.67027
    rVSS_120 (MM22_ELT_s VSS_88) resistor r=12.8495
    rVSS_119 (MM22_ELT_s VSS_88) resistor r=1.69926
    rVSS_118 (MM22_ELT_s VSS_91) resistor r=4.557
    rVSS_117 (VSS_84 VSS_86) resistor r=15.1041
    rVSS_116 (VSS_84 VSS_89) resistor r=9.43134
    rVSS_115 (VSS_85 VSS_86) resistor r=15.1041
    rVSS_114 (VSS_85 VSS_142) resistor r=9.89549
    rVSS_113 (VSS_87 VSS_88) resistor r=12.8495
    rVSS_112 (VSS_87 VSS_90) resistor r=9.4369
    rVSS_111 (VSS_89 VSS_91) resistor r=21.1301
    rVSS_110 (VSS_90 VSS_91) resistor r=21.1301
    rVSS_109 (MM1_ELT_s VSS_95) resistor r=2.67027
    rVSS_108 (MM1_ELT_s VSS_97) resistor r=12.8495
    rVSS_107 (MM1_ELT_s VSS_97) resistor r=1.69926
    rVSS_106 (MM1_ELT_s VSS_98) resistor r=18.0507
    rVSS_105 (VSS_93 VSS_95) resistor r=15.1041
    rVSS_104 (VSS_93 VSS_98) resistor r=9.43134
    rVSS_103 (VSS_94 VSS_95) resistor r=15.1041
    rVSS_102 (VSS_94 VSS_143) resistor r=9.89549
    rVSS_101 (VSS_96 VSS_97) resistor r=12.8495
    rVSS_100 (MM2_ELT_s VSS_102) resistor r=2.67027
    rVSS_99 (MM2_ELT_s VSS_104) resistor r=7.63611
    rVSS_98 (MM2_ELT_s VSS_104) resistor r=1.46105
    rVSS_97 (MM2_ELT_s VSS_106) resistor r=7.63611
    rVSS_96 (MM2_ELT_s VSS_106) resistor r=1.46105
    rVSS_95 (MM2_ELT_s VSS_109) resistor r=4.557
    rVSS_94 (VSS_100 VSS_102) resistor r=15.1041
    rVSS_93 (VSS_100 VSS_107) resistor r=9.43134
    rVSS_92 (VSS_101 VSS_102) resistor r=15.1041
    rVSS_91 (VSS_101 VSS_144) resistor r=9.89549
    rVSS_90 (VSS_103 VSS_104) resistor r=7.63611
    rVSS_89 (VSS_105 VSS_106) resistor r=7.63611
    rVSS_88 (VSS_105 VSS_108) resistor r=9.4369
    rVSS_87 (VSS_107 VSS_109) resistor r=21.1301
    rVSS_86 (VSS_108 VSS_109) resistor r=21.1301
    rVSS_85 (MM3_ELT_s VSS_111) resistor r=18.0507
    rVSS_84 (MM3_ELT_s VSS_114) resistor r=2.67027
    rVSS_83 (MM3_ELT_s VSS_116) resistor r=12.8495
    rVSS_82 (MM3_ELT_s VSS_116) resistor r=1.69926
    rVSS_81 (VSS_111 VSS_113) resistor r=9.43134
    rVSS_80 (VSS_112 VSS_114) resistor r=15.1041
    rVSS_79 (VSS_112 VSS_146) resistor r=11.0157
    rVSS_78 (VSS_113 VSS_114) resistor r=15.1041
    rVSS_77 (VSS_115 VSS_116) resistor r=12.8495
    rVSS_76 (VSS_115 VSS_148) resistor r=10.6787
    rVSS_75 (MM18_ELT_s VSS_120) resistor r=2.67027
    rVSS_74 (MM18_ELT_s VSS_122) resistor r=12.8495
    rVSS_73 (MM18_ELT_s VSS_122) resistor r=1.69926
    rVSS_72 (MM18_ELT_s VSS_125) resistor r=4.557
    rVSS_71 (MM18_ELT_s VSS_148) resistor r=10.6787
    rVSS_70 (VSS_118 VSS_120) resistor r=15.1041
    rVSS_69 (VSS_118 VSS_123) resistor r=9.43134
    rVSS_68 (VSS_119 VSS_120) resistor r=15.1041
    rVSS_67 (VSS_119 VSS_146) resistor r=11.0157
    rVSS_66 (VSS_121 VSS_122) resistor r=12.8495
    rVSS_65 (VSS_121 VSS_124) resistor r=9.4369
    rVSS_64 (VSS_123 VSS_125) resistor r=21.1301
    rVSS_63 (VSS_124 VSS_125) resistor r=21.1301
    rVSS_62 (MM19_ELT_s VSS_127) resistor r=18.0507
    rVSS_61 (MM19_ELT_s VSS_130) resistor r=2.67027
    rVSS_60 (MM19_ELT_s VSS_132) resistor r=12.8495
    rVSS_59 (MM19_ELT_s VSS_132) resistor r=1.69926
    rVSS_58 (VSS_127 VSS_129) resistor r=9.43134
    rVSS_57 (VSS_128 VSS_130) resistor r=15.1041
    rVSS_56 (VSS_128 VSS_150) resistor r=11.0157
    rVSS_55 (VSS_129 VSS_130) resistor r=15.1041
    rVSS_54 (VSS_131 VSS_132) resistor r=12.8495
    rVSS_53 (MM4_ELT_s VSS_136) resistor r=2.67027
    rVSS_52 (MM4_ELT_s VSS_138) resistor r=12.1643
    rVSS_51 (MM4_ELT_s VSS_138) resistor r=1.36649
    rVSS_50 (MM4_ELT_s VSS_141) resistor r=4.557
    rVSS_49 (VSS_134 VSS_136) resistor r=15.1041
    rVSS_48 (VSS_134 VSS_139) resistor r=9.43134
    rVSS_47 (VSS_135 VSS_136) resistor r=15.1041
    rVSS_46 (VSS_135 VSS_150) resistor r=11.0157
    rVSS_45 (VSS_137 VSS_138) resistor r=12.1643
    rVSS_44 (VSS_137 VSS_140) resistor r=9.4369
    rVSS_43 (VSS_139 VSS_141) resistor r=21.1301
    rVSS_42 (VSS_140 VSS_141) resistor r=21.1301
    rVSS_41 (VSS_145 VSS_146) resistor r=0.762262
    rVSS_40 (VSS_147 VSS_148) resistor r=0.57282
    rVSS_39 (VSS_149 VSS_150) resistor r=0.762262
    rCDN_93 (CDN_22 CDN_28) resistor r=58.3583
    rCDN_92 (CDN_22 CDN_28) resistor r=4.16253
    rCDN_91 (CDN_22 CDN_28) resistor r=58.3583
    rCDN_90 (CDN_22 CDN_28) resistor r=4.16253
    rCDN_89 (CDN_25 CDN_28) resistor r=58.3583
    rCDN_88 (CDN_25 CDN_28) resistor r=6.30933
    rCDN_87 (CDN_25 CDN_28) resistor r=58.3583
    rCDN_86 (CDN_25 CDN_28) resistor r=6.30933
    rCDN_85 (CDN_28 CDN_30) resistor r=14.9
    rCDN_84 (CDN_28 CDN_53) resistor r=24.8333
    rCDN_83 (CDN_28 CDN_50) resistor r=24.8333
    rCDN_82 (CDN_28 CDN_61) resistor r=24.8333
    rCDN_81 (CDN_28 CDN_58) resistor r=24.8333
    rCDN_80 (CDN_28 CDN_82) resistor r=58.3583
    rCDN_79 (CDN_28 CDN_85) resistor r=58.3583
    rCDN_78 (CDN_28 CDN_53) resistor r=4.16253
    rCDN_77 (CDN_28 CDN_30) resistor r=6.30933
    rCDN_76 (CDN_28 CDN_61) resistor r=1.63969
    rCDN_75 (CDN_28 CDN_50) resistor r=4.16253
    rCDN_74 (CDN_28 CDN_82) resistor r=4.16253
    rCDN_73 (CDN_28 CDN_58) resistor r=4.16253
    rCDN_72 (CDN_28 CDN_85) resistor r=4.16253
    rCDN_71 (CDN_28 CDN_30) resistor r=14.9
    rCDN_70 (CDN_28 CDN_161) resistor r=39.7333
    rCDN_69 (CDN_28 CDN_53) resistor r=24.8333
    rCDN_68 (CDN_28 CDN_50) resistor r=24.8333
    rCDN_67 (CDN_28 CDN_61) resistor r=24.8333
    rCDN_66 (CDN_28 CDN_58) resistor r=24.8333
    rCDN_65 (CDN_28 CDN_82) resistor r=58.3583
    rCDN_64 (CDN_28 MM19_ELT_g) resistor r=7.45
    rCDN_63 (CDN_28 CDN_53) resistor r=4.16253
    rCDN_62 (CDN_28 CDN_30) resistor r=6.30933
    rCDN_61 (CDN_28 CDN_61) resistor r=1.63969
    rCDN_60 (CDN_28 CDN_50) resistor r=4.16253
    rCDN_59 (CDN_28 CDN_82) resistor r=4.16253
    rCDN_58 (CDN_28 CDN_58) resistor r=4.16253
    rCDN_57 (CDN_28 CDN_85) resistor r=4.16253
    rCDN_56 (CDN_36 CDN_39) resistor r=14.9
    rCDN_55 (CDN_36 CDN_39) resistor r=6.30933
    rCDN_54 (CDN_36 CDN_39) resistor r=14.9
    rCDN_53 (CDN_36 CDN_39) resistor r=6.30933
    rCDN_52 (CDN_39 CDN_42) resistor r=202.392
    rCDN_51 (CDN_39 CDN_45) resistor r=202.392
    rCDN_50 (CDN_39 CDN_69) resistor r=24.8333
    rCDN_49 (CDN_39 CDN_66) resistor r=24.8333
    rCDN_48 (CDN_39 CDN_77) resistor r=24.8333
    rCDN_47 (CDN_39 CDN_74) resistor r=24.8333
    rCDN_46 (CDN_39 CDN_90) resistor r=202.392
    rCDN_45 (CDN_39 CDN_93) resistor r=202.392
    rCDN_44 (CDN_39 CDN_42) resistor r=6.30933
    rCDN_43 (CDN_39 CDN_69) resistor r=1.63969
    rCDN_42 (CDN_39 CDN_77) resistor r=4.16253
    rCDN_41 (CDN_39 CDN_45) resistor r=4.16253
    rCDN_40 (CDN_39 CDN_66) resistor r=4.16253
    rCDN_39 (CDN_39 CDN_90) resistor r=4.16253
    rCDN_38 (CDN_39 CDN_74) resistor r=4.16253
    rCDN_37 (CDN_39 CDN_93) resistor r=4.16253
    rCDN_36 (CDN_39 CDN_163) resistor r=42.2167
    rCDN_35 (CDN_39 CDN_42) resistor r=202.392
    rCDN_34 (CDN_39 CDN_45) resistor r=202.392
    rCDN_33 (CDN_39 CDN_69) resistor r=24.8333
    rCDN_32 (CDN_39 CDN_66) resistor r=24.8333
    rCDN_31 (CDN_39 CDN_77) resistor r=24.8333
    rCDN_30 (CDN_39 CDN_74) resistor r=24.8333
    rCDN_29 (CDN_39 CDN_90) resistor r=202.392
    rCDN_28 (CDN_39 MM17_ELT_g) resistor r=7.45
    rCDN_27 (CDN_39 CDN_42) resistor r=6.30933
    rCDN_26 (CDN_39 CDN_69) resistor r=1.63969
    rCDN_25 (CDN_39 CDN_77) resistor r=4.16253
    rCDN_24 (CDN_39 CDN_45) resistor r=4.16253
    rCDN_23 (CDN_39 CDN_66) resistor r=4.16253
    rCDN_22 (CDN_39 CDN_90) resistor r=4.16253
    rCDN_21 (CDN_39 CDN_74) resistor r=4.16253
    rCDN_20 (CDN_39 CDN_93) resistor r=4.16253
    rCDN_19 (CDN_85 MM19_ELT_g) resistor r=50.9083
    rCDN_18 (CDN_93 MM17_ELT_g) resistor r=194.942
    rCDN_17 (CDN CDN_135) resistor r=10
    rCDN_16 (CDN_135 CDN_203) resistor r=7.45
    rCDN_15 (CDN_161 CDN_203) resistor r=5.23411
    rCDN_14 (CDN_163 CDN_203) resistor r=5.23411
    rnet027_40 (MM3_ELT_d net027) resistor r=0.01
    rnet027_39 (net027_1 net027_3) resistor r=0.410267
    rnet027_38 (net027_1 net027_7) resistor r=0.0960945
    rnet027_37 (net027_3 net027_4) resistor r=13
    rnet027_36 (net027_4 net027) resistor r=8.44
    rnet027_35 (net027_6 net027_7) resistor r=1.29746
    rnet027_34 (net027_6 net027_15) resistor r=0.0960945
    rnet027_33 (net027_8 net027_10) resistor r=0.218292
    rnet027_32 (net027_8 net027_14) resistor r=0.0960945
    rnet027_31 (net027_10 net027_11) resistor r=8.66667
    rnet027_30 (net027_11 MM5_ELT_s) resistor r=2.90692
    rnet027_29 (net027_11 net027_26) resistor r=12.1406
    rnet027_28 (net027_13 net027_14) resistor r=0.28944
    rnet027_27 (net027_13 net027_16) resistor r=0.0960945
    rnet027_26 (net027_15 net027_16) resistor r=0.53895
    rnet027_25 (net027_17 net027_20) resistor r=21.1301
    rnet027_24 (net027_17 net027_22) resistor r=9.43134
    rnet027_23 (net027_18 net027_20) resistor r=21.1301
    rnet027_22 (net027_18 net027_24) resistor r=9.4369
    rnet027_21 (MM5_ELT_s net027_20) resistor r=4.557
    rnet027_20 (MM5_ELT_s net027_23) resistor r=2.67027
    rnet027_19 (MM5_ELT_s net027_25) resistor r=12.8495
    rnet027_18 (MM5_ELT_s net027_25) resistor r=1.69926
    rnet027_17 (net027_21 net027_23) resistor r=15.1041
    rnet027_16 (net027_21 net027_26) resistor r=9.89549
    rnet027_15 (net027_22 net027_23) resistor r=15.1041
    rnet027_14 (net027_24 net027_25) resistor r=12.8495
    rCDNN_165 (MM17_ELT_d CDNN) resistor r=0.01
    rCDNN_164 (CDNN_22 CDNN_28) resistor r=58.3583
    rCDNN_163 (CDNN_22 CDNN_28) resistor r=4.16253
    rCDNN_162 (CDNN_22 CDNN_28) resistor r=58.3583
    rCDNN_161 (CDNN_22 CDNN_28) resistor r=4.16253
    rCDNN_160 (CDNN_25 CDNN_28) resistor r=58.3583
    rCDNN_159 (CDNN_25 CDNN_28) resistor r=4.16253
    rCDNN_158 (CDNN_25 CDNN_28) resistor r=58.3583
    rCDNN_157 (CDNN_25 CDNN_28) resistor r=4.16253
    rCDNN_156 (CDNN_28 CDNN_33) resistor r=24.8333
    rCDNN_155 (CDNN_28 CDNN_30) resistor r=24.8333
    rCDNN_154 (CDNN_28 CDNN_41) resistor r=24.8333
    rCDNN_153 (CDNN_28 CDNN_38) resistor r=24.8333
    rCDNN_152 (CDNN_28 CDNN_46) resistor r=14.9
    rCDNN_151 (CDNN_28 CDNN_52) resistor r=58.3583
    rCDNN_150 (CDNN_28 CDNN_55) resistor r=58.3583
    rCDNN_149 (CDNN_28 CDNN_33) resistor r=4.16253
    rCDNN_148 (CDNN_28 CDNN_41) resistor r=4.16253
    rCDNN_147 (CDNN_28 CDNN_52) resistor r=6.30933
    rCDNN_146 (CDNN_28 CDNN_46) resistor r=6.30933
    rCDNN_145 (CDNN_28 CDNN_30) resistor r=1.63969
    rCDNN_144 (CDNN_28 CDNN_38) resistor r=4.16253
    rCDNN_143 (CDNN_28 CDNN_55) resistor r=4.16253
    rCDNN_142 (CDNN_28 CDNN_33) resistor r=24.8333
    rCDNN_141 (CDNN_28 CDNN_30) resistor r=24.8333
    rCDNN_140 (CDNN_28 CDNN_41) resistor r=24.8333
    rCDNN_139 (CDNN_28 CDNN_38) resistor r=24.8333
    rCDNN_138 (CDNN_28 CDNN_223) resistor r=54.6333
    rCDNN_137 (CDNN_28 CDNN_46) resistor r=14.9
    rCDNN_136 (CDNN_28 CDNN_52) resistor r=58.3583
    rCDNN_135 (CDNN_28 MM20_ELT_g) resistor r=7.45
    rCDNN_134 (CDNN_28 CDNN_33) resistor r=4.16253
    rCDNN_133 (CDNN_28 CDNN_41) resistor r=4.16253
    rCDNN_132 (CDNN_28 CDNN_52) resistor r=6.30933
    rCDNN_131 (CDNN_28 CDNN_46) resistor r=6.30933
    rCDNN_130 (CDNN_28 CDNN_30) resistor r=1.63969
    rCDNN_129 (CDNN_28 CDNN_38) resistor r=4.16253
    rCDNN_128 (CDNN_28 CDNN_55) resistor r=4.16253
    rCDNN_127 (CDNN_55 MM20_ELT_g) resistor r=50.9083
    rCDNN_126 (CDNN_60 CDNN_66) resistor r=58.3583
    rCDNN_125 (CDNN_60 CDNN_66) resistor r=4.16253
    rCDNN_124 (CDNN_60 CDNN_66) resistor r=58.3583
    rCDNN_123 (CDNN_60 CDNN_66) resistor r=4.16253
    rCDNN_122 (CDNN_63 CDNN_66) resistor r=58.3583
    rCDNN_121 (CDNN_63 CDNN_66) resistor r=6.30933
    rCDNN_120 (CDNN_63 CDNN_66) resistor r=58.3583
    rCDNN_119 (CDNN_63 CDNN_66) resistor r=6.30933
    rCDNN_118 (CDNN_66 CDNN_68) resistor r=14.9
    rCDNN_117 (CDNN_66 CDNN_77) resistor r=24.8333
    rCDNN_116 (CDNN_66 CDNN_74) resistor r=24.8333
    rCDNN_115 (CDNN_66 CDNN_85) resistor r=24.8333
    rCDNN_114 (CDNN_66 CDNN_82) resistor r=24.8333
    rCDNN_113 (CDNN_66 CDNN_90) resistor r=58.3583
    rCDNN_112 (CDNN_66 CDNN_93) resistor r=58.3583
    rCDNN_111 (CDNN_66 CDNN_77) resistor r=4.16253
    rCDNN_110 (CDNN_66 CDNN_68) resistor r=6.30933
    rCDNN_109 (CDNN_66 CDNN_85) resistor r=1.63969
    rCDNN_108 (CDNN_66 CDNN_74) resistor r=4.16253
    rCDNN_107 (CDNN_66 CDNN_90) resistor r=4.16253
    rCDNN_106 (CDNN_66 CDNN_82) resistor r=4.16253
    rCDNN_105 (CDNN_66 CDNN_93) resistor r=4.16253
    rCDNN_104 (CDNN_66 CDNN_68) resistor r=14.9
    rCDNN_103 (CDNN_66 CDNN_235) resistor r=39.7333
    rCDNN_102 (CDNN_66 CDNN_77) resistor r=24.8333
    rCDNN_101 (CDNN_66 CDNN_74) resistor r=24.8333
    rCDNN_100 (CDNN_66 CDNN_85) resistor r=24.8333
    rCDNN_99 (CDNN_66 CDNN_82) resistor r=24.8333
    rCDNN_98 (CDNN_66 CDNN_90) resistor r=58.3583
    rCDNN_97 (CDNN_66 MM18_ELT_g) resistor r=7.45
    rCDNN_96 (CDNN_66 CDNN_77) resistor r=4.16253
    rCDNN_95 (CDNN_66 CDNN_68) resistor r=6.30933
    rCDNN_94 (CDNN_66 CDNN_85) resistor r=1.63969
    rCDNN_93 (CDNN_66 CDNN_74) resistor r=4.16253
    rCDNN_92 (CDNN_66 CDNN_90) resistor r=4.16253
    rCDNN_91 (CDNN_66 CDNN_82) resistor r=4.16253
    rCDNN_90 (CDNN_66 CDNN_93) resistor r=4.16253
    rCDNN_89 (CDNN_93 MM18_ELT_g) resistor r=50.9083
    rCDNN_88 (CDNN_131 CDNN_133) resistor r=0.390895
    rCDNN_87 (CDNN_131 CDNN_139) resistor r=0.0960945
    rCDNN_86 (CDNN_133 CDNN_134) resistor r=10
    rCDNN_85 (CDNN_134 CDNN_252) resistor r=18.9636
    rCDNN_84 (CDNN_136 CDNN_160) resistor r=0.583422
    rCDNN_83 (CDNN_136 CDNN_141) resistor r=0.0960945
    rCDNN_82 (CDNN_139 CDNN_162) resistor r=0.12857
    rCDNN_81 (CDNN_140 CDNN_141) resistor r=0.300917
    rCDNN_80 (CDNN_140 CDNN_143) resistor r=0.0960945
    rCDNN_79 (CDNN_142 CDNN_143) resistor r=0.133281
    rCDNN_78 (CDNN_142 CDNN_144) resistor r=0.0960945
    rCDNN_77 (CDNN_144 CDNN_146) resistor r=0.0764559
    rCDNN_76 (CDNN_146 CDNN_147) resistor r=10
    rCDNN_75 (CDNN_147 CDNN_235) resistor r=5.6595
    rCDNN_74 (CDNN_153 CDNN_154) resistor r=8.66667
    rCDNN_73 (CDNN_153 CDNN_166) resistor r=0.560895
    rCDNN_72 (CDNN_153 CDNN_156) resistor r=0.560895
    rCDNN_71 (CDNN_154 CDNN) resistor r=16.1807
    rCDNN_70 (CDNN_154 CDNN_157) resistor r=32.3614
    rCDNN_69 (CDNN_156 CDNN_157) resistor r=26
    rCDNN_68 (CDNN_159 CDNN_160) resistor r=0.0614189
    rCDNN_67 (CDNN_159 CDNN_188) resistor r=0.0481821
    rCDNN_66 (CDNN_161 CDNN_162) resistor r=0.0614189
    rCDNN_65 (CDNN_161 CDNN_188) resistor r=0.289093
    rCDNN_64 (CDNN_165 CDNN_166) resistor r=0.0691773
    rCDNN_63 (CDNN_165 CDNN_193) resistor r=0.325062
    rCDNN_62 (CDNN_169 CDNN_170) resistor r=0.478781
    rCDNN_61 (CDNN_169 CDNN_189) resistor r=0.0579622
    rCDNN_60 (CDNN_170 CDNN_187) resistor r=0.0382401
    rCDNN_59 (CDNN_171 CDNN_172) resistor r=1.0629
    rCDNN_58 (CDNN_171 CDNN_174) resistor r=0.0764802
    rCDNN_57 (CDNN_172 CDNN_189) resistor r=0.0150634
    rCDNN_56 (CDNN_173 CDNN_174) resistor r=0.393145
    rCDNN_55 (CDNN_173 CDNN_190) resistor r=0.0150634
    rCDNN_54 (CDNN_175 CDNN_176) resistor r=0.393145
    rCDNN_53 (CDNN_175 CDNN_192) resistor r=0.0382401
    rCDNN_52 (CDNN_176 CDNN_189) resistor r=0.0579622
    rCDNN_51 (CDNN_177 CDNN_179) resistor r=0.0389253
    rCDNN_50 (CDNN_177 CDNN_190) resistor r=0.0579622
    rCDNN_49 (CDNN_179 CDNN_180) resistor r=0.75
    rCDNN_48 (CDNN_180 CDNN_263) resistor r=13
    rCDNN_47 (CDNN_187 CDNN_188) resistor r=0.75
    rCDNN_46 (CDNN_192 CDNN_193) resistor r=0.75
    rCDNN_45 (CDNN_193 CDNN_270) resistor r=8.66667
    rCDNN_44 (CDNN_223 CDNN_252) resistor r=9.29775
    rCDNN_43 (CDNN_263 MM19_ELT_d) resistor r=8.44
    rCDNN_42 (CDNN_270 CDNN) resistor r=32.3614
    rY_148 (MM20_ELT_d Y) resistor r=0.01
    rY_147 (Y_22 Y_28) resistor r=58.3583
    rY_146 (Y_22 Y_28) resistor r=4.16253
    rY_145 (Y_22 Y_28) resistor r=58.3583
    rY_144 (Y_22 Y_28) resistor r=4.16253
    rY_143 (Y_25 Y_28) resistor r=58.3583
    rY_142 (Y_25 Y_28) resistor r=6.30933
    rY_141 (Y_25 Y_28) resistor r=58.3583
    rY_140 (Y_25 Y_28) resistor r=6.30933
    rY_139 (Y_28 Y_30) resistor r=14.9
    rY_138 (Y_28 Y_39) resistor r=24.8333
    rY_137 (Y_28 Y_36) resistor r=24.8333
    rY_136 (Y_28 Y_47) resistor r=24.8333
    rY_135 (Y_28 Y_44) resistor r=24.8333
    rY_134 (Y_28 Y_52) resistor r=58.3583
    rY_133 (Y_28 Y_55) resistor r=58.3583
    rY_132 (Y_28 Y_39) resistor r=4.16253
    rY_131 (Y_28 Y_30) resistor r=6.30933
    rY_130 (Y_28 Y_47) resistor r=1.63969
    rY_129 (Y_28 Y_36) resistor r=4.16253
    rY_128 (Y_28 Y_52) resistor r=4.16253
    rY_127 (Y_28 Y_44) resistor r=4.16253
    rY_126 (Y_28 Y_55) resistor r=4.16253
    rY_125 (Y_28 Y_30) resistor r=14.9
    rY_124 (Y_28 Y_202) resistor r=39.7333
    rY_123 (Y_28 Y_39) resistor r=24.8333
    rY_122 (Y_28 Y_36) resistor r=24.8333
    rY_121 (Y_28 Y_47) resistor r=24.8333
    rY_120 (Y_28 Y_44) resistor r=24.8333
    rY_119 (Y_28 Y_52) resistor r=58.3583
    rY_118 (Y_28 MM3_ELT_g) resistor r=7.45
    rY_117 (Y_28 Y_39) resistor r=4.16253
    rY_116 (Y_28 Y_30) resistor r=6.30933
    rY_115 (Y_28 Y_47) resistor r=1.63969
    rY_114 (Y_28 Y_36) resistor r=4.16253
    rY_113 (Y_28 Y_52) resistor r=4.16253
    rY_112 (Y_28 Y_44) resistor r=4.16253
    rY_111 (Y_28 Y_55) resistor r=4.16253
    rY_110 (Y_55 MM3_ELT_g) resistor r=50.9083
    rY_109 (Y_60 Y_66) resistor r=58.3583
    rY_108 (Y_60 Y_66) resistor r=4.16253
    rY_107 (Y_60 Y_66) resistor r=58.3583
    rY_106 (Y_60 Y_66) resistor r=4.16253
    rY_105 (Y_63 Y_66) resistor r=58.3583
    rY_104 (Y_63 Y_66) resistor r=4.16253
    rY_103 (Y_63 Y_66) resistor r=58.3583
    rY_102 (Y_63 Y_66) resistor r=4.16253
    rY_101 (Y_66 Y_71) resistor r=24.8333
    rY_100 (Y_66 Y_68) resistor r=24.8333
    rY_99 (Y_66 Y_79) resistor r=24.8333
    rY_98 (Y_66 Y_76) resistor r=24.8333
    rY_97 (Y_66 Y_84) resistor r=55.875
    rY_96 (Y_66 Y_87) resistor r=55.875
    rY_95 (Y_66 Y_92) resistor r=11.175
    rY_94 (Y_66 Y_71) resistor r=4.16253
    rY_93 (Y_66 Y_79) resistor r=4.16253
    rY_92 (Y_66 Y_92) resistor r=5.53947
    rY_91 (Y_66 Y_68) resistor r=5.53947
    rY_90 (Y_66 Y_84) resistor r=2.32428
    rY_89 (Y_66 Y_76) resistor r=4.16253
    rY_88 (Y_66 Y_87) resistor r=4.16253
    rY_87 (Y_66 Y_71) resistor r=24.8333
    rY_86 (Y_66 Y_68) resistor r=24.8333
    rY_85 (Y_66 Y_79) resistor r=24.8333
    rY_84 (Y_66 Y_76) resistor r=24.8333
    rY_83 (Y_66 Y_84) resistor r=55.875
    rY_82 (Y_66 MM8_ELT_g) resistor r=4.96667
    rY_81 (Y_66 Y_92) resistor r=11.175
    rY_80 (Y_66 Y_231) resistor r=29.8
    rY_79 (Y_66 Y_71) resistor r=4.16253
    rY_78 (Y_66 Y_79) resistor r=4.16253
    rY_77 (Y_66 Y_92) resistor r=5.53947
    rY_76 (Y_66 Y_68) resistor r=5.53947
    rY_75 (Y_66 Y_84) resistor r=2.32428
    rY_74 (Y_66 Y_76) resistor r=4.16253
    rY_73 (Y_66 Y_87) resistor r=4.16253
    rY_72 (Y_87 MM8_ELT_g) resistor r=50.9083
    rY_71 (Y_131 Y_132) resistor r=0.30313
    rY_70 (Y_131 Y_141) resistor r=0.0960945
    rY_69 (Y_132 Y_153) resistor r=0.0507585
    rY_68 (Y_133 Y_134) resistor r=0.212038
    rY_67 (Y_133 Y_156) resistor r=0.0728274
    rY_66 (Y_134 Y_166) resistor r=0.0964411
    rY_65 (Y_135 Y_137) resistor r=0.294846
    rY_64 (Y_135 Y_156) resistor r=0.0189266
    rY_63 (Y_137 Y_138) resistor r=13
    rY_62 (Y_138 Y) resistor r=8.09035
    rY_61 (Y_140 Y_141) resistor r=0.502733
    rY_60 (Y_140 Y_158) resistor r=0.0724834
    rY_59 (Y_142 Y_143) resistor r=1.88088
    rY_58 (Y_142 Y_146) resistor r=0.0960945
    rY_57 (Y_143 Y_156) resistor r=0.0728274
    rY_56 (Y_146 Y_148) resistor r=0.10299
    rY_55 (Y_148 Y_149) resistor r=10
    rY_54 (Y_149 Y_231) resistor r=4.6552
    rY_53 (Y_153 Y_154) resistor r=13
    rY_52 (Y_153 Y_163) resistor r=0.0456381
    rY_51 (Y_154 MM6_ELT_d) resistor r=8.44
    rY_50 (Y_158 Y_159) resistor r=10
    rY_49 (Y_159 Y_202) resistor r=5.39869
    rY_48 (Y_160 Y_162) resistor r=0.751258
    rY_47 (Y_160 Y_169) resistor r=0.0764802
    rY_46 (Y_162 Y_163) resistor r=0.75
    rY_45 (Y_162 Y_165) resistor r=0.716225
    rY_44 (Y_165 Y_166) resistor r=0.75
    rY_43 (Y_168 Y_169) resistor r=0.70844
    rY_42 (Y_168 Y_177) resistor r=0.0150634
    rY_41 (Y_170 Y_172) resistor r=0.0389253
    rY_40 (Y_170 Y_177) resistor r=0.0579622
    rY_39 (Y_172 Y_173) resistor r=0.75
    rY_38 (Y_173 Y_252) resistor r=13
    rY_37 (Y_252 MM18_ELT_d) resistor r=8.44
    rnet026_38 (MM2_ELT_d net026) resistor r=0.01
    rnet026_37 (net026_1 net026_3) resistor r=0.371995
    rnet026_36 (net026_1 net026_12) resistor r=0.0960945
    rnet026_35 (net026_3 net026_4) resistor r=8.66667
    rnet026_34 (net026_4 MM6_ELT_s) resistor r=2.90692
    rnet026_33 (net026_4 net026_26) resistor r=12.1406
    rnet026_32 (net026_6 net026_8) resistor r=0.303776
    rnet026_31 (net026_6 net026_14) resistor r=0.0960945
    rnet026_30 (net026_8 net026_9) resistor r=13
    rnet026_29 (net026_9 net026) resistor r=8.44
    rnet026_28 (net026_11 net026_12) resistor r=0.541238
    rnet026_27 (net026_11 net026_16) resistor r=0.0960945
    rnet026_26 (net026_13 net026_14) resistor r=0.26229
    rnet026_25 (net026_13 net026_15) resistor r=0.0960945
    rnet026_24 (net026_15 net026_16) resistor r=0.793789
    rnet026_23 (MM6_ELT_s net026_20) resistor r=2.67027
    rnet026_22 (MM6_ELT_s net026_22) resistor r=12.8495
    rnet026_21 (MM6_ELT_s net026_22) resistor r=1.69926
    rnet026_20 (MM6_ELT_s net026_25) resistor r=4.557
    rnet026_19 (net026_18 net026_20) resistor r=15.1041
    rnet026_18 (net026_18 net026_23) resistor r=9.43134
    rnet026_17 (net026_19 net026_20) resistor r=15.1041
    rnet026_16 (net026_19 net026_26) resistor r=9.89549
    rnet026_15 (net026_21 net026_22) resistor r=12.8495
    rnet026_14 (net026_21 net026_24) resistor r=9.4369
    rnet026_13 (net026_23 net026_25) resistor r=21.1301
    rnet026_12 (net026_24 net026_25) resistor r=21.1301
    rX_89 (MM10_ELT_d X) resistor r=0.01
    rX_88 (X_14 X_20) resistor r=58.3583
    rX_87 (X_14 X_20) resistor r=4.16253
    rX_86 (X_14 X_20) resistor r=58.3583
    rX_85 (X_14 X_20) resistor r=4.16253
    rX_84 (X_17 X_20) resistor r=58.3583
    rX_83 (X_17 X_20) resistor r=4.16253
    rX_82 (X_17 X_20) resistor r=58.3583
    rX_81 (X_17 X_20) resistor r=4.16253
    rX_80 (X_20 X_25) resistor r=24.8333
    rX_79 (X_20 X_22) resistor r=24.8333
    rX_78 (X_20 X_33) resistor r=8.69167
    rX_77 (X_20 X_30) resistor r=8.69167
    rX_76 (X_20 X_38) resistor r=14.9
    rX_75 (X_20 X_47) resistor r=8.69167
    rX_74 (X_20 X_44) resistor r=8.69167
    rX_73 (X_20 X_52) resistor r=58.3583
    rX_72 (X_20 X_55) resistor r=58.3583
    rX_71 (X_20 X_25) resistor r=4.16253
    rX_70 (X_20 X_33) resistor r=4.16253
    rX_69 (X_20 X_47) resistor r=6.30933
    rX_68 (X_20 X_30) resistor r=6.30933
    rX_67 (X_20 X_38) resistor r=1.63969
    rX_66 (X_20 X_22) resistor r=4.16253
    rX_65 (X_20 X_52) resistor r=4.16253
    rX_64 (X_20 X_44) resistor r=4.16253
    rX_63 (X_20 X_55) resistor r=4.16253
    rX_62 (X_20 X_25) resistor r=24.8333
    rX_61 (X_20 X_22) resistor r=24.8333
    rX_60 (X_20 X_33) resistor r=8.69167
    rX_59 (X_20 X_30) resistor r=8.69167
    rX_58 (X_20 X_38) resistor r=14.9
    rX_57 (X_20 X_128) resistor r=39.7333
    rX_56 (X_20 X_47) resistor r=8.69167
    rX_55 (X_20 X_44) resistor r=8.69167
    rX_54 (X_20 X_52) resistor r=58.3583
    rX_53 (X_20 MM2_ELT_g) resistor r=7.45
    rX_52 (X_20 X_25) resistor r=4.16253
    rX_51 (X_20 X_33) resistor r=4.16253
    rX_50 (X_20 X_47) resistor r=6.30933
    rX_49 (X_20 X_30) resistor r=6.30933
    rX_48 (X_20 X_38) resistor r=1.63969
    rX_47 (X_20 X_22) resistor r=4.16253
    rX_46 (X_20 X_52) resistor r=4.16253
    rX_45 (X_20 X_44) resistor r=4.16253
    rX_44 (X_20 X_55) resistor r=4.16253
    rX_43 (X_55 MM2_ELT_g) resistor r=50.9083
    rX_42 (X_80 X_82) resistor r=0.159882
    rX_41 (X_80 X_91) resistor r=0.0960945
    rX_40 (X_82 X_83) resistor r=13
    rX_39 (X_83 X) resistor r=8.09035
    rX_38 (X_85 X_87) resistor r=0.303776
    rX_37 (X_85 X_101) resistor r=0.0101006
    rX_36 (X_87 X_88) resistor r=13
    rX_35 (X_88 MM1_ELT_d) resistor r=8.44
    rX_34 (X_90 X_91) resistor r=0.0927172
    rX_33 (X_90 X_95) resistor r=0.0960945
    rX_32 (X_92 X_93) resistor r=0.309867
    rX_31 (X_92 X_103) resistor r=0.0101006
    rX_30 (X_93 X_105) resistor r=0.0728274
    rX_29 (X_94 X_95) resistor r=0.321529
    rX_28 (X_94 X_105) resistor r=0.0728274
    rX_27 (X_96 X_98) resistor r=0.767103
    rX_26 (X_96 X_105) resistor r=0.0189266
    rX_25 (X_98 X_99) resistor r=10
    rX_24 (X_99 X_143) resistor r=4.74091
    rX_23 (X_101 X_103) resistor r=0.126876
    rX_22 (X_128 X_144) resistor r=4.38767
    rX_21 (X_143 X_144) resistor r=3.71511
    rnet29_32 (MM11_ELT_d net29) resistor r=0.01
    rnet29_31 (net29_1 net29_3) resistor r=0.0905999
    rnet29_30 (net29_1 net29_7) resistor r=0.0960945
    rnet29_29 (net29_3 net29_4) resistor r=13
    rnet29_28 (net29_4 net29) resistor r=8.09035
    rnet29_27 (net29_6 net29_7) resistor r=0.112237
    rnet29_26 (net29_6 net29_8) resistor r=0.0960945
    rnet29_25 (net29_8 net29_10) resistor r=0.904332
    rnet29_24 (net29_10 net29_11) resistor r=8.66667
    rnet29_23 (net29_11 net29_21) resistor r=16.4995
    rnet29_22 (net29_11 net29_20) resistor r=16.4995
    rnet29_21 (net29_11 MM10_ELT_s) resistor r=3.29107
    rnet29_20 (MM10_ELT_s net29_14) resistor r=17.3029
    rnet29_19 (MM10_ELT_s net29_17) resistor r=2.55965
    rnet29_18 (MM10_ELT_s net29_19) resistor r=12.3172
    rnet29_17 (MM10_ELT_s net29_19) resistor r=1.62887
    rnet29_16 (net29_14 net29_16) resistor r=9.04062
    rnet29_15 (net29_15 net29_17) resistor r=14.4784
    rnet29_14 (net29_15 net29_21) resistor r=9.48555
    rnet29_13 (net29_16 net29_17) resistor r=14.4784
    rnet29_12 (net29_18 net29_19) resistor r=12.3172
    rnet29_11 (net29_18 net29_20) resistor r=9.39461
    rCPNN_262 (MM21_ELT_d CPNN) resistor r=0.01
    rCPNN_261 (CPNN_42 CPNN_45) resistor r=14.9
    rCPNN_260 (CPNN_42 CPNN_45) resistor r=6.30933
    rCPNN_259 (CPNN_42 CPNN_45) resistor r=14.9
    rCPNN_258 (CPNN_42 CPNN_45) resistor r=6.30933
    rCPNN_257 (CPNN_45 CPNN_48) resistor r=58.3583
    rCPNN_256 (CPNN_45 CPNN_51) resistor r=58.3583
    rCPNN_255 (CPNN_45 CPNN_59) resistor r=24.8333
    rCPNN_254 (CPNN_45 CPNN_56) resistor r=24.8333
    rCPNN_253 (CPNN_45 CPNN_67) resistor r=24.8333
    rCPNN_252 (CPNN_45 CPNN_64) resistor r=24.8333
    rCPNN_251 (CPNN_45 CPNN_72) resistor r=58.3583
    rCPNN_250 (CPNN_45 CPNN_75) resistor r=58.3583
    rCPNN_249 (CPNN_45 CPNN_48) resistor r=6.30933
    rCPNN_248 (CPNN_45 CPNN_59) resistor r=1.63969
    rCPNN_247 (CPNN_45 CPNN_67) resistor r=4.16253
    rCPNN_246 (CPNN_45 CPNN_51) resistor r=4.16253
    rCPNN_245 (CPNN_45 CPNN_56) resistor r=4.16253
    rCPNN_244 (CPNN_45 CPNN_72) resistor r=4.16253
    rCPNN_243 (CPNN_45 CPNN_64) resistor r=4.16253
    rCPNN_242 (CPNN_45 CPNN_75) resistor r=4.16253
    rCPNN_241 (CPNN_45 CPNN_363) resistor r=39.7333
    rCPNN_240 (CPNN_45 CPNN_48) resistor r=58.3583
    rCPNN_239 (CPNN_45 CPNN_51) resistor r=58.3583
    rCPNN_238 (CPNN_45 CPNN_59) resistor r=24.8333
    rCPNN_237 (CPNN_45 CPNN_56) resistor r=24.8333
    rCPNN_236 (CPNN_45 CPNN_67) resistor r=24.8333
    rCPNN_235 (CPNN_45 CPNN_64) resistor r=24.8333
    rCPNN_234 (CPNN_45 CPNN_72) resistor r=58.3583
    rCPNN_233 (CPNN_45 MM10_ELT_g) resistor r=7.45
    rCPNN_232 (CPNN_45 CPNN_48) resistor r=6.30933
    rCPNN_231 (CPNN_45 CPNN_59) resistor r=1.63969
    rCPNN_230 (CPNN_45 CPNN_67) resistor r=4.16253
    rCPNN_229 (CPNN_45 CPNN_51) resistor r=4.16253
    rCPNN_228 (CPNN_45 CPNN_56) resistor r=4.16253
    rCPNN_227 (CPNN_45 CPNN_72) resistor r=4.16253
    rCPNN_226 (CPNN_45 CPNN_64) resistor r=4.16253
    rCPNN_225 (CPNN_45 CPNN_75) resistor r=4.16253
    rCPNN_224 (CPNN_75 MM10_ELT_g) resistor r=50.9083
    rCPNN_223 (CPNN_80 CPNN_86) resistor r=58.3583
    rCPNN_222 (CPNN_80 CPNN_86) resistor r=4.16253
    rCPNN_221 (CPNN_80 CPNN_86) resistor r=58.3583
    rCPNN_220 (CPNN_80 CPNN_86) resistor r=4.16253
    rCPNN_219 (CPNN_83 CPNN_86) resistor r=58.3583
    rCPNN_218 (CPNN_83 CPNN_86) resistor r=4.16253
    rCPNN_217 (CPNN_83 CPNN_86) resistor r=58.3583
    rCPNN_216 (CPNN_83 CPNN_86) resistor r=4.16253
    rCPNN_215 (CPNN_86 CPNN_91) resistor r=24.8333
    rCPNN_214 (CPNN_86 CPNN_88) resistor r=24.8333
    rCPNN_213 (CPNN_86 CPNN_99) resistor r=24.8333
    rCPNN_212 (CPNN_86 CPNN_96) resistor r=24.8333
    rCPNN_211 (CPNN_86 CPNN_118) resistor r=14.9
    rCPNN_210 (CPNN_86 CPNN_124) resistor r=58.3583
    rCPNN_209 (CPNN_86 CPNN_127) resistor r=58.3583
    rCPNN_208 (CPNN_86 CPNN_91) resistor r=4.16253
    rCPNN_207 (CPNN_86 CPNN_99) resistor r=4.16253
    rCPNN_206 (CPNN_86 CPNN_124) resistor r=6.30933
    rCPNN_205 (CPNN_86 CPNN_118) resistor r=6.30933
    rCPNN_204 (CPNN_86 CPNN_88) resistor r=1.63969
    rCPNN_203 (CPNN_86 CPNN_96) resistor r=4.16253
    rCPNN_202 (CPNN_86 CPNN_127) resistor r=4.16253
    rCPNN_201 (CPNN_86 CPNN_91) resistor r=24.8333
    rCPNN_200 (CPNN_86 CPNN_88) resistor r=24.8333
    rCPNN_199 (CPNN_86 CPNN_99) resistor r=24.8333
    rCPNN_198 (CPNN_86 CPNN_96) resistor r=24.8333
    rCPNN_197 (CPNN_86 CPNN_395) resistor r=54.6333
    rCPNN_196 (CPNN_86 CPNN_118) resistor r=14.9
    rCPNN_195 (CPNN_86 CPNN_124) resistor r=58.3583
    rCPNN_194 (CPNN_86 MM9_ELT_g) resistor r=7.45
    rCPNN_193 (CPNN_86 CPNN_91) resistor r=4.16253
    rCPNN_192 (CPNN_86 CPNN_99) resistor r=4.16253
    rCPNN_191 (CPNN_86 CPNN_124) resistor r=6.30933
    rCPNN_190 (CPNN_86 CPNN_118) resistor r=6.30933
    rCPNN_189 (CPNN_86 CPNN_88) resistor r=1.63969
    rCPNN_188 (CPNN_86 CPNN_96) resistor r=4.16253
    rCPNN_187 (CPNN_86 CPNN_127) resistor r=4.16253
    rCPNN_186 (CPNN_104 CPNN_110) resistor r=58.3583
    rCPNN_185 (CPNN_104 CPNN_110) resistor r=4.16253
    rCPNN_184 (CPNN_104 CPNN_110) resistor r=58.3583
    rCPNN_183 (CPNN_104 CPNN_110) resistor r=4.16253
    rCPNN_182 (CPNN_107 CPNN_110) resistor r=58.3583
    rCPNN_181 (CPNN_107 CPNN_110) resistor r=6.30933
    rCPNN_180 (CPNN_107 CPNN_110) resistor r=58.3583
    rCPNN_179 (CPNN_107 CPNN_110) resistor r=6.30933
    rCPNN_178 (CPNN_110 CPNN_112) resistor r=14.9
    rCPNN_177 (CPNN_110 CPNN_135) resistor r=24.8333
    rCPNN_176 (CPNN_110 CPNN_132) resistor r=24.8333
    rCPNN_175 (CPNN_110 CPNN_143) resistor r=24.8333
    rCPNN_174 (CPNN_110 CPNN_140) resistor r=24.8333
    rCPNN_173 (CPNN_110 CPNN_148) resistor r=58.3583
    rCPNN_172 (CPNN_110 CPNN_151) resistor r=58.3583
    rCPNN_171 (CPNN_110 CPNN_135) resistor r=4.16253
    rCPNN_170 (CPNN_110 CPNN_112) resistor r=6.30933
    rCPNN_169 (CPNN_110 CPNN_143) resistor r=1.63969
    rCPNN_168 (CPNN_110 CPNN_132) resistor r=4.16253
    rCPNN_167 (CPNN_110 CPNN_148) resistor r=4.16253
    rCPNN_166 (CPNN_110 CPNN_140) resistor r=4.16253
    rCPNN_165 (CPNN_110 CPNN_151) resistor r=4.16253
    rCPNN_164 (CPNN_110 CPNN_112) resistor r=14.9
    rCPNN_163 (CPNN_110 CPNN_393) resistor r=40.975
    rCPNN_162 (CPNN_110 CPNN_135) resistor r=24.8333
    rCPNN_161 (CPNN_110 CPNN_132) resistor r=24.8333
    rCPNN_160 (CPNN_110 CPNN_143) resistor r=24.8333
    rCPNN_159 (CPNN_110 CPNN_140) resistor r=24.8333
    rCPNN_158 (CPNN_110 CPNN_148) resistor r=58.3583
    rCPNN_157 (CPNN_110 MM6_ELT_g) resistor r=7.45
    rCPNN_156 (CPNN_110 CPNN_135) resistor r=4.16253
    rCPNN_155 (CPNN_110 CPNN_112) resistor r=6.30933
    rCPNN_154 (CPNN_110 CPNN_143) resistor r=1.63969
    rCPNN_153 (CPNN_110 CPNN_132) resistor r=4.16253
    rCPNN_152 (CPNN_110 CPNN_148) resistor r=4.16253
    rCPNN_151 (CPNN_110 CPNN_140) resistor r=4.16253
    rCPNN_150 (CPNN_110 CPNN_151) resistor r=4.16253
    rCPNN_149 (CPNN_127 MM9_ELT_g) resistor r=50.9083
    rCPNN_148 (CPNN_151 MM6_ELT_g) resistor r=50.9083
    rCPNN_147 (CPNN_156 CPNN_162) resistor r=58.3583
    rCPNN_146 (CPNN_156 CPNN_162) resistor r=4.16253
    rCPNN_145 (CPNN_156 CPNN_162) resistor r=58.3583
    rCPNN_144 (CPNN_156 CPNN_162) resistor r=4.16253
    rCPNN_143 (CPNN_159 CPNN_162) resistor r=58.3583
    rCPNN_142 (CPNN_159 CPNN_162) resistor r=4.16253
    rCPNN_141 (CPNN_159 CPNN_162) resistor r=58.3583
    rCPNN_140 (CPNN_159 CPNN_162) resistor r=4.16253
    rCPNN_139 (CPNN_162 CPNN_167) resistor r=24.8333
    rCPNN_138 (CPNN_162 CPNN_164) resistor r=24.8333
    rCPNN_137 (CPNN_162 CPNN_175) resistor r=24.8333
    rCPNN_136 (CPNN_162 CPNN_172) resistor r=24.8333
    rCPNN_135 (CPNN_162 CPNN_180) resistor r=58.3583
    rCPNN_134 (CPNN_162 CPNN_183) resistor r=58.3583
    rCPNN_133 (CPNN_162 CPNN_188) resistor r=14.9
    rCPNN_132 (CPNN_162 CPNN_167) resistor r=4.16253
    rCPNN_131 (CPNN_162 CPNN_175) resistor r=4.16253
    rCPNN_130 (CPNN_162 CPNN_164) resistor r=4.16253
    rCPNN_129 (CPNN_162 CPNN_180) resistor r=4.16253
    rCPNN_128 (CPNN_162 CPNN_188) resistor r=6.30933
    rCPNN_127 (CPNN_162 CPNN_183) resistor r=6.30933
    rCPNN_126 (CPNN_162 CPNN_172) resistor r=1.63969
    rCPNN_125 (CPNN_162 CPNN_167) resistor r=24.8333
    rCPNN_124 (CPNN_162 CPNN_164) resistor r=24.8333
    rCPNN_123 (CPNN_162 CPNN_175) resistor r=24.8333
    rCPNN_122 (CPNN_162 CPNN_172) resistor r=24.8333
    rCPNN_121 (CPNN_162 CPNN_180) resistor r=58.3583
    rCPNN_120 (CPNN_162 MM5_ELT_g) resistor r=22.35
    rCPNN_119 (CPNN_162 CPNN_188) resistor r=14.9
    rCPNN_118 (CPNN_162 CPNN_431) resistor r=40.975
    rCPNN_117 (CPNN_162 CPNN_167) resistor r=4.16253
    rCPNN_116 (CPNN_162 CPNN_175) resistor r=4.16253
    rCPNN_115 (CPNN_162 CPNN_164) resistor r=4.16253
    rCPNN_114 (CPNN_162 CPNN_180) resistor r=4.16253
    rCPNN_113 (CPNN_162 CPNN_188) resistor r=6.30933
    rCPNN_112 (CPNN_162 CPNN_183) resistor r=6.30933
    rCPNN_111 (CPNN_162 CPNN_172) resistor r=1.63969
    rCPNN_110 (CPNN_183 MM5_ELT_g) resistor r=36.0083
    rCPNN_109 (CPNN_261 CPNN_263) resistor r=0.303776
    rCPNN_108 (CPNN_261 CPNN_291) resistor r=0.0101006
    rCPNN_107 (CPNN_263 CPNN_264) resistor r=13
    rCPNN_106 (CPNN_264 MM22_ELT_d) resistor r=8.44
    rCPNN_105 (CPNN_266 CPNN_268) resistor r=0.341082
    rCPNN_104 (CPNN_266 CPNN_295) resistor r=0.0101006
    rCPNN_103 (CPNN_268 CPNN_269) resistor r=8.66667
    rCPNN_102 (CPNN_268 CPNN_271) resistor r=0.639529
    rCPNN_101 (CPNN_269 CPNN) resistor r=32.3614
    rCPNN_100 (CPNN_271 CPNN_272) resistor r=8.66667
    rCPNN_99 (CPNN_271 CPNN_274) resistor r=0.426353
    rCPNN_98 (CPNN_272 CPNN) resistor r=16.1807
    rCPNN_97 (CPNN_272 CPNN_275) resistor r=32.3614
    rCPNN_96 (CPNN_274 CPNN_275) resistor r=26
    rCPNN_95 (CPNN_277 CPNN_278) resistor r=0.308124
    rCPNN_94 (CPNN_277 CPNN_293) resistor r=0.0101006
    rCPNN_93 (CPNN_278 CPNN_299) resistor r=0.119077
    rCPNN_92 (CPNN_279 CPNN_280) resistor r=0.224473
    rCPNN_91 (CPNN_279 CPNN_299) resistor r=0.119077
    rCPNN_90 (CPNN_280 CPNN_297) resistor r=0.0101006
    rCPNN_89 (CPNN_281 CPNN_284) resistor r=0.129694
    rCPNN_88 (CPNN_281 CPNN_300) resistor r=0.103548
    rCPNN_87 (CPNN_282 CPNN_284) resistor r=0.242096
    rCPNN_86 (CPNN_282 CPNN_299) resistor r=0.0119888
    rCPNN_85 (CPNN_284 CPNN_285) resistor r=10
    rCPNN_84 (CPNN_285 CPNN_463) resistor r=7.88824
    rCPNN_83 (CPNN_286 CPNN_288) resistor r=0.18888
    rCPNN_82 (CPNN_286 CPNN_301) resistor r=0.0967476
    rCPNN_81 (CPNN_288 CPNN_289) resistor r=10
    rCPNN_80 (CPNN_289 CPNN_443) resistor r=12.8682
    rCPNN_79 (CPNN_291 CPNN_293) resistor r=0.131756
    rCPNN_78 (CPNN_295 CPNN_297) resistor r=0.131756
    rCPNN_77 (CPNN_300 CPNN_305) resistor r=0.0413476
    rCPNN_76 (CPNN_301 CPNN_319) resistor r=1.11511
    rCPNN_75 (CPNN_302 CPNN_304) resistor r=0.163486
    rCPNN_74 (CPNN_302 CPNN_308) resistor r=0.0771447
    rCPNN_73 (CPNN_304 CPNN_305) resistor r=0.75
    rCPNN_72 (CPNN_307 CPNN_308) resistor r=0.304844
    rCPNN_71 (CPNN_307 CPNN_318) resistor r=0.0350658
    rCPNN_70 (CPNN_309 CPNN_310) resistor r=1.21058
    rCPNN_69 (CPNN_309 CPNN_318) resistor r=0.0421665
    rCPNN_68 (CPNN_310 CPNN_312) resistor r=0.0764802
    rCPNN_67 (CPNN_311 CPNN_312) resistor r=1.00735
    rCPNN_66 (CPNN_311 CPNN_314) resistor r=0.0764802
    rCPNN_65 (CPNN_313 CPNN_314) resistor r=0.498244
    rCPNN_64 (CPNN_313 CPNN_321) resistor r=0.0382401
    rCPNN_63 (CPNN_318 CPNN_319) resistor r=0.75
    rCPNN_62 (CPNN_321 CPNN_459) resistor r=0.75
    rCPNN_61 (CPNN_363 CPNN_463) resistor r=8.45489
    rCPNN_60 (CPNN_393 CPNN_444) resistor r=3.725
    rCPNN_59 (CPNN_395 CPNN_444) resistor r=3.725
    rCPNN_58 (CPNN_431 CPNN_454) resistor r=4.38767
    rCPNN_57 (CPNN_443 CPNN_444) resistor r=3.725
    rCPNN_56 (CPNN_453 CPNN_454) resistor r=3.71511
    rCPNN_55 (CPNN_453 CPNN_458) resistor r=6.09545
    rCPNN_54 (CPNN_458 CPNN_459) resistor r=10
    rD_106 (D_22 D_28) resistor r=58.3583
    rD_105 (D_22 D_28) resistor r=4.16253
    rD_104 (D_22 D_28) resistor r=58.3583
    rD_103 (D_22 D_28) resistor r=4.16253
    rD_102 (D_25 D_28) resistor r=58.3583
    rD_101 (D_25 D_28) resistor r=4.16253
    rD_100 (D_25 D_28) resistor r=58.3583
    rD_99 (D_25 D_28) resistor r=4.16253
    rD_98 (D_28 D_47) resistor r=24.8333
    rD_97 (D_28 D_44) resistor r=24.8333
    rD_96 (D_28 D_55) resistor r=24.8333
    rD_95 (D_28 D_52) resistor r=24.8333
    rD_94 (D_28 D_76) resistor r=58.3583
    rD_93 (D_28 D_79) resistor r=58.3583
    rD_92 (D_28 D_84) resistor r=14.9
    rD_91 (D_28 D_47) resistor r=4.16253
    rD_90 (D_28 D_55) resistor r=4.16253
    rD_89 (D_28 D_44) resistor r=4.16253
    rD_88 (D_28 D_76) resistor r=4.16253
    rD_87 (D_28 D_84) resistor r=6.30933
    rD_86 (D_28 D_79) resistor r=6.30933
    rD_85 (D_28 D_52) resistor r=1.63969
    rD_84 (D_28 D_47) resistor r=24.8333
    rD_83 (D_28 D_44) resistor r=24.8333
    rD_82 (D_28 D_55) resistor r=24.8333
    rD_81 (D_28 D_52) resistor r=24.8333
    rD_80 (D_28 D_76) resistor r=58.3583
    rD_79 (D_28 MM1_ELT_g) resistor r=22.35
    rD_78 (D_28 D_84) resistor r=14.9
    rD_77 (D_28 D_187) resistor r=39.7333
    rD_76 (D_28 D_47) resistor r=4.16253
    rD_75 (D_28 D_55) resistor r=4.16253
    rD_74 (D_28 D_44) resistor r=4.16253
    rD_73 (D_28 D_76) resistor r=4.16253
    rD_72 (D_28 D_84) resistor r=6.30933
    rD_71 (D_28 D_79) resistor r=6.30933
    rD_70 (D_28 D_52) resistor r=1.63969
    rD_69 (D_30 D_33) resistor r=14.9
    rD_68 (D_30 D_33) resistor r=6.30933
    rD_67 (D_30 D_33) resistor r=14.9
    rD_66 (D_30 D_33) resistor r=6.30933
    rD_65 (D_33 D_36) resistor r=58.3583
    rD_64 (D_33 D_39) resistor r=58.3583
    rD_63 (D_33 D_63) resistor r=24.8333
    rD_62 (D_33 D_60) resistor r=24.8333
    rD_61 (D_33 D_71) resistor r=24.8333
    rD_60 (D_33 D_68) resistor r=24.8333
    rD_59 (D_33 D_90) resistor r=58.3583
    rD_58 (D_33 D_93) resistor r=58.3583
    rD_57 (D_33 D_36) resistor r=6.30933
    rD_56 (D_33 D_63) resistor r=1.63969
    rD_55 (D_33 D_71) resistor r=4.16253
    rD_54 (D_33 D_39) resistor r=4.16253
    rD_53 (D_33 D_60) resistor r=4.16253
    rD_52 (D_33 D_90) resistor r=4.16253
    rD_51 (D_33 D_68) resistor r=4.16253
    rD_50 (D_33 D_93) resistor r=4.16253
    rD_49 (D_33 D_161) resistor r=39.7333
    rD_48 (D_33 D_36) resistor r=58.3583
    rD_47 (D_33 D_39) resistor r=58.3583
    rD_46 (D_33 D_63) resistor r=24.8333
    rD_45 (D_33 D_60) resistor r=24.8333
    rD_44 (D_33 D_71) resistor r=24.8333
    rD_43 (D_33 D_68) resistor r=24.8333
    rD_42 (D_33 D_90) resistor r=58.3583
    rD_41 (D_33 MM11_ELT_g) resistor r=7.45
    rD_40 (D_33 D_36) resistor r=6.30933
    rD_39 (D_33 D_63) resistor r=1.63969
    rD_38 (D_33 D_71) resistor r=4.16253
    rD_37 (D_33 D_39) resistor r=4.16253
    rD_36 (D_33 D_60) resistor r=4.16253
    rD_35 (D_33 D_90) resistor r=4.16253
    rD_34 (D_33 D_68) resistor r=4.16253
    rD_33 (D_33 D_93) resistor r=4.16253
    rD_32 (D_79 MM1_ELT_g) resistor r=36.0083
    rD_31 (D_93 MM11_ELT_g) resistor r=50.9083
    rD_30 (D_132 D_133) resistor r=10
    rD_29 (D_132 D) resistor r=0.0784964
    rD_28 (D_133 D_200) resistor r=13.5455
    rD_27 (D_161 D_201) resistor r=4.38767
    rD_26 (D_173 D_174) resistor r=57.5682
    rD_25 (D_173 D_197) resistor r=9.29775
    rD_24 (D_174 D_201) resistor r=3.71511
    rD_23 (D_187 D_195) resistor r=8.32506
    rD_22 (D_194 D_195) resistor r=40.975
    rD_21 (D_194 D_196) resistor r=8.32506
    rD_20 (D_196 D_197) resistor r=275.65
    rD_19 (D_200 D_201) resistor r=3.71511
    rCPN_96 (CPN_22 CPN_28) resistor r=58.3583
    rCPN_95 (CPN_22 CPN_28) resistor r=4.16253
    rCPN_94 (CPN_22 CPN_28) resistor r=58.3583
    rCPN_93 (CPN_22 CPN_28) resistor r=4.16253
    rCPN_92 (CPN_25 CPN_28) resistor r=58.3583
    rCPN_91 (CPN_25 CPN_28) resistor r=6.30933
    rCPN_90 (CPN_25 CPN_28) resistor r=58.3583
    rCPN_89 (CPN_25 CPN_28) resistor r=6.30933
    rCPN_88 (CPN_28 CPN_30) resistor r=14.9
    rCPN_87 (CPN_28 CPN_53) resistor r=24.8333
    rCPN_86 (CPN_28 CPN_50) resistor r=24.8333
    rCPN_85 (CPN_28 CPN_61) resistor r=24.8333
    rCPN_84 (CPN_28 CPN_58) resistor r=24.8333
    rCPN_83 (CPN_28 CPN_82) resistor r=58.3583
    rCPN_82 (CPN_28 CPN_85) resistor r=58.3583
    rCPN_81 (CPN_28 CPN_53) resistor r=4.16253
    rCPN_80 (CPN_28 CPN_30) resistor r=6.30933
    rCPN_79 (CPN_28 CPN_61) resistor r=1.63969
    rCPN_78 (CPN_28 CPN_50) resistor r=4.16253
    rCPN_77 (CPN_28 CPN_82) resistor r=4.16253
    rCPN_76 (CPN_28 CPN_58) resistor r=4.16253
    rCPN_75 (CPN_28 CPN_85) resistor r=4.16253
    rCPN_74 (CPN_28 CPN_30) resistor r=14.9
    rCPN_73 (CPN_28 CPN_162) resistor r=40.975
    rCPN_72 (CPN_28 CPN_53) resistor r=24.8333
    rCPN_71 (CPN_28 CPN_50) resistor r=24.8333
    rCPN_70 (CPN_28 CPN_61) resistor r=24.8333
    rCPN_69 (CPN_28 CPN_58) resistor r=24.8333
    rCPN_68 (CPN_28 CPN_82) resistor r=58.3583
    rCPN_67 (CPN_28 MM22_ELT_g) resistor r=7.45
    rCPN_66 (CPN_28 CPN_53) resistor r=4.16253
    rCPN_65 (CPN_28 CPN_30) resistor r=6.30933
    rCPN_64 (CPN_28 CPN_61) resistor r=1.63969
    rCPN_63 (CPN_28 CPN_50) resistor r=4.16253
    rCPN_62 (CPN_28 CPN_82) resistor r=4.16253
    rCPN_61 (CPN_28 CPN_58) resistor r=4.16253
    rCPN_60 (CPN_28 CPN_85) resistor r=4.16253
    rCPN_59 (CPN_36 CPN_39) resistor r=14.9
    rCPN_58 (CPN_36 CPN_39) resistor r=6.30933
    rCPN_57 (CPN_36 CPN_39) resistor r=14.9
    rCPN_56 (CPN_36 CPN_39) resistor r=6.30933
    rCPN_55 (CPN_39 CPN_42) resistor r=202.392
    rCPN_54 (CPN_39 CPN_45) resistor r=202.392
    rCPN_53 (CPN_39 CPN_69) resistor r=24.8333
    rCPN_52 (CPN_39 CPN_66) resistor r=24.8333
    rCPN_51 (CPN_39 CPN_77) resistor r=24.8333
    rCPN_50 (CPN_39 CPN_74) resistor r=24.8333
    rCPN_49 (CPN_39 CPN_90) resistor r=202.392
    rCPN_48 (CPN_39 CPN_93) resistor r=202.392
    rCPN_47 (CPN_39 CPN_42) resistor r=6.30933
    rCPN_46 (CPN_39 CPN_69) resistor r=1.63969
    rCPN_45 (CPN_39 CPN_77) resistor r=4.16253
    rCPN_44 (CPN_39 CPN_45) resistor r=4.16253
    rCPN_43 (CPN_39 CPN_66) resistor r=4.16253
    rCPN_42 (CPN_39 CPN_90) resistor r=4.16253
    rCPN_41 (CPN_39 CPN_74) resistor r=4.16253
    rCPN_40 (CPN_39 CPN_93) resistor r=4.16253
    rCPN_39 (CPN_39 CPN_164) resistor r=40.975
    rCPN_38 (CPN_39 CPN_42) resistor r=202.392
    rCPN_37 (CPN_39 CPN_45) resistor r=202.392
    rCPN_36 (CPN_39 CPN_69) resistor r=24.8333
    rCPN_35 (CPN_39 CPN_66) resistor r=24.8333
    rCPN_34 (CPN_39 CPN_77) resistor r=24.8333
    rCPN_33 (CPN_39 CPN_74) resistor r=24.8333
    rCPN_32 (CPN_39 CPN_90) resistor r=202.392
    rCPN_31 (CPN_39 MM21_ELT_g) resistor r=7.45
    rCPN_30 (CPN_39 CPN_42) resistor r=6.30933
    rCPN_29 (CPN_39 CPN_69) resistor r=1.63969
    rCPN_28 (CPN_39 CPN_77) resistor r=4.16253
    rCPN_27 (CPN_39 CPN_45) resistor r=4.16253
    rCPN_26 (CPN_39 CPN_66) resistor r=4.16253
    rCPN_25 (CPN_39 CPN_90) resistor r=4.16253
    rCPN_24 (CPN_39 CPN_74) resistor r=4.16253
    rCPN_23 (CPN_39 CPN_93) resistor r=4.16253
    rCPN_22 (CPN_85 MM22_ELT_g) resistor r=50.9083
    rCPN_21 (CPN_93 MM21_ELT_g) resistor r=194.942
    rCPN_20 (CPN_132 CPN_133) resistor r=10
    rCPN_19 (CPN_132 CPN) resistor r=0.0875808
    rCPN_18 (CPN_133 CPN_196) resistor r=13.5455
    rCPN_17 (CPN_162 CPN_197) resistor r=3.725
    rCPN_16 (CPN_164 CPN_197) resistor r=3.725
    rCPN_15 (CPN_196 CPN_197) resistor r=3.725
ends DDFNCNQD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: CKBD2_LVT_ELT
// View name: calibre
subckt CKBD2_LVT_ELT I Z VDD VSS
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.4125e-13 pd=1.34e-06 \
        ps=3.55e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.4125e-13 pd=1.34e-06 \
        ps=3.55e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.4125e-13 pd=1.34e-06 \
        ps=3.55e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.8485e-13 pd=3.66e-06 \
        ps=6.64333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.8485e-13 pd=3.66e-06 \
        ps=6.64333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.8485e-13 pd=3.66e-06 \
        ps=6.64333e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    ciZ_20 (Z_3 VSS) capacitor c=7.21956e-17
    ciZ_19 (Z_4 VSS) capacitor c=1.17382e-16
    ciZ_18 (Z_8 VSS) capacitor c=2.40618e-16
    ciZ_17 (Z_9 VSS) capacitor c=3.53834e-16
    ciZ_16 (Z_17 VSS) capacitor c=4.45429e-17
    ciZ_15 (Z_18 VSS) capacitor c=1.51463e-17
    ciZ_14 (Z_19 VSS) capacitor c=4.37539e-17
    ciZ_13 (Z_20 VSS) capacitor c=1.51463e-17
    ciZ_12 (Z_22 VSS) capacitor c=9.23576e-18
    ciZ_11 (Z_24 VSS) capacitor c=9.23576e-18
    ciZ_10 (Z_25 VSS) capacitor c=6.61733e-18
    ciZ_9 (Z_29 VSS) capacitor c=4.75426e-17
    ciZ_8 (Z_30 VSS) capacitor c=1.1105e-16
    ciZ_7 (Z_34 VSS) capacitor c=1.73902e-16
    ciZ_6 (Z_35 VSS) capacitor c=3.2943e-16
    ciZ_5 (Z VSS) capacitor c=2.26239e-17
    ciZ_4 (Z_48 VSS) capacitor c=2.67317e-17
    ciZ_3 (Z_49 VSS) capacitor c=1.08433e-17
    ciZ_2 (Z_52 VSS) capacitor c=1.88483e-17
    ciZ_1 (Z_56 VSS) capacitor c=1.55821e-17
    ciZ_0 (Z_58 VSS) capacitor c=5.57037e-18
    ciVDD_19 (VDD_2 VSS) capacitor c=6.33974e-17
    ciVDD_18 (VDD_11 VSS) capacitor c=2.42709e-16
    ciVDD_17 (VDD_19 VSS) capacitor c=2.06362e-17
    ciVDD_16 (VDD_20 VSS) capacitor c=2.99255e-17
    ciVDD_15 (VDD_27 VSS) capacitor c=2.4611e-16
    ciVDD_14 (VDD_35 VSS) capacitor c=1.64325e-17
    ciVDD_13 (VDD_38 VSS) capacitor c=6.41756e-17
    ciVDD_12 (VDD_41 VSS) capacitor c=3.58509e-18
    ciVDD_11 (VDD_42 VSS) capacitor c=3.58509e-18
    ciVDD_10 (VDD_48 VSS) capacitor c=1.32762e-17
    ciVDD_9 (VDD_50 VSS) capacitor c=4.67076e-18
    ciVDD_8 (VDD_53 VSS) capacitor c=1.11099e-18
    ciVDD_7 (VDD_57 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_59 VSS) capacitor c=5.38611e-18
    ciVDD_5 (MM14_ELT_s VSS) capacitor c=1.83252e-17
    ciVDD_4 (VDD_62 VSS) capacitor c=4.89311e-18
    ciVDD_3 (VDD_65 VSS) capacitor c=1.11099e-18
    ciVDD_2 (VDD_68 VSS) capacitor c=3.74333e-16
    ciVDD_1 (VDD_70 VSS) capacitor c=6.95673e-18
    ciVDD_0 (VDD_72 VSS) capacitor c=3.77014e-16
    ciVSS_13 (VSS_2 VSS) capacitor c=6.14087e-17
    ciVSS_12 (VSS_11 VSS) capacitor c=7.12037e-17
    ciVSS_11 (VSS_12 VSS) capacitor c=1.19726e-16
    ciVSS_10 (VSS_14 VSS) capacitor c=2.84451e-17
    ciVSS_9 (VSS_21 VSS) capacitor c=7.41406e-17
    ciVSS_8 (VSS_22 VSS) capacitor c=1.18558e-16
    ciVSS_7 (VSS_26 VSS) capacitor c=6.28372e-17
    ciVSS_6 (VSS_29 VSS) capacitor c=3.58509e-18
    ciVSS_5 (VSS_30 VSS) capacitor c=3.58509e-18
    ciVSS_4 (VSS_39 VSS) capacitor c=3.988e-18
    ciVSS_3 (VSS_45 VSS) capacitor c=4.96966e-18
    ciVSS_2 (MM15_ELT_s VSS) capacitor c=4.05795e-18
    ciVSS_1 (VSS_51 VSS) capacitor c=3.93524e-18
    ciVSS_0 (VSS_58 VSS) capacitor c=8.25361e-18
    cinet11_38 (net11_42 VSS) capacitor c=3.00043e-18
    cinet11_37 (net11_48 VSS) capacitor c=2.5237e-16
    cinet11_36 (net11_59 VSS) capacitor c=7.75614e-16
    cinet11_35 (net11_65 VSS) capacitor c=3.00043e-18
    cinet11_34 (net11_70 VSS) capacitor c=2.23768e-17
    cinet11_33 (net11_78 VSS) capacitor c=1.98626e-17
    cinet11_32 (net11_86 VSS) capacitor c=1.35297e-17
    cinet11_31 (net11_94 VSS) capacitor c=1.51948e-17
    cinet11_30 (net11_102 VSS) capacitor c=2.97045e-18
    cinet11_29 (net11_105 VSS) capacitor c=1.11212e-18
    cinet11_28 (net11_110 VSS) capacitor c=1.05656e-18
    cinet11_27 (net11_113 VSS) capacitor c=3.00043e-18
    cinet11_26 (net11_118 VSS) capacitor c=4.26469e-18
    cinet11_25 (net11_121 VSS) capacitor c=4.79949e-19
    cinet11_24 (net11_124 VSS) capacitor c=1.88379e-16
    cinet11_23 (net11_126 VSS) capacitor c=4.79949e-19
    cinet11_22 (net11_129 VSS) capacitor c=4.28147e-18
    cinet11_21 (net11_132 VSS) capacitor c=5.75568e-16
    cinet11_20 (net11_134 VSS) capacitor c=2.23559e-17
    cinet11_19 (net11_142 VSS) capacitor c=2.08546e-17
    cinet11_18 (net11_150 VSS) capacitor c=1.27573e-17
    cinet11_17 (net11_158 VSS) capacitor c=1.51948e-17
    cinet11_16 (net11_166 VSS) capacitor c=2.11871e-18
    cinet11_15 (net11_189 VSS) capacitor c=2.22299e-18
    cinet11_14 (net11_263 VSS) capacitor c=5.86248e-17
    cinet11_13 (net11_264 VSS) capacitor c=1.11634e-16
    cinet11_12 (net11_268 VSS) capacitor c=1.91277e-16
    cinet11_11 (net11_269 VSS) capacitor c=3.29932e-16
    cinet11_10 (net11_277 VSS) capacitor c=2.19197e-17
    cinet11_9 (net11_278 VSS) capacitor c=1.11714e-17
    cinet11_8 (net11_279 VSS) capacitor c=2.21159e-17
    cinet11_7 (net11_280 VSS) capacitor c=1.11714e-17
    cinet11_6 (net11_282 VSS) capacitor c=2.30591e-18
    cinet11_5 (net11_284 VSS) capacitor c=2.30591e-18
    cinet11_4 (net11_287 VSS) capacitor c=7.67183e-17
    cinet11_3 (net11_290 VSS) capacitor c=2.11485e-17
    cinet11_2 (net11_402 VSS) capacitor c=6.83014e-18
    cinet11_1 (net11_415 VSS) capacitor c=6.83284e-17
    cinet11_0 (net11_416 VSS) capacitor c=6.58262e-18
    ciI_12 (I_22 VSS) capacitor c=2.22299e-18
    ciI_11 (I_28 VSS) capacitor c=1.96061e-16
    ciI_10 (I_33 VSS) capacitor c=2.22299e-18
    ciI_9 (I_36 VSS) capacitor c=5.80168e-16
    ciI_8 (I_38 VSS) capacitor c=2.23768e-17
    ciI_7 (I_46 VSS) capacitor c=2.07274e-17
    ciI_6 (I_54 VSS) capacitor c=1.4283e-17
    ciI_5 (I_62 VSS) capacitor c=1.51948e-17
    ciI_4 (I_70 VSS) capacitor c=4.21073e-18
    ciI_3 (I_93 VSS) capacitor c=4.28147e-18
    ciI_2 (I VSS) capacitor c=4.50037e-17
    ciI_1 (I_198 VSS) capacitor c=2.7087e-17
    ciI_0 (I_199 VSS) capacitor c=1.09556e-17
    rZ_68 (Z_1 Z_3) resistor r=0.479713
    rZ_67 (Z_1 Z_18) resistor r=0.0960785
    rZ_66 (Z_3 Z_4) resistor r=13
    rZ_65 (Z_4 MM1_ELT_d) resistor r=8.44
    rZ_64 (Z_6 Z_8) resistor r=0.573315
    rZ_63 (Z_6 Z_20) resistor r=0.0960785
    rZ_62 (Z_8 Z_9) resistor r=8.66667
    rZ_61 (Z_8 Z_11) resistor r=0.702019
    rZ_60 (Z_9 MM2_ELT_d) resistor r=32.3614
    rZ_59 (Z_11 Z_12) resistor r=8.66667
    rZ_58 (Z_11 Z_14) resistor r=0.468012
    rZ_57 (Z_12 MM2_ELT_d) resistor r=16.1807
    rZ_56 (Z_12 Z_15) resistor r=32.3614
    rZ_55 (Z_14 Z_15) resistor r=26
    rZ_54 (Z_17 Z_18) resistor r=0.387189
    rZ_53 (Z_17 Z_21) resistor r=0.0960785
    rZ_52 (Z_19 Z_20) resistor r=0.402313
    rZ_51 (Z_19 Z_24) resistor r=0.0960785
    rZ_50 (Z_21 Z_22) resistor r=0.164431
    rZ_49 (Z_22 Z_49) resistor r=0.0728153
    rZ_48 (Z_23 Z_24) resistor r=0.164431
    rZ_47 (Z_23 Z_49) resistor r=0.0728153
    rZ_46 (Z_25 Z_26) resistor r=0.226811
    rZ_45 (Z_25 Z_58) resistor r=0.0189234
    rZ_44 (Z_26 Z_49) resistor r=0.0189234
    rZ_43 (Z_27 Z_29) resistor r=0.303726
    rZ_42 (Z_27 Z_50) resistor r=0.010099
    rZ_41 (Z_29 Z_30) resistor r=13
    rZ_40 (Z_30 MM15_ELT_d) resistor r=8.44
    rZ_39 (Z_32 Z_34) resistor r=0.341025
    rZ_38 (Z_32 Z_54) resistor r=0.010099
    rZ_37 (Z_34 Z_35) resistor r=8.66667
    rZ_36 (Z_34 Z_37) resistor r=0.639423
    rZ_35 (Z_35 MM14_ELT_d) resistor r=32.3614
    rZ_34 (Z_37 Z_38) resistor r=8.66667
    rZ_33 (Z_37 Z_40) resistor r=0.426282
    rZ_32 (Z_38 MM14_ELT_d) resistor r=16.1807
    rZ_31 (Z_38 Z_41) resistor r=32.3614
    rZ_30 (Z_40 Z_41) resistor r=26
    rZ_29 (Z_43 Z) resistor r=0.160591
    rZ_28 (Z_43 Z_52) resistor r=0.010099
    rZ_27 (Z_44 Z) resistor r=0.0953507
    rZ_26 (Z_44 Z_58) resistor r=0.0728153
    rZ_25 (Z_47 Z_48) resistor r=0.301107
    rZ_24 (Z_47 Z_58) resistor r=0.0728153
    rZ_23 (Z_48 Z_56) resistor r=0.010099
    rZ_22 (Z_50 Z_52) resistor r=0.128197
    rZ_21 (Z_54 Z_56) resistor r=0.126855
    rVDD_90 (MM2_ELT_b MM13_ELT_b) resistor r=0.01
    rVDD_89 (MM14_ELT_b MM13_ELT_b) resistor r=0.01
    rVDD_88 (MM13_ELT_b VDD_23) resistor r=8.66667
    rVDD_87 (MM13_ELT_b VDD_8) resistor r=67.52
    rVDD_86 (MM13_ELT_b VDD_39) resistor r=67.52
    rVDD_85 (VDD_2 VDD_7) resistor r=0.114632
    rVDD_84 (VDD_2 VDD_41) resistor r=0.0221541
    rVDD_83 (VDD VDD_7) resistor r=0.102773
    rVDD_82 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_81 (VDD_9 VDD_18) resistor r=0.415361
    rVDD_80 (VDD_9 VDD_41) resistor r=0.0882227
    rVDD_79 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_78 (VDD_11 VDD_15) resistor r=0.702019
    rVDD_77 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_76 (VDD_15 VDD_18) resistor r=0.702019
    rVDD_75 (VDD_18 VDD_19) resistor r=8.66667
    rVDD_74 (VDD_19 MM2_ELT_s) resistor r=0.850556
    rVDD_73 (VDD_19 MM13_ELT_s) resistor r=0.850556
    rVDD_72 (VDD_19 VDD_67) resistor r=13.0961
    rVDD_71 (VDD_20 VDD_23) resistor r=0.083009
    rVDD_70 (VDD_20 VDD_42) resistor r=0.0221541
    rVDD_69 (VDD_21 VDD_23) resistor r=0.0869618
    rVDD_68 (VDD_21 VDD_41) resistor r=0.0221541
    rVDD_67 (VDD_25 VDD_34) resistor r=0.415361
    rVDD_66 (VDD_25 VDD_42) resistor r=0.0882227
    rVDD_65 (VDD_27 VDD_35) resistor r=8.66667
    rVDD_64 (VDD_27 VDD_31) resistor r=0.702019
    rVDD_63 (VDD_31 VDD_35) resistor r=8.66667
    rVDD_62 (VDD_31 VDD_34) resistor r=0.702019
    rVDD_61 (VDD_34 VDD_35) resistor r=8.66667
    rVDD_60 (VDD_35 MM14_ELT_s) resistor r=4.04518
    rVDD_59 (VDD_35 VDD_71) resistor r=4.04518
    rVDD_58 (VDD_35 MM2_ELT_s) resistor r=4.04518
    rVDD_57 (VDD_35 VDD_69) resistor r=4.04518
    rVDD_56 (VDD_36 VDD_38) resistor r=0.118584
    rVDD_55 (VDD_36 VDD_42) resistor r=0.0221541
    rVDD_54 (VDD_38 VDD_39) resistor r=8.66667
    rVDD_53 (VDD_45 VDD_48) resistor r=31.2341
    rVDD_52 (VDD_45 VDD_49) resistor r=9.04595
    rVDD_51 (VDD_46 VDD_48) resistor r=31.2341
    rVDD_50 (VDD_46 VDD_52) resistor r=9.04062
    rVDD_49 (MM13_ELT_s VDD_48) resistor r=6.12113
    rVDD_48 (MM13_ELT_s VDD_50) resistor r=12.3172
    rVDD_47 (MM13_ELT_s VDD_50) resistor r=1.62887
    rVDD_46 (MM13_ELT_s VDD_53) resistor r=2.55965
    rVDD_45 (VDD_49 VDD_50) resistor r=12.3172
    rVDD_44 (VDD_51 VDD_53) resistor r=14.4784
    rVDD_43 (VDD_51 VDD_68) resistor r=10.5593
    rVDD_42 (VDD_52 VDD_53) resistor r=14.4784
    rVDD_41 (MM2_ELT_s VDD_57) resistor r=2.55965
    rVDD_40 (MM2_ELT_s VDD_59) resistor r=12.3172
    rVDD_39 (MM2_ELT_s VDD_59) resistor r=1.62887
    rVDD_38 (VDD_55 VDD_57) resistor r=14.4784
    rVDD_37 (VDD_55 VDD_72) resistor r=10.5593
    rVDD_36 (VDD_56 VDD_57) resistor r=14.4784
    rVDD_35 (VDD_56 VDD_68) resistor r=10.5593
    rVDD_34 (VDD_58 VDD_59) resistor r=12.3172
    rVDD_33 (VDD_58 VDD_70) resistor r=10.2363
    rVDD_32 (MM14_ELT_s VDD_62) resistor r=12.3172
    rVDD_31 (MM14_ELT_s VDD_62) resistor r=1.62887
    rVDD_30 (MM14_ELT_s VDD_65) resistor r=2.55965
    rVDD_29 (MM14_ELT_s VDD_66) resistor r=25.7298
    rVDD_28 (VDD_61 VDD_62) resistor r=12.3172
    rVDD_27 (VDD_61 VDD_70) resistor r=10.2363
    rVDD_26 (VDD_63 VDD_65) resistor r=14.4784
    rVDD_25 (VDD_63 VDD_66) resistor r=9.04062
    rVDD_24 (VDD_64 VDD_65) resistor r=14.4784
    rVDD_23 (VDD_64 VDD_72) resistor r=10.5593
    rVDD_22 (VDD_67 VDD_68) resistor r=0.730683
    rVDD_21 (VDD_69 VDD_70) resistor r=0.549089
    rVDD_20 (VDD_71 VDD_72) resistor r=0.730683
    rVSS_76 (MM1_ELT_b MM12_ELT_b) resistor r=0.01
    rVSS_75 (MM15_ELT_b MM12_ELT_b) resistor r=0.01
    rVSS_74 (MM12_ELT_b VSS_17) resistor r=8.66667
    rVSS_73 (MM12_ELT_b VSS_8) resistor r=64.7228
    rVSS_72 (MM12_ELT_b VSS_27) resistor r=64.7228
    rVSS_71 (VSS_2 VSS_7) resistor r=0.114632
    rVSS_70 (VSS_2 VSS_29) resistor r=0.0221541
    rVSS_69 (VSS VSS_7) resistor r=0.100797
    rVSS_68 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_67 (VSS_9 VSS_11) resistor r=0.444612
    rVSS_66 (VSS_9 VSS_29) resistor r=0.0882227
    rVSS_65 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_64 (VSS_12 MM1_ELT_s) resistor r=2.27123
    rVSS_63 (VSS_12 MM12_ELT_s) resistor r=2.27123
    rVSS_62 (VSS_12 VSS_53) resistor r=8.4738
    rVSS_61 (VSS_14 VSS_17) resistor r=0.083009
    rVSS_60 (VSS_14 VSS_30) resistor r=0.0221541
    rVSS_59 (VSS_15 VSS_17) resistor r=0.0869618
    rVSS_58 (VSS_15 VSS_29) resistor r=0.0221541
    rVSS_57 (VSS_19 VSS_21) resistor r=0.444612
    rVSS_56 (VSS_19 VSS_30) resistor r=0.0882227
    rVSS_55 (VSS_21 VSS_22) resistor r=8.66667
    rVSS_54 (VSS_22 MM15_ELT_s) resistor r=4.22001
    rVSS_53 (VSS_22 VSS_57) resistor r=4.22001
    rVSS_52 (VSS_22 MM1_ELT_s) resistor r=4.22001
    rVSS_51 (VSS_22 VSS_55) resistor r=4.22001
    rVSS_50 (VSS_24 VSS_26) resistor r=0.118584
    rVSS_49 (VSS_24 VSS_30) resistor r=0.0221541
    rVSS_48 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_47 (VSS_31 VSS_34) resistor r=21.1301
    rVSS_46 (VSS_31 VSS_36) resistor r=9.43134
    rVSS_45 (VSS_32 VSS_34) resistor r=21.1301
    rVSS_44 (VSS_32 VSS_38) resistor r=9.4369
    rVSS_43 (MM12_ELT_s VSS_34) resistor r=4.557
    rVSS_42 (MM12_ELT_s VSS_37) resistor r=2.67027
    rVSS_41 (MM12_ELT_s VSS_39) resistor r=12.8495
    rVSS_40 (MM12_ELT_s VSS_39) resistor r=1.69926
    rVSS_39 (VSS_35 VSS_37) resistor r=15.1041
    rVSS_38 (VSS_35 VSS_54) resistor r=11.0157
    rVSS_37 (VSS_36 VSS_37) resistor r=15.1041
    rVSS_36 (VSS_38 VSS_39) resistor r=12.8495
    rVSS_35 (MM1_ELT_s VSS_43) resistor r=2.67027
    rVSS_34 (MM1_ELT_s VSS_45) resistor r=12.8495
    rVSS_33 (MM1_ELT_s VSS_45) resistor r=1.69926
    rVSS_32 (VSS_41 VSS_43) resistor r=15.1041
    rVSS_31 (VSS_41 VSS_56) resistor r=11.0157
    rVSS_30 (VSS_42 VSS_43) resistor r=15.1041
    rVSS_29 (VSS_42 VSS_54) resistor r=11.0157
    rVSS_28 (VSS_44 VSS_45) resistor r=12.8495
    rVSS_27 (VSS_44 VSS_58) resistor r=10.6787
    rVSS_26 (MM15_ELT_s VSS_49) resistor r=2.67027
    rVSS_25 (MM15_ELT_s VSS_51) resistor r=12.8495
    rVSS_24 (MM15_ELT_s VSS_51) resistor r=1.69926
    rVSS_23 (MM15_ELT_s VSS_52) resistor r=18.0507
    rVSS_22 (VSS_47 VSS_49) resistor r=15.1041
    rVSS_21 (VSS_47 VSS_52) resistor r=9.43134
    rVSS_20 (VSS_48 VSS_49) resistor r=15.1041
    rVSS_19 (VSS_48 VSS_56) resistor r=11.0157
    rVSS_18 (VSS_50 VSS_51) resistor r=12.8495
    rVSS_17 (VSS_50 VSS_58) resistor r=10.6787
    rVSS_16 (VSS_53 VSS_54) resistor r=0.762262
    rVSS_15 (VSS_55 VSS_56) resistor r=0.762262
    rVSS_14 (VSS_57 VSS_58) resistor r=0.57282
    rnet11_224 (MM13_ELT_d net11) resistor r=0.01
    rnet11_223 (net11_42 net11_48) resistor r=58.3583
    rnet11_222 (net11_42 net11_48) resistor r=4.16253
    rnet11_221 (net11_42 net11_48) resistor r=58.3583
    rnet11_220 (net11_42 net11_48) resistor r=4.16253
    rnet11_219 (net11_45 net11_48) resistor r=58.3583
    rnet11_218 (net11_45 net11_48) resistor r=6.30933
    rnet11_217 (net11_45 net11_48) resistor r=58.3583
    rnet11_216 (net11_45 net11_48) resistor r=6.30933
    rnet11_215 (net11_48 net11_50) resistor r=14.9
    rnet11_214 (net11_48 net11_73) resistor r=24.8333
    rnet11_213 (net11_48 net11_70) resistor r=24.8333
    rnet11_212 (net11_48 net11_81) resistor r=24.8333
    rnet11_211 (net11_48 net11_78) resistor r=24.8333
    rnet11_210 (net11_48 net11_102) resistor r=58.3583
    rnet11_209 (net11_48 net11_105) resistor r=58.3583
    rnet11_208 (net11_48 net11_73) resistor r=4.16253
    rnet11_207 (net11_48 net11_50) resistor r=6.30933
    rnet11_206 (net11_48 net11_81) resistor r=1.63969
    rnet11_205 (net11_48 net11_70) resistor r=4.16253
    rnet11_204 (net11_48 net11_102) resistor r=4.16253
    rnet11_203 (net11_48 net11_78) resistor r=4.16253
    rnet11_202 (net11_48 net11_105) resistor r=4.16253
    rnet11_201 (net11_48 net11_50) resistor r=14.9
    rnet11_200 (net11_48 net11_335) resistor r=40.975
    rnet11_199 (net11_48 net11_73) resistor r=24.8333
    rnet11_198 (net11_48 net11_70) resistor r=24.8333
    rnet11_197 (net11_48 net11_81) resistor r=24.8333
    rnet11_196 (net11_48 net11_78) resistor r=24.8333
    rnet11_195 (net11_48 net11_102) resistor r=58.3583
    rnet11_194 (net11_48 MM1_ELT_g) resistor r=7.45
    rnet11_193 (net11_48 net11_73) resistor r=4.16253
    rnet11_192 (net11_48 net11_50) resistor r=6.30933
    rnet11_191 (net11_48 net11_81) resistor r=1.63969
    rnet11_190 (net11_48 net11_70) resistor r=4.16253
    rnet11_189 (net11_48 net11_102) resistor r=4.16253
    rnet11_188 (net11_48 net11_78) resistor r=4.16253
    rnet11_187 (net11_48 net11_105) resistor r=4.16253
    rnet11_186 (net11_56 net11_59) resistor r=14.9
    rnet11_185 (net11_56 net11_59) resistor r=6.30933
    rnet11_184 (net11_56 net11_59) resistor r=14.9
    rnet11_183 (net11_56 net11_59) resistor r=6.30933
    rnet11_182 (net11_59 net11_62) resistor r=202.392
    rnet11_181 (net11_59 net11_65) resistor r=202.392
    rnet11_180 (net11_59 net11_89) resistor r=24.8333
    rnet11_179 (net11_59 net11_86) resistor r=24.8333
    rnet11_178 (net11_59 net11_97) resistor r=24.8333
    rnet11_177 (net11_59 net11_94) resistor r=24.8333
    rnet11_176 (net11_59 net11_110) resistor r=202.392
    rnet11_175 (net11_59 net11_113) resistor r=202.392
    rnet11_174 (net11_59 net11_62) resistor r=6.30933
    rnet11_173 (net11_59 net11_89) resistor r=1.63969
    rnet11_172 (net11_59 net11_97) resistor r=4.16253
    rnet11_171 (net11_59 net11_65) resistor r=4.16253
    rnet11_170 (net11_59 net11_86) resistor r=4.16253
    rnet11_169 (net11_59 net11_110) resistor r=4.16253
    rnet11_168 (net11_59 net11_94) resistor r=4.16253
    rnet11_167 (net11_59 net11_113) resistor r=4.16253
    rnet11_166 (net11_59 net11_337) resistor r=40.975
    rnet11_165 (net11_59 net11_62) resistor r=202.392
    rnet11_164 (net11_59 net11_65) resistor r=202.392
    rnet11_163 (net11_59 net11_89) resistor r=24.8333
    rnet11_162 (net11_59 net11_86) resistor r=24.8333
    rnet11_161 (net11_59 net11_97) resistor r=24.8333
    rnet11_160 (net11_59 net11_94) resistor r=24.8333
    rnet11_159 (net11_59 net11_110) resistor r=202.392
    rnet11_158 (net11_59 MM2_ELT_g) resistor r=7.45
    rnet11_157 (net11_59 net11_62) resistor r=6.30933
    rnet11_156 (net11_59 net11_89) resistor r=1.63969
    rnet11_155 (net11_59 net11_97) resistor r=4.16253
    rnet11_154 (net11_59 net11_65) resistor r=4.16253
    rnet11_153 (net11_59 net11_86) resistor r=4.16253
    rnet11_152 (net11_59 net11_110) resistor r=4.16253
    rnet11_151 (net11_59 net11_94) resistor r=4.16253
    rnet11_150 (net11_59 net11_113) resistor r=4.16253
    rnet11_149 (net11_105 MM1_ELT_g) resistor r=50.9083
    rnet11_148 (net11_113 MM2_ELT_g) resistor r=194.942
    rnet11_147 (net11_118 net11_124) resistor r=58.3583
    rnet11_146 (net11_118 net11_124) resistor r=4.16253
    rnet11_145 (net11_118 net11_124) resistor r=58.3583
    rnet11_144 (net11_118 net11_124) resistor r=4.16253
    rnet11_143 (net11_121 net11_124) resistor r=58.3583
    rnet11_142 (net11_121 net11_124) resistor r=4.16253
    rnet11_141 (net11_121 net11_124) resistor r=58.3583
    rnet11_140 (net11_121 net11_124) resistor r=4.16253
    rnet11_139 (net11_124 net11_137) resistor r=24.8333
    rnet11_138 (net11_124 net11_134) resistor r=24.8333
    rnet11_137 (net11_124 net11_145) resistor r=24.8333
    rnet11_136 (net11_124 net11_142) resistor r=24.8333
    rnet11_135 (net11_124 net11_166) resistor r=58.3583
    rnet11_134 (net11_124 net11_169) resistor r=58.3583
    rnet11_133 (net11_124 net11_174) resistor r=14.9
    rnet11_132 (net11_124 net11_137) resistor r=4.16253
    rnet11_131 (net11_124 net11_145) resistor r=4.16253
    rnet11_130 (net11_124 net11_134) resistor r=4.16253
    rnet11_129 (net11_124 net11_166) resistor r=4.16253
    rnet11_128 (net11_124 net11_174) resistor r=6.30933
    rnet11_127 (net11_124 net11_169) resistor r=6.30933
    rnet11_126 (net11_124 net11_142) resistor r=1.63969
    rnet11_125 (net11_124 net11_137) resistor r=24.8333
    rnet11_124 (net11_124 net11_134) resistor r=24.8333
    rnet11_123 (net11_124 net11_145) resistor r=24.8333
    rnet11_122 (net11_124 net11_142) resistor r=24.8333
    rnet11_121 (net11_124 net11_166) resistor r=58.3583
    rnet11_120 (net11_124 MM15_ELT_g) resistor r=22.35
    rnet11_119 (net11_124 net11_174) resistor r=14.9
    rnet11_118 (net11_124 net11_389) resistor r=40.975
    rnet11_117 (net11_124 net11_137) resistor r=4.16253
    rnet11_116 (net11_124 net11_145) resistor r=4.16253
    rnet11_115 (net11_124 net11_134) resistor r=4.16253
    rnet11_114 (net11_124 net11_166) resistor r=4.16253
    rnet11_113 (net11_124 net11_174) resistor r=6.30933
    rnet11_112 (net11_124 net11_169) resistor r=6.30933
    rnet11_111 (net11_124 net11_142) resistor r=1.63969
    rnet11_110 (net11_126 net11_132) resistor r=202.392
    rnet11_109 (net11_126 net11_132) resistor r=4.16253
    rnet11_108 (net11_126 net11_132) resistor r=202.392
    rnet11_107 (net11_126 net11_132) resistor r=4.16253
    rnet11_106 (net11_129 net11_132) resistor r=202.392
    rnet11_105 (net11_129 net11_132) resistor r=4.16253
    rnet11_104 (net11_129 net11_132) resistor r=202.392
    rnet11_103 (net11_129 net11_132) resistor r=4.16253
    rnet11_102 (net11_132 net11_153) resistor r=24.8333
    rnet11_101 (net11_132 net11_150) resistor r=24.8333
    rnet11_100 (net11_132 net11_161) resistor r=24.8333
    rnet11_99 (net11_132 net11_158) resistor r=24.8333
    rnet11_98 (net11_132 net11_180) resistor r=14.9
    rnet11_97 (net11_132 net11_186) resistor r=202.392
    rnet11_96 (net11_132 net11_189) resistor r=202.392
    rnet11_95 (net11_132 net11_153) resistor r=4.16253
    rnet11_94 (net11_132 net11_161) resistor r=4.16253
    rnet11_93 (net11_132 net11_186) resistor r=6.30933
    rnet11_92 (net11_132 net11_180) resistor r=6.30933
    rnet11_91 (net11_132 net11_150) resistor r=1.63969
    rnet11_90 (net11_132 net11_158) resistor r=4.16253
    rnet11_89 (net11_132 net11_189) resistor r=4.16253
    rnet11_88 (net11_132 net11_153) resistor r=24.8333
    rnet11_87 (net11_132 net11_150) resistor r=24.8333
    rnet11_86 (net11_132 net11_161) resistor r=24.8333
    rnet11_85 (net11_132 net11_158) resistor r=24.8333
    rnet11_84 (net11_132 net11_391) resistor r=40.975
    rnet11_83 (net11_132 net11_180) resistor r=14.9
    rnet11_82 (net11_132 net11_186) resistor r=202.392
    rnet11_81 (net11_132 MM14_ELT_g) resistor r=7.45
    rnet11_80 (net11_132 net11_153) resistor r=4.16253
    rnet11_79 (net11_132 net11_161) resistor r=4.16253
    rnet11_78 (net11_132 net11_186) resistor r=6.30933
    rnet11_77 (net11_132 net11_180) resistor r=6.30933
    rnet11_76 (net11_132 net11_150) resistor r=1.63969
    rnet11_75 (net11_132 net11_158) resistor r=4.16253
    rnet11_74 (net11_132 net11_189) resistor r=4.16253
    rnet11_73 (net11_169 MM15_ELT_g) resistor r=36.0083
    rnet11_72 (net11_189 MM14_ELT_g) resistor r=194.942
    rnet11_71 (net11_261 net11_263) resistor r=0.436939
    rnet11_70 (net11_261 net11_278) resistor r=0.0960785
    rnet11_69 (net11_263 net11_264) resistor r=13
    rnet11_68 (net11_264 MM12_ELT_d) resistor r=8.44
    rnet11_67 (net11_266 net11_268) resistor r=0.522195
    rnet11_66 (net11_266 net11_280) resistor r=0.0960785
    rnet11_65 (net11_268 net11_269) resistor r=8.66667
    rnet11_64 (net11_268 net11_271) resistor r=0.639423
    rnet11_63 (net11_269 net11) resistor r=32.3614
    rnet11_62 (net11_271 net11_272) resistor r=8.66667
    rnet11_61 (net11_271 net11_274) resistor r=0.426282
    rnet11_60 (net11_272 net11) resistor r=16.1807
    rnet11_59 (net11_272 net11_275) resistor r=32.3614
    rnet11_58 (net11_274 net11_275) resistor r=26
    rnet11_57 (net11_277 net11_278) resistor r=0.0927018
    rnet11_56 (net11_277 net11_281) resistor r=0.0960785
    rnet11_55 (net11_279 net11_280) resistor r=0.0927018
    rnet11_54 (net11_279 net11_284) resistor r=0.0960785
    rnet11_53 (net11_281 net11_282) resistor r=0.0878228
    rnet11_52 (net11_282 net11_290) resistor r=0.119057
    rnet11_51 (net11_283 net11_284) resistor r=0.0878228
    rnet11_50 (net11_283 net11_290) resistor r=0.119057
    rnet11_49 (net11_285 net11_287) resistor r=0.186222
    rnet11_48 (net11_285 net11_290) resistor r=0.0119903
    rnet11_47 (net11_287 net11_288) resistor r=10
    rnet11_46 (net11_288 net11_401) resistor r=4.06364
    rnet11_45 (net11_288 net11_415) resistor r=93.4636
    rnet11_44 (net11_335 net11_402) resistor r=10.0997
    rnet11_43 (net11_337 net11_402) resistor r=10.0997
    rnet11_42 (net11_389 net11_416) resistor r=10.0997
    rnet11_41 (net11_391 net11_416) resistor r=10.0997
    rnet11_40 (net11_401 net11_402) resistor r=0.877078
    rnet11_39 (net11_415 net11_416) resistor r=0.877078
    rI_94 (I_22 I_28) resistor r=58.3583
    rI_93 (I_22 I_28) resistor r=4.16253
    rI_92 (I_22 I_28) resistor r=58.3583
    rI_91 (I_22 I_28) resistor r=4.16253
    rI_90 (I_25 I_28) resistor r=58.3583
    rI_89 (I_25 I_28) resistor r=4.16253
    rI_88 (I_25 I_28) resistor r=58.3583
    rI_87 (I_25 I_28) resistor r=4.16253
    rI_86 (I_28 I_41) resistor r=24.8333
    rI_85 (I_28 I_38) resistor r=24.8333
    rI_84 (I_28 I_49) resistor r=24.8333
    rI_83 (I_28 I_46) resistor r=24.8333
    rI_82 (I_28 I_70) resistor r=58.3583
    rI_81 (I_28 I_73) resistor r=58.3583
    rI_80 (I_28 I_78) resistor r=14.9
    rI_79 (I_28 I_41) resistor r=4.16253
    rI_78 (I_28 I_49) resistor r=4.16253
    rI_77 (I_28 I_38) resistor r=4.16253
    rI_76 (I_28 I_70) resistor r=4.16253
    rI_75 (I_28 I_78) resistor r=6.30933
    rI_74 (I_28 I_73) resistor r=6.30933
    rI_73 (I_28 I_46) resistor r=1.63969
    rI_72 (I_28 I_41) resistor r=24.8333
    rI_71 (I_28 I_38) resistor r=24.8333
    rI_70 (I_28 I_49) resistor r=24.8333
    rI_69 (I_28 I_46) resistor r=24.8333
    rI_68 (I_28 I_70) resistor r=58.3583
    rI_67 (I_28 MM12_ELT_g) resistor r=22.35
    rI_66 (I_28 I_78) resistor r=14.9
    rI_65 (I_28 I_182) resistor r=40.975
    rI_64 (I_28 I_41) resistor r=4.16253
    rI_63 (I_28 I_49) resistor r=4.16253
    rI_62 (I_28 I_38) resistor r=4.16253
    rI_61 (I_28 I_70) resistor r=4.16253
    rI_60 (I_28 I_78) resistor r=6.30933
    rI_59 (I_28 I_73) resistor r=6.30933
    rI_58 (I_28 I_46) resistor r=1.63969
    rI_57 (I_30 I_36) resistor r=202.392
    rI_56 (I_30 I_36) resistor r=4.16253
    rI_55 (I_30 I_36) resistor r=202.392
    rI_54 (I_30 I_36) resistor r=4.16253
    rI_53 (I_33 I_36) resistor r=202.392
    rI_52 (I_33 I_36) resistor r=4.16253
    rI_51 (I_33 I_36) resistor r=202.392
    rI_50 (I_33 I_36) resistor r=4.16253
    rI_49 (I_36 I_57) resistor r=24.8333
    rI_48 (I_36 I_54) resistor r=24.8333
    rI_47 (I_36 I_65) resistor r=24.8333
    rI_46 (I_36 I_62) resistor r=24.8333
    rI_45 (I_36 I_84) resistor r=14.9
    rI_44 (I_36 I_90) resistor r=202.392
    rI_43 (I_36 I_93) resistor r=202.392
    rI_42 (I_36 I_57) resistor r=4.16253
    rI_41 (I_36 I_65) resistor r=4.16253
    rI_40 (I_36 I_90) resistor r=6.30933
    rI_39 (I_36 I_84) resistor r=6.30933
    rI_38 (I_36 I_54) resistor r=1.63969
    rI_37 (I_36 I_62) resistor r=4.16253
    rI_36 (I_36 I_93) resistor r=4.16253
    rI_35 (I_36 I_57) resistor r=24.8333
    rI_34 (I_36 I_54) resistor r=24.8333
    rI_33 (I_36 I_65) resistor r=24.8333
    rI_32 (I_36 I_62) resistor r=24.8333
    rI_31 (I_36 I_184) resistor r=40.975
    rI_30 (I_36 I_84) resistor r=14.9
    rI_29 (I_36 I_90) resistor r=202.392
    rI_28 (I_36 MM13_ELT_g) resistor r=7.45
    rI_27 (I_36 I_57) resistor r=4.16253
    rI_26 (I_36 I_65) resistor r=4.16253
    rI_25 (I_36 I_90) resistor r=6.30933
    rI_24 (I_36 I_84) resistor r=6.30933
    rI_23 (I_36 I_54) resistor r=1.63969
    rI_22 (I_36 I_62) resistor r=4.16253
    rI_21 (I_36 I_93) resistor r=4.16253
    rI_20 (I_73 MM12_ELT_g) resistor r=36.0083
    rI_19 (I_93 MM13_ELT_g) resistor r=194.942
    rI_18 (I_132 I_133) resistor r=10
    rI_17 (I_132 I) resistor r=0.0846462
    rI_16 (I_133 I_198) resistor r=41.3136
    rI_15 (I_182 I_199) resistor r=10.0997
    rI_14 (I_184 I_199) resistor r=10.0997
    rI_13 (I_198 I_199) resistor r=0.877078
ends CKBD2_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DDFCNQD1_LVT_ELT
// View name: calibre
subckt DDFCNQD1_LVT_ELT CDN CP D Q VDD VSS
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.0725e-13 pd=1.34e-06 \
        ps=4.81e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=3.0725e-13 as=9.4e-14 pd=4.81e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM24_ELT (MM24_ELT_d MM24_ELT_g MM24_ELT_s MM24_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM22_ELT (MM22_ELT_d MM22_ELT_g MM22_ELT_s MM22_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.93575e-13 pd=3.66e-06 \
        ps=7.295e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.93575e-13 pd=3.66e-06 \
        ps=7.295e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=6.4365e-13 as=3.26e-13 pd=9.45e-06 \
        ps=3.66e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM20_ELT (MM20_ELT_d MM20_ELT_g MM20_ELT_s MM20_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.4365e-13 pd=3.66e-06 \
        ps=9.45e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM26_ELT (MM26_ELT_d MM26_ELT_g MM26_ELT_s MM26_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.02583e-13 pd=1.34e-06 \
        ps=3.75909e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.88292e-13 pd=3.66e-06 \
        ps=8.55091e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM23_ELT (MM23_ELT_d MM23_ELT_g MM23_ELT_s MM23_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM21_ELT (MM21_ELT_d MM21_ELT_g MM21_ELT_s MM21_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciQ_8 (Q_3 VSS) capacitor c=4.85223e-17
    ciQ_7 (Q_4 VSS) capacitor c=1.11576e-16
    ciQ_6 (Q_8 VSS) capacitor c=1.73805e-16
    ciQ_5 (Q_9 VSS) capacitor c=3.29378e-16
    ciQ_4 (Q_17 VSS) capacitor c=2.27485e-17
    ciQ_3 (Q_18 VSS) capacitor c=1.24301e-17
    ciQ_2 (Q_19 VSS) capacitor c=2.12404e-17
    ciQ_1 (Q_20 VSS) capacitor c=6.36472e-18
    ciQ_0 (Q VSS) capacitor c=6.99269e-17
    ciVDD_48 (VDD_4 VSS) capacitor c=1.33928e-16
    ciVDD_47 (VDD_13 VSS) capacitor c=4.70678e-17
    ciVDD_46 (VDD_14 VSS) capacitor c=2.63453e-17
    ciVDD_45 (VDD_20 VSS) capacitor c=2.23678e-16
    ciVDD_44 (VDD_28 VSS) capacitor c=7.03416e-18
    ciVDD_43 (VDD_32 VSS) capacitor c=8.7195e-17
    ciVDD_42 (VDD_39 VSS) capacitor c=1.76409e-16
    ciVDD_41 (VDD_40 VSS) capacitor c=2.57964e-18
    ciVDD_40 (VDD_47 VSS) capacitor c=1.53677e-16
    ciVDD_39 (VDD_48 VSS) capacitor c=2.88869e-16
    ciVDD_38 (VDD_64 VSS) capacitor c=2.45459e-16
    ciVDD_37 (VDD_72 VSS) capacitor c=3.73273e-16
    ciVDD_36 (VDD_78 VSS) capacitor c=7.74034e-17
    ciVDD_35 (VDD_86 VSS) capacitor c=3.58509e-18
    ciVDD_34 (VDD_89 VSS) capacitor c=3.58509e-18
    ciVDD_33 (VDD_91 VSS) capacitor c=3.58509e-18
    ciVDD_32 (VDD_97 VSS) capacitor c=1.11099e-18
    ciVDD_31 (VDD_98 VSS) capacitor c=3.16638e-18
    ciVDD_30 (VDD_99 VSS) capacitor c=2.30804e-18
    ciVDD_29 (VDD_102 VSS) capacitor c=1.7339e-17
    ciVDD_28 (VDD_106 VSS) capacitor c=1.71175e-18
    ciVDD_27 (MM23_ELT_s VSS) capacitor c=3.97088e-18
    ciVDD_26 (VDD_108 VSS) capacitor c=1.70317e-18
    ciVDD_25 (VDD_109 VSS) capacitor c=1.64973e-18
    ciVDD_24 (VDD_112 VSS) capacitor c=1.71175e-18
    ciVDD_23 (VDD_113 VSS) capacitor c=5.53407e-18
    ciVDD_22 (VDD_114 VSS) capacitor c=1.64973e-18
    ciVDD_21 (VDD_117 VSS) capacitor c=9.60313e-18
    ciVDD_20 (MM9_ELT_s VSS) capacitor c=5.78319e-17
    ciVDD_19 (VDD_123 VSS) capacitor c=1.11099e-18
    ciVDD_18 (VDD_124 VSS) capacitor c=2.38266e-18
    ciVDD_17 (VDD_125 VSS) capacitor c=5.60847e-18
    ciVDD_16 (VDD_128 VSS) capacitor c=2.34185e-18
    ciVDD_15 (MM26_ELT_s VSS) capacitor c=1.03508e-17
    ciVDD_14 (VDD_130 VSS) capacitor c=4.22695e-18
    ciVDD_13 (VDD_132 VSS) capacitor c=4.0633e-18
    ciVDD_12 (MM8_ELT_s VSS) capacitor c=3.93055e-17
    ciVDD_11 (VDD_137 VSS) capacitor c=1.68965e-18
    ciVDD_10 (VDD_138 VSS) capacitor c=4.4658e-18
    ciVDD_9 (VDD_140 VSS) capacitor c=6.04798e-18
    ciVDD_8 (VDD_144 VSS) capacitor c=1.11099e-18
    ciVDD_7 (VDD_145 VSS) capacitor c=8.79289e-18
    ciVDD_6 (VDD_146 VSS) capacitor c=1.07074e-18
    ciVDD_5 (VDD_149 VSS) capacitor c=2.18215e-17
    ciVDD_4 (VDD_150 VSS) capacitor c=2.16736e-16
    ciVDD_3 (VDD_153 VSS) capacitor c=2.10889e-17
    ciVDD_2 (VDD_164 VSS) capacitor c=1.25557e-17
    ciVDD_1 (VDD_177 VSS) capacitor c=8.99169e-17
    ciVDD_0 (VDD_179 VSS) capacitor c=7.91131e-17
    ciVSS_31 (VSS_4 VSS) capacitor c=6.09405e-17
    ciVSS_30 (VSS_10 VSS) capacitor c=6.97876e-17
    ciVSS_29 (VSS_11 VSS) capacitor c=2.63453e-17
    ciVSS_28 (VSS_17 VSS) capacitor c=1.0194e-16
    ciVSS_27 (VSS_23 VSS) capacitor c=4.57384e-16
    ciVSS_26 (VSS_42 VSS) capacitor c=7.06933e-17
    ciVSS_25 (VSS_43 VSS) capacitor c=7.17618e-17
    ciVSS_24 (VSS_45 VSS) capacitor c=4.68455e-17
    ciVSS_23 (VSS_52 VSS) capacitor c=7.267e-17
    ciVSS_22 (VSS_53 VSS) capacitor c=1.15679e-16
    ciVSS_21 (VSS_60 VSS) capacitor c=7.5624e-17
    ciVSS_20 (VSS_68 VSS) capacitor c=7.90598e-18
    ciVSS_19 (VSS_70 VSS) capacitor c=3.58509e-18
    ciVSS_18 (VSS_71 VSS) capacitor c=3.58509e-18
    ciVSS_17 (VSS_73 VSS) capacitor c=3.28682e-18
    ciVSS_16 (VSS_75 VSS) capacitor c=1.82623e-18
    ciVSS_15 (VSS_76 VSS) capacitor c=2.45965e-18
    ciVSS_14 (VSS_77 VSS) capacitor c=1.93794e-18
    ciVSS_13 (VSS_80 VSS) capacitor c=2.83254e-18
    ciVSS_12 (VSS_82 VSS) capacitor c=1.9009e-18
    ciVSS_11 (VSS_83 VSS) capacitor c=1.41393e-18
    ciVSS_10 (VSS_84 VSS) capacitor c=6.31794e-18
    ciVSS_9 (VSS_89 VSS) capacitor c=5.32905e-18
    ciVSS_8 (MM2_ELT_s VSS) capacitor c=6.57974e-18
    ciVSS_7 (VSS_95 VSS) capacitor c=2.70432e-18
    ciVSS_6 (VSS_96 VSS) capacitor c=4.19145e-18
    ciVSS_5 (MM3_ELT_s VSS) capacitor c=5.533e-18
    ciVSS_4 (VSS_103 VSS) capacitor c=2.26158e-18
    ciVSS_3 (VSS_108 VSS) capacitor c=6.92189e-18
    ciVSS_2 (VSS_112 VSS) capacitor c=6.23788e-18
    ciVSS_1 (VSS_113 VSS) capacitor c=6.9763e-17
    ciVSS_0 (VSS_114 VSS) capacitor c=7.92472e-17
    cinet032_5 (net032_3 VSS) capacitor c=1.66145e-16
    cinet032_4 (net032_4 VSS) capacitor c=3.3306e-16
    cinet032_3 (net032_12 VSS) capacitor c=1.25629e-16
    cinet032_2 (net032_13 VSS) capacitor c=1.76586e-17
    cinet032_1 (net032_16 VSS) capacitor c=1.72879e-16
    cinet032_0 (net032_17 VSS) capacitor c=3.38319e-16
    cinet035_5 (net035_3 VSS) capacitor c=6.35813e-17
    cinet035_4 (net035_4 VSS) capacitor c=1.09556e-16
    cinet035_3 (net035_6 VSS) capacitor c=2.64642e-16
    cinet035_2 (net035_7 VSS) capacitor c=1.24428e-17
    cinet035_1 (net035_10 VSS) capacitor c=5.85461e-17
    cinet035_0 (net035_11 VSS) capacitor c=1.13472e-16
    ciY_24 (Y_22 VSS) capacitor c=3.3054e-18
    ciY_23 (Y_28 VSS) capacitor c=2.00577e-16
    ciY_22 (Y_39 VSS) capacitor c=6.16218e-16
    ciY_21 (Y_45 VSS) capacitor c=6.9891e-18
    ciY_20 (Y_50 VSS) capacitor c=2.25086e-17
    ciY_19 (Y_58 VSS) capacitor c=1.95119e-17
    ciY_18 (Y_66 VSS) capacitor c=1.09991e-17
    ciY_17 (Y_74 VSS) capacitor c=2.12292e-17
    ciY_16 (Y_82 VSS) capacitor c=3.00043e-18
    ciY_15 (Y_85 VSS) capacitor c=4.00952e-18
    ciY_14 (Y_90 VSS) capacitor c=5.25444e-18
    ciY_13 (Y_93 VSS) capacitor c=3.85496e-18
    ciY_12 (Y_133 VSS) capacitor c=1.68614e-16
    ciY_11 (Y_134 VSS) capacitor c=3.33957e-16
    ciY_10 (Y_142 VSS) capacitor c=1.38588e-16
    ciY_9 (Y_143 VSS) capacitor c=2.34363e-17
    ciY_8 (Y_144 VSS) capacitor c=3.27911e-17
    ciY_7 (Y_145 VSS) capacitor c=2.19836e-17
    ciY_6 (Y_148 VSS) capacitor c=1.51369e-16
    ciY_5 (Y_151 VSS) capacitor c=1.51648e-17
    ciY_4 (Y_153 VSS) capacitor c=7.06646e-17
    ciY_3 (Y_154 VSS) capacitor c=9.70077e-17
    ciY_2 (Y_159 VSS) capacitor c=3.49366e-17
    ciY_1 (Y_227 VSS) capacitor c=4.21542e-17
    ciY_0 (Y_229 VSS) capacitor c=1.08977e-16
    cinet031_12 (net031_3 VSS) capacitor c=1.78176e-16
    cinet031_11 (net031_4 VSS) capacitor c=3.25172e-16
    cinet031_10 (net031_12 VSS) capacitor c=1.48713e-16
    cinet031_9 (net031_13 VSS) capacitor c=1.32791e-17
    cinet031_8 (net031_18 VSS) capacitor c=1.55584e-16
    cinet031_7 (net031_25 VSS) capacitor c=2.68252e-16
    cinet031_6 (net031_27 VSS) capacitor c=3.96975e-17
    cinet031_5 (MM20_ELT_s VSS) capacitor c=2.43707e-17
    cinet031_4 (net031_29 VSS) capacitor c=2.60412e-18
    cinet031_3 (net031_30 VSS) capacitor c=7.20752e-18
    cinet031_2 (net031_31 VSS) capacitor c=3.56699e-18
    cinet031_1 (net031_32 VSS) capacitor c=3.4908e-18
    cinet031_0 (net031_33 VSS) capacitor c=5.8371e-18
    ciCDN_36 (CDN_42 VSS) capacitor c=3.5405e-18
    ciCDN_35 (CDN_45 VSS) capacitor c=2.97314e-18
    ciCDN_34 (CDN_48 VSS) capacitor c=2.21976e-16
    ciCDN_33 (CDN_50 VSS) capacitor c=1.59041e-17
    ciCDN_32 (CDN_58 VSS) capacitor c=2.19451e-17
    ciCDN_31 (CDN_75 VSS) capacitor c=4.15066e-18
    ciCDN_30 (CDN_80 VSS) capacitor c=8.95667e-18
    ciCDN_29 (CDN_83 VSS) capacitor c=5.1954e-18
    ciCDN_28 (CDN_86 VSS) capacitor c=1.91784e-16
    ciCDN_27 (CDN_88 VSS) capacitor c=2.05848e-18
    ciCDN_26 (CDN_91 VSS) capacitor c=3.85496e-18
    ciCDN_25 (CDN_94 VSS) capacitor c=2.54003e-16
    ciCDN_24 (CDN_96 VSS) capacitor c=2.83705e-17
    ciCDN_23 (CDN_104 VSS) capacitor c=1.63434e-17
    ciCDN_22 (CDN_112 VSS) capacitor c=1.55882e-17
    ciCDN_21 (CDN_120 VSS) capacitor c=2.59722e-17
    ciCDN_20 (CDN_128 VSS) capacitor c=4.08613e-18
    ciCDN_19 (CDN_151 VSS) capacitor c=3.63767e-18
    ciCDN_18 (CDN_156 VSS) capacitor c=5.03014e-18
    ciCDN_17 (CDN_162 VSS) capacitor c=1.89923e-16
    ciCDN_16 (CDN_170 VSS) capacitor c=2.54543e-17
    ciCDN_15 (CDN_178 VSS) capacitor c=2.17293e-17
    ciCDN_14 (CDN_186 VSS) capacitor c=5.44995e-18
    ciCDN_13 (CDN_189 VSS) capacitor c=7.69567e-18
    ciCDN_12 (CDN_261 VSS) capacitor c=6.78054e-17
    ciCDN_11 (CDN_269 VSS) capacitor c=1.30923e-16
    ciCDN_10 (CDN_270 VSS) capacitor c=1.84312e-16
    ciCDN_9 (CDN_271 VSS) capacitor c=2.34947e-17
    ciCDN_8 (CDN_276 VSS) capacitor c=9.67589e-18
    ciCDN_7 (CDN_277 VSS) capacitor c=1.34897e-17
    ciCDN_6 (CDN_279 VSS) capacitor c=6.89254e-17
    ciCDN_5 (CDN_396 VSS) capacitor c=2.52968e-17
    ciCDN_4 (CDN_397 VSS) capacitor c=1.91208e-17
    ciCDN_3 (CDN_406 VSS) capacitor c=8.96961e-18
    ciCDN_2 (CDN_407 VSS) capacitor c=2.08114e-17
    ciCDN_1 (CDN_408 VSS) capacitor c=2.71352e-17
    ciCDN_0 (CDN_413 VSS) capacitor c=5.93962e-17
    cinet033_5 (net033_3 VSS) capacitor c=5.63638e-17
    cinet033_4 (net033_4 VSS) capacitor c=1.12162e-16
    cinet033_3 (net033_6 VSS) capacitor c=2.18456e-16
    cinet033_2 (net033_7 VSS) capacitor c=1.80507e-17
    cinet033_1 (net033_10 VSS) capacitor c=5.68841e-17
    cinet033_0 (net033_11 VSS) capacitor c=1.11893e-16
    ciU_45 (U_22 VSS) capacitor c=4.28147e-18
    ciU_44 (U_28 VSS) capacitor c=1.88315e-16
    ciU_43 (U_39 VSS) capacitor c=5.68675e-16
    ciU_42 (U_45 VSS) capacitor c=5.13601e-18
    ciU_41 (U_50 VSS) capacitor c=2.23559e-17
    ciU_40 (U_58 VSS) capacitor c=1.51948e-17
    ciU_39 (U_66 VSS) capacitor c=1.91248e-17
    ciU_38 (U_74 VSS) capacitor c=9.56216e-18
    ciU_37 (U_82 VSS) capacitor c=2.11871e-18
    ciU_36 (U_85 VSS) capacitor c=2.742e-18
    ciU_35 (U_90 VSS) capacitor c=2.43312e-19
    ciU_34 (U_93 VSS) capacitor c=2.22299e-18
    ciU_33 (U_133 VSS) capacitor c=4.56403e-17
    ciU_32 (U_139 VSS) capacitor c=1.29058e-16
    ciU_31 (U_144 VSS) capacitor c=1.64875e-17
    ciU_30 (U_145 VSS) capacitor c=6.59412e-18
    ciU_29 (U_148 VSS) capacitor c=5.1536e-18
    ciU_28 (U_150 VSS) capacitor c=4.62053e-18
    ciU_27 (U_153 VSS) capacitor c=2.13326e-17
    ciU_26 (U_155 VSS) capacitor c=1.19675e-16
    ciU_25 (U_158 VSS) capacitor c=2.42466e-17
    ciU_24 (U_159 VSS) capacitor c=7.83772e-17
    ciU_23 (U_161 VSS) capacitor c=1.42037e-16
    ciU_22 (U_162 VSS) capacitor c=1.14477e-17
    ciU_21 (U_165 VSS) capacitor c=5.65724e-17
    ciU_20 (U_166 VSS) capacitor c=4.09534e-17
    ciU_19 (U_168 VSS) capacitor c=1.39008e-17
    ciU_18 (U_170 VSS) capacitor c=1.46445e-16
    ciU_17 (U_171 VSS) capacitor c=1.60295e-17
    ciU_16 (U_175 VSS) capacitor c=3.75172e-17
    ciU_15 (U_236 VSS) capacitor c=2.38849e-17
    ciU_14 (U_237 VSS) capacitor c=1.65685e-17
    ciU_13 (U_245 VSS) capacitor c=4.94954e-19
    ciU_12 (U_246 VSS) capacitor c=1.4062e-18
    ciU_11 (U_247 VSS) capacitor c=4.56234e-18
    ciU_10 (U_248 VSS) capacitor c=1.21034e-18
    ciU_9 (U_249 VSS) capacitor c=4.92287e-18
    ciU_8 (U_252 VSS) capacitor c=5.34056e-18
    ciU_7 (U_253 VSS) capacitor c=6.64882e-17
    ciU_6 (MM5_ELT_d VSS) capacitor c=2.38417e-17
    ciU_5 (U_256 VSS) capacitor c=2.32894e-18
    ciU_4 (U_258 VSS) capacitor c=4.99436e-18
    ciU_3 (U_260 VSS) capacitor c=5.45881e-18
    ciU_2 (U_269 VSS) capacitor c=1.17451e-16
    ciU_1 (U_276 VSS) capacitor c=2.35587e-16
    ciU_0 (U VSS) capacitor c=4.10011e-17
    cinet037_10 (net037_3 VSS) capacitor c=1.15938e-16
    cinet037_9 (net037_9 VSS) capacitor c=8.40105e-18
    cinet037_8 (net037_11 VSS) capacitor c=1.9009e-18
    cinet037_7 (net037_12 VSS) capacitor c=4.55538e-18
    cinet037_6 (net037_13 VSS) capacitor c=3.81689e-18
    cinet037_5 (net037_14 VSS) capacitor c=1.97184e-18
    cinet037_4 (MM24_ELT_d VSS) capacitor c=4.64626e-18
    cinet037_3 (net037_16 VSS) capacitor c=1.4757e-18
    cinet037_2 (net037_18 VSS) capacitor c=5.92123e-18
    cinet037_1 (net037_23 VSS) capacitor c=2.15678e-18
    cinet037_0 (net037 VSS) capacitor c=1.19562e-16
    ciX_25 (X_15 VSS) capacitor c=6.06786e-16
    ciX_24 (X_21 VSS) capacitor c=4.15066e-18
    ciX_23 (X_26 VSS) capacitor c=2.10331e-17
    ciX_22 (X_34 VSS) capacitor c=1.51948e-17
    ciX_21 (X_42 VSS) capacitor c=7.85641e-18
    ciX_20 (X_45 VSS) capacitor c=3.85496e-18
    ciX_19 (X_67 VSS) capacitor c=4.23769e-17
    ciX_18 (X_68 VSS) capacitor c=4.61365e-17
    ciX_17 (X_69 VSS) capacitor c=1.38306e-17
    ciX_16 (X_74 VSS) capacitor c=2.3973e-17
    ciX_15 (X_77 VSS) capacitor c=4.86881e-17
    ciX_14 (X_78 VSS) capacitor c=1.1375e-16
    ciX_13 (X_82 VSS) capacitor c=1.22668e-16
    ciX_12 (X_85 VSS) capacitor c=3.41329e-17
    ciX_11 (X_89 VSS) capacitor c=2.82866e-17
    ciX_10 (X_92 VSS) capacitor c=9.95463e-17
    ciX_9 (X_93 VSS) capacitor c=9.29032e-18
    ciX_8 (X_94 VSS) capacitor c=1.3864e-17
    ciX_7 (X_95 VSS) capacitor c=6.73708e-18
    ciX_6 (X_96 VSS) capacitor c=1.46314e-17
    ciX_5 (X_99 VSS) capacitor c=1.67447e-17
    ciX_4 (X_100 VSS) capacitor c=5.85172e-17
    ciX_3 (X_105 VSS) capacitor c=1.74668e-17
    ciX_2 (X_106 VSS) capacitor c=7.77645e-17
    ciX_1 (X_134 VSS) capacitor c=4.22059e-17
    ciX_0 (X_152 VSS) capacitor c=1.22668e-16
    ciD_14 (D_22 VSS) capacitor c=4.24577e-18
    ciD_13 (D_28 VSS) capacitor c=2.03391e-16
    ciD_12 (D_39 VSS) capacitor c=2.34552e-16
    ciD_11 (D_45 VSS) capacitor c=3.53953e-18
    ciD_10 (D_50 VSS) capacitor c=2.79853e-17
    ciD_9 (D_58 VSS) capacitor c=1.59328e-17
    ciD_8 (D_66 VSS) capacitor c=1.55399e-17
    ciD_7 (D_74 VSS) capacitor c=2.70833e-17
    ciD_6 (D_82 VSS) capacitor c=7.1697e-18
    ciD_5 (D_85 VSS) capacitor c=1.84089e-18
    ciD_4 (D_90 VSS) capacitor c=3.1332e-18
    ciD_3 (D_93 VSS) capacitor c=5.67168e-18
    ciD_2 (D_132 VSS) capacitor c=5.36467e-17
    ciD_1 (D_194 VSS) capacitor c=3.75824e-17
    ciD_0 (D_195 VSS) capacitor c=9.04118e-18
    ciCPN_48 (CPN_42 VSS) capacitor c=8.42816e-18
    ciCPN_47 (CPN_45 VSS) capacitor c=8.00794e-18
    ciCPN_46 (CPN_48 VSS) capacitor c=2.02823e-16
    ciCPN_45 (CPN_50 VSS) capacitor c=3.20049e-17
    ciCPN_44 (CPN_58 VSS) capacitor c=2.44308e-17
    ciCPN_43 (CPN_66 VSS) capacitor c=1.07785e-17
    ciCPN_42 (CPN_80 VSS) capacitor c=2.95159e-17
    ciCPN_41 (CPN_83 VSS) capacitor c=5.19694e-18
    ciCPN_40 (CPN_86 VSS) capacitor c=5.9921e-16
    ciCPN_39 (CPN_88 VSS) capacitor c=2.09965e-17
    ciCPN_38 (CPN_96 VSS) capacitor c=1.81836e-17
    ciCPN_37 (CPN_113 VSS) capacitor c=3.23494e-18
    ciCPN_36 (CPN_118 VSS) capacitor c=3.882e-18
    ciCPN_35 (CPN_124 VSS) capacitor c=2.18835e-16
    ciCPN_34 (CPN_135 VSS) capacitor c=5.84707e-16
    ciCPN_33 (CPN_141 VSS) capacitor c=2.98953e-18
    ciCPN_32 (CPN_146 VSS) capacitor c=2.19916e-17
    ciCPN_31 (CPN_154 VSS) capacitor c=2.5504e-17
    ciCPN_30 (CPN_162 VSS) capacitor c=2.38153e-17
    ciCPN_29 (CPN_170 VSS) capacitor c=2.20096e-17
    ciCPN_28 (CPN_178 VSS) capacitor c=2.96703e-18
    ciCPN_27 (CPN_181 VSS) capacitor c=7.83349e-18
    ciCPN_26 (CPN_186 VSS) capacitor c=4.22922e-18
    ciCPN_25 (CPN_189 VSS) capacitor c=6.9891e-18
    ciCPN_24 (CPN_263 VSS) capacitor c=1.67749e-16
    ciCPN_23 (CPN_264 VSS) capacitor c=3.34246e-16
    ciCPN_22 (CPN_273 VSS) capacitor c=9.14296e-17
    ciCPN_21 (CPN_277 VSS) capacitor c=2.92141e-17
    ciCPN_20 (CPN_281 VSS) capacitor c=2.28249e-17
    ciCPN_19 (CPN_285 VSS) capacitor c=3.83352e-17
    ciCPN_18 (CPN_288 VSS) capacitor c=1.64106e-16
    ciCPN_17 (CPN_289 VSS) capacitor c=1.16064e-17
    ciCPN_16 (CPN_290 VSS) capacitor c=1.26265e-17
    ciCPN_15 (CPN_293 VSS) capacitor c=8.20305e-17
    ciCPN_14 (CPN_296 VSS) capacitor c=7.21898e-17
    ciCPN_13 (CPN_297 VSS) capacitor c=1.39111e-16
    ciCPN_12 (CPN_301 VSS) capacitor c=1.94022e-17
    ciCPN_11 (CPN_304 VSS) capacitor c=9.3114e-17
    ciCPN_10 (CPN_307 VSS) capacitor c=9.40259e-17
    ciCPN_9 (CPN_310 VSS) capacitor c=5.4755e-18
    ciCPN_8 (CPN_311 VSS) capacitor c=1.35213e-17
    ciCPN_7 (CPN_312 VSS) capacitor c=3.2391e-17
    ciCPN_6 (CPN_368 VSS) capacitor c=1.89845e-17
    ciCPN_5 (CPN_429 VSS) capacitor c=1.61348e-17
    ciCPN_4 (CPN_434 VSS) capacitor c=3.79588e-17
    ciCPN_3 (CPN_435 VSS) capacitor c=7.98172e-18
    ciCPN_2 (CPN_446 VSS) capacitor c=4.39311e-17
    ciCPN_1 (CPN_449 VSS) capacitor c=1.11545e-16
    ciCPN_0 (CPN_450 VSS) capacitor c=3.68645e-17
    ciCP_14 (CP_22 VSS) capacitor c=3.00043e-18
    ciCP_13 (CP_28 VSS) capacitor c=2.11855e-16
    ciCP_12 (CP_39 VSS) capacitor c=6.43014e-16
    ciCP_11 (CP_45 VSS) capacitor c=3.44142e-18
    ciCP_10 (CP_50 VSS) capacitor c=2.58559e-17
    ciCP_9 (CP_58 VSS) capacitor c=2.05252e-17
    ciCP_8 (CP_66 VSS) capacitor c=1.20988e-17
    ciCP_7 (CP_74 VSS) capacitor c=1.51948e-17
    ciCP_6 (CP_82 VSS) capacitor c=3.24866e-18
    ciCP_5 (CP_85 VSS) capacitor c=4.90087e-18
    ciCP_4 (CP_90 VSS) capacitor c=5.17514e-18
    ciCP_3 (CP_93 VSS) capacitor c=3.35294e-18
    ciCP_2 (CP VSS) capacitor c=4.2788e-17
    ciCP_1 (CP_196 VSS) capacitor c=3.13771e-17
    ciCP_0 (CP_197 VSS) capacitor c=1.42463e-17
    rQ_28 (Q_1 Q_3) resistor r=0.303846
    rQ_27 (Q_1 Q_18) resistor r=0.0961166
    rQ_26 (Q_3 Q_4) resistor r=13
    rQ_25 (Q_4 MM4_ELT_d) resistor r=8.44
    rQ_24 (Q_6 Q_8) resistor r=0.341161
    rQ_23 (Q_6 Q_20) resistor r=0.0961166
    rQ_22 (Q_8 Q_9) resistor r=8.66667
    rQ_21 (Q_8 Q_11) resistor r=0.639676
    rQ_20 (Q_9 MM7_ELT_d) resistor r=32.3614
    rQ_19 (Q_11 Q_12) resistor r=8.66667
    rQ_18 (Q_11 Q_14) resistor r=0.426451
    rQ_17 (Q_12 MM7_ELT_d) resistor r=16.1807
    rQ_16 (Q_12 Q_15) resistor r=32.3614
    rQ_15 (Q_14 Q_15) resistor r=26
    rQ_14 (Q_17 Q_18) resistor r=0.136667
    rQ_13 (Q_17 Q_21) resistor r=0.0961166
    rQ_12 (Q_19 Q_20) resistor r=0.136667
    rQ_11 (Q_19 Q_22) resistor r=0.0961166
    rQ_10 (Q_21 Q) resistor r=0.156191
    rQ_9 (Q_22 Q) resistor r=0.5364
    rVDD_225 (MM11_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_224 (MM23_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_223 (MM9_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_222 (MM26_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_221 (MM20_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_220 (MM5_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_219 (MM8_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_218 (MM7_ELT_b MM21_ELT_b) resistor r=0.01
    rVDD_217 (MM21_ELT_b VDD_54) resistor r=8.66667
    rVDD_216 (MM21_ELT_b VDD_57) resistor r=8.66667
    rVDD_215 (MM21_ELT_b VDD_60) resistor r=8.66667
    rVDD_214 (MM21_ELT_b VDD_75) resistor r=8.66667
    rVDD_213 (MM21_ELT_b VDD_78) resistor r=26
    rVDD_212 (MM21_ELT_b VDD_52) resistor r=11.2533
    rVDD_211 (VDD_2 VDD_11) resistor r=0.490418
    rVDD_210 (VDD_2 VDD_84) resistor r=0.119218
    rVDD_209 (VDD_4 VDD_12) resistor r=8.66667
    rVDD_208 (VDD_4 VDD_8) resistor r=0.639676
    rVDD_207 (VDD_8 VDD_12) resistor r=8.66667
    rVDD_206 (VDD_8 VDD_11) resistor r=0.639676
    rVDD_205 (VDD_11 VDD_12) resistor r=8.66667
    rVDD_204 (VDD_12 MM21_ELT_s) resistor r=1.847
    rVDD_203 (VDD_12 VDD_150) resistor r=20.317
    rVDD_202 (VDD_13 VDD_16) resistor r=0.221401
    rVDD_201 (VDD_13 VDD_86) resistor r=0.0221584
    rVDD_200 (VDD_14 VDD_16) resistor r=0.0336055
    rVDD_199 (VDD_14 VDD_84) resistor r=0.0177911
    rVDD_198 (VDD_16 VDD_17) resistor r=8.66667
    rVDD_197 (VDD_17 VDD_87) resistor r=67.52
    rVDD_196 (VDD_18 VDD_30) resistor r=0.175715
    rVDD_195 (VDD_18 VDD_86) resistor r=0.0882599
    rVDD_194 (VDD_20 VDD_21) resistor r=8.66667
    rVDD_193 (VDD_20 VDD_24) resistor r=0.48477
    rVDD_192 (VDD_21 MM11_ELT_s) resistor r=2.78649
    rVDD_191 (VDD_21 VDD_177) resistor r=11.6377
    rVDD_190 (VDD_24 VDD_25) resistor r=26
    rVDD_189 (VDD_24 VDD_27) resistor r=0.824109
    rVDD_188 (VDD_25 VDD_105) resistor r=5.67797
    rVDD_187 (VDD_25 VDD_177) resistor r=3.80758
    rVDD_186 (VDD_27 VDD_28) resistor r=8.66667
    rVDD_185 (VDD_27 VDD_30) resistor r=0.48477
    rVDD_184 (VDD_28 VDD_179) resistor r=16.4995
    rVDD_183 (VDD_28 VDD_151) resistor r=16.4995
    rVDD_182 (VDD_28 MM23_ELT_s) resistor r=3.29107
    rVDD_181 (VDD_30 VDD_31) resistor r=26
    rVDD_180 (VDD_31 VDD_111) resistor r=5.67797
    rVDD_179 (VDD_31 VDD_179) resistor r=3.80758
    rVDD_178 (VDD_32 VDD_35) resistor r=0.221401
    rVDD_177 (VDD_32 VDD_89) resistor r=0.0221584
    rVDD_176 (VDD_33 VDD_35) resistor r=0.217447
    rVDD_175 (VDD_33 VDD_86) resistor r=0.0221584
    rVDD_174 (VDD_35 VDD_36) resistor r=8.66667
    rVDD_173 (VDD_36 VDD_87) resistor r=67.52
    rVDD_172 (VDD_36 VDD_90) resistor r=67.52
    rVDD_171 (VDD_37 VDD_46) resistor r=0.253811
    rVDD_170 (VDD_37 VDD_89) resistor r=0.0882599
    rVDD_169 (VDD_39 VDD_40) resistor r=8.66667
    rVDD_168 (VDD_39 VDD_43) resistor r=0.804879
    rVDD_167 (VDD_40 VDD_158) resistor r=11.4907
    rVDD_166 (VDD_40 VDD_152) resistor r=11.4907
    rVDD_165 (VDD_40 MM9_ELT_s) resistor r=1.22439
    rVDD_164 (VDD_43 VDD_47) resistor r=8.66667
    rVDD_163 (VDD_43 VDD_46) resistor r=0.536586
    rVDD_162 (VDD_46 VDD_47) resistor r=26
    rVDD_161 (VDD_47 MM26_ELT_s) resistor r=4.04518
    rVDD_160 (VDD_47 VDD_161) resistor r=4.04518
    rVDD_159 (VDD_47 MM9_ELT_s) resistor r=4.04518
    rVDD_158 (VDD_47 VDD_155) resistor r=4.04518
    rVDD_157 (VDD_48 VDD_60) resistor r=0.0950228
    rVDD_156 (VDD_48 VDD_91) resistor r=0.0221584
    rVDD_155 (VDD_49 VDD_51) resistor r=0.217447
    rVDD_154 (VDD_49 VDD_89) resistor r=0.0221584
    rVDD_153 (VDD_51 VDD_52) resistor r=8.66667
    rVDD_152 (VDD_51 VDD_54) resistor r=0.237557
    rVDD_151 (VDD_52 VDD_90) resistor r=67.52
    rVDD_150 (VDD_54 VDD_57) resistor r=0.237557
    rVDD_149 (VDD_57 VDD_60) resistor r=0.237557
    rVDD_148 (VDD_62 VDD_71) resistor r=0.538428
    rVDD_147 (VDD_62 VDD_91) resistor r=0.0882599
    rVDD_146 (VDD_64 VDD_72) resistor r=8.66667
    rVDD_145 (VDD_64 VDD_68) resistor r=0.702297
    rVDD_144 (VDD_68 VDD_72) resistor r=8.66667
    rVDD_143 (VDD_68 VDD_71) resistor r=0.468198
    rVDD_142 (VDD_71 VDD_72) resistor r=13
    rVDD_141 (VDD_72 MM7_ELT_s) resistor r=4.04518
    rVDD_140 (VDD_72 VDD_165) resistor r=4.04518
    rVDD_139 (VDD_72 MM8_ELT_s) resistor r=4.04518
    rVDD_138 (VDD_72 VDD_163) resistor r=4.04518
    rVDD_137 (VDD_73 VDD_75) resistor r=0.106747
    rVDD_136 (VDD_73 VDD_91) resistor r=0.0221584
    rVDD_135 (VDD_75 VDD_78) resistor r=0.158143
    rVDD_134 (VDD VDD_84) resistor r=0.0513966
    rVDD_133 (VDD_86 VDD_87) resistor r=8.66667
    rVDD_132 (VDD_89 VDD_90) resistor r=8.66667
    rVDD_131 (MM21_ELT_s VDD_97) resistor r=2.55965
    rVDD_130 (MM21_ELT_s VDD_99) resistor r=12.3172
    rVDD_129 (MM21_ELT_s VDD_99) resistor r=1.62887
    rVDD_128 (MM21_ELT_s VDD_102) resistor r=6.12113
    rVDD_127 (VDD_95 VDD_97) resistor r=14.4784
    rVDD_126 (VDD_95 VDD_101) resistor r=9.04062
    rVDD_125 (VDD_96 VDD_97) resistor r=14.4784
    rVDD_124 (VDD_96 VDD_150) resistor r=9.48555
    rVDD_123 (VDD_98 VDD_99) resistor r=12.3172
    rVDD_122 (VDD_98 VDD_100) resistor r=9.04595
    rVDD_121 (VDD_100 VDD_102) resistor r=31.2341
    rVDD_120 (VDD_101 VDD_102) resistor r=31.2341
    rVDD_119 (MM11_ELT_s VDD_106) resistor r=2.55965
    rVDD_118 (MM11_ELT_s VDD_114) resistor r=12.3172
    rVDD_117 (MM11_ELT_s VDD_114) resistor r=1.62887
    rVDD_116 (MM11_ELT_s VDD_117) resistor r=4.36821
    rVDD_115 (VDD_104 VDD_106) resistor r=14.4784
    rVDD_114 (VDD_104 VDD_116) resistor r=9.04062
    rVDD_113 (VDD_105 VDD_106) resistor r=14.4784
    rVDD_112 (MM23_ELT_s VDD_109) resistor r=12.3172
    rVDD_111 (MM23_ELT_s VDD_109) resistor r=1.62887
    rVDD_110 (MM23_ELT_s VDD_112) resistor r=2.55965
    rVDD_109 (MM23_ELT_s VDD_118) resistor r=17.3029
    rVDD_108 (VDD_108 VDD_109) resistor r=12.3172
    rVDD_107 (VDD_108 VDD_151) resistor r=9.39461
    rVDD_106 (VDD_110 VDD_112) resistor r=14.4784
    rVDD_105 (VDD_110 VDD_118) resistor r=9.04062
    rVDD_104 (VDD_111 VDD_112) resistor r=14.4784
    rVDD_103 (VDD_113 VDD_114) resistor r=12.3172
    rVDD_102 (VDD_113 VDD_115) resistor r=9.04595
    rVDD_101 (VDD_115 VDD_117) resistor r=20.2547
    rVDD_100 (VDD_116 VDD_117) resistor r=20.2547
    rVDD_99 (MM9_ELT_s VDD_120) resistor r=25.7298
    rVDD_98 (MM9_ELT_s VDD_123) resistor r=2.55965
    rVDD_97 (MM9_ELT_s VDD_125) resistor r=12.3172
    rVDD_96 (MM9_ELT_s VDD_125) resistor r=1.62887
    rVDD_95 (MM9_ELT_s VDD_128) resistor r=2.36478
    rVDD_94 (MM9_ELT_s VDD_153) resistor r=3.7149
    rVDD_93 (MM9_ELT_s VDD_155) resistor r=13.4839
    rVDD_92 (VDD_120 VDD_122) resistor r=9.04062
    rVDD_91 (VDD_121 VDD_123) resistor r=14.4784
    rVDD_90 (VDD_121 VDD_162) resistor r=10.5593
    rVDD_89 (VDD_122 VDD_123) resistor r=14.4784
    rVDD_88 (VDD_124 VDD_125) resistor r=12.3172
    rVDD_87 (VDD_124 VDD_126) resistor r=9.45545
    rVDD_86 (VDD_126 VDD_128) resistor r=6.18629
    rVDD_85 (VDD_127 VDD_128) resistor r=6.18629
    rVDD_84 (VDD_127 VDD_153) resistor r=4.87148
    rVDD_83 (MM26_ELT_s VDD_132) resistor r=2.55965
    rVDD_82 (MM26_ELT_s VDD_133) resistor r=17.3029
    rVDD_81 (MM26_ELT_s VDD_158) resistor r=20.2259
    rVDD_80 (VDD_130 VDD_132) resistor r=14.4784
    rVDD_79 (VDD_130 VDD_133) resistor r=9.04062
    rVDD_78 (VDD_131 VDD_132) resistor r=14.4784
    rVDD_77 (VDD_131 VDD_162) resistor r=10.5593
    rVDD_76 (MM8_ELT_s VDD_135) resistor r=25.7298
    rVDD_75 (MM8_ELT_s VDD_138) resistor r=2.55965
    rVDD_74 (MM8_ELT_s VDD_140) resistor r=12.3172
    rVDD_73 (MM8_ELT_s VDD_140) resistor r=1.62887
    rVDD_72 (VDD_135 VDD_137) resistor r=9.04062
    rVDD_71 (VDD_136 VDD_138) resistor r=14.4784
    rVDD_70 (VDD_136 VDD_166) resistor r=10.5593
    rVDD_69 (VDD_137 VDD_138) resistor r=14.4784
    rVDD_68 (VDD_139 VDD_140) resistor r=12.3172
    rVDD_67 (VDD_139 VDD_164) resistor r=10.2363
    rVDD_66 (MM7_ELT_s VDD_144) resistor r=2.55965
    rVDD_65 (MM7_ELT_s VDD_146) resistor r=11.6604
    rVDD_64 (MM7_ELT_s VDD_146) resistor r=1.30988
    rVDD_63 (MM7_ELT_s VDD_149) resistor r=6.12113
    rVDD_62 (MM7_ELT_s VDD_164) resistor r=10.2363
    rVDD_61 (VDD_142 VDD_144) resistor r=14.4784
    rVDD_60 (VDD_142 VDD_148) resistor r=9.04062
    rVDD_59 (VDD_143 VDD_144) resistor r=14.4784
    rVDD_58 (VDD_143 VDD_166) resistor r=10.5593
    rVDD_57 (VDD_145 VDD_146) resistor r=11.6604
    rVDD_56 (VDD_145 VDD_147) resistor r=9.04595
    rVDD_55 (VDD_147 VDD_149) resistor r=31.2341
    rVDD_54 (VDD_148 VDD_149) resistor r=31.2341
    rVDD_53 (VDD_152 VDD_153) resistor r=4.87148
    rVDD_52 (VDD_155 VDD_158) resistor r=10.7871
    rVDD_51 (VDD_161 VDD_162) resistor r=0.730683
    rVDD_50 (VDD_163 VDD_164) resistor r=0.549089
    rVDD_49 (VDD_165 VDD_166) resistor r=0.730683
    rVSS_159 (MM1_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_158 (MM10_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_157 (MM24_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_156 (MM18_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_155 (MM2_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_154 (MM3_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_153 (MM4_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_152 (MM22_ELT_b VSS_35) resistor r=8.66667
    rVSS_151 (MM22_ELT_b VSS_38) resistor r=8.66667
    rVSS_150 (MM22_ELT_b VSS_48) resistor r=8.66667
    rVSS_149 (MM22_ELT_b VSS_57) resistor r=8.66667
    rVSS_148 (MM22_ELT_b VSS_60) resistor r=26
    rVSS_147 (MM22_ELT_b VSS_33) resistor r=10.7871
    rVSS_146 (VSS_2 VSS_4) resistor r=0.399797
    rVSS_145 (VSS_2 VSS_66) resistor r=0.119218
    rVSS_144 (VSS_4 VSS_8) resistor r=8.66667
    rVSS_143 (VSS_4 VSS_7) resistor r=0.426451
    rVSS_142 (VSS_7 VSS_8) resistor r=26
    rVSS_141 (VSS_8 MM22_ELT_s) resistor r=2.90692
    rVSS_140 (VSS_8 VSS_113) resistor r=12.1406
    rVSS_139 (VSS_10 VSS_13) resistor r=0.221401
    rVSS_138 (VSS_10 VSS_68) resistor r=0.0221584
    rVSS_137 (VSS_11 VSS_13) resistor r=0.0336055
    rVSS_136 (VSS_11 VSS_66) resistor r=0.0177911
    rVSS_135 (VSS_13 VSS_14) resistor r=8.66667
    rVSS_134 (VSS_14 VSS_69) resistor r=64.7228
    rVSS_133 (VSS_15 VSS_17) resistor r=0.405128
    rVSS_132 (VSS_15 VSS_68) resistor r=0.0882599
    rVSS_131 (VSS_17 VSS_21) resistor r=8.66667
    rVSS_130 (VSS_17 VSS_20) resistor r=0.436083
    rVSS_129 (VSS_20 VSS_21) resistor r=26
    rVSS_128 (VSS_21 MM1_ELT_s) resistor r=2.90692
    rVSS_127 (VSS_21 VSS_114) resistor r=12.1406
    rVSS_126 (VSS_23 VSS_38) resistor r=0.0395359
    rVSS_125 (VSS_23 VSS_70) resistor r=0.0221584
    rVSS_124 (VSS_24 VSS_26) resistor r=0.217761
    rVSS_123 (VSS_24 VSS_68) resistor r=0.0221584
    rVSS_122 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_121 (VSS_26 VSS_29) resistor r=0.237557
    rVSS_120 (VSS_27 VSS_69) resistor r=64.7228
    rVSS_119 (VSS_27 VSS_30) resistor r=64.7228
    rVSS_118 (VSS_29 VSS_30) resistor r=8.66667
    rVSS_117 (VSS_29 VSS_32) resistor r=0.237557
    rVSS_116 (VSS_30 VSS_33) resistor r=64.7228
    rVSS_115 (VSS_32 VSS_33) resistor r=8.66667
    rVSS_114 (VSS_32 VSS_35) resistor r=0.237557
    rVSS_113 (VSS_35 VSS_38) resistor r=0.237215
    rVSS_112 (VSS_40 VSS_42) resistor r=0.454472
    rVSS_111 (VSS_40 VSS_70) resistor r=0.0882599
    rVSS_110 (VSS_42 VSS_43) resistor r=8.66667
    rVSS_109 (VSS_43 VSS_116) resistor r=16.9307
    rVSS_108 (VSS_43 VSS_115) resistor r=16.9307
    rVSS_107 (VSS_43 MM2_ELT_s) resistor r=3.33844
    rVSS_106 (VSS_45 VSS_48) resistor r=0.0948861
    rVSS_105 (VSS_45 VSS_71) resistor r=0.0221584
    rVSS_104 (VSS_46 VSS_48) resistor r=0.162097
    rVSS_103 (VSS_46 VSS_70) resistor r=0.0221584
    rVSS_102 (VSS_50 VSS_52) resistor r=0.438936
    rVSS_101 (VSS_50 VSS_71) resistor r=0.0882599
    rVSS_100 (VSS_52 VSS_53) resistor r=8.66667
    rVSS_99 (VSS_53 MM4_ELT_s) resistor r=4.22001
    rVSS_98 (VSS_53 VSS_119) resistor r=4.22001
    rVSS_97 (VSS_53 MM3_ELT_s) resistor r=4.22001
    rVSS_96 (VSS_53 VSS_117) resistor r=4.22001
    rVSS_95 (VSS_55 VSS_57) resistor r=0.106747
    rVSS_94 (VSS_55 VSS_71) resistor r=0.0221584
    rVSS_93 (VSS_57 VSS_60) resistor r=0.158143
    rVSS_92 (VSS VSS_66) resistor r=0.0494198
    rVSS_91 (VSS_68 VSS_69) resistor r=8.66667
    rVSS_90 (MM22_ELT_s VSS_75) resistor r=2.67027
    rVSS_89 (MM22_ELT_s VSS_77) resistor r=12.8495
    rVSS_88 (MM22_ELT_s VSS_77) resistor r=1.69926
    rVSS_87 (MM22_ELT_s VSS_80) resistor r=4.557
    rVSS_86 (VSS_73 VSS_75) resistor r=15.1041
    rVSS_85 (VSS_73 VSS_78) resistor r=9.43134
    rVSS_84 (VSS_74 VSS_75) resistor r=15.1041
    rVSS_83 (VSS_74 VSS_113) resistor r=9.89549
    rVSS_82 (VSS_76 VSS_77) resistor r=12.8495
    rVSS_81 (VSS_76 VSS_79) resistor r=9.4369
    rVSS_80 (VSS_78 VSS_80) resistor r=21.1301
    rVSS_79 (VSS_79 VSS_80) resistor r=21.1301
    rVSS_78 (MM1_ELT_s VSS_84) resistor r=2.67027
    rVSS_77 (MM1_ELT_s VSS_86) resistor r=12.8495
    rVSS_76 (MM1_ELT_s VSS_86) resistor r=1.69926
    rVSS_75 (MM1_ELT_s VSS_89) resistor r=4.557
    rVSS_74 (VSS_82 VSS_84) resistor r=15.1041
    rVSS_73 (VSS_82 VSS_87) resistor r=9.43134
    rVSS_72 (VSS_83 VSS_84) resistor r=15.1041
    rVSS_71 (VSS_83 VSS_114) resistor r=9.89549
    rVSS_70 (VSS_85 VSS_86) resistor r=12.8495
    rVSS_69 (VSS_85 VSS_88) resistor r=9.4369
    rVSS_68 (VSS_87 VSS_89) resistor r=21.1301
    rVSS_67 (VSS_88 VSS_89) resistor r=21.1301
    rVSS_66 (MM2_ELT_s VSS_91) resistor r=18.0507
    rVSS_65 (MM2_ELT_s VSS_94) resistor r=2.67027
    rVSS_64 (MM2_ELT_s VSS_96) resistor r=12.8495
    rVSS_63 (MM2_ELT_s VSS_96) resistor r=1.69926
    rVSS_62 (VSS_91 VSS_93) resistor r=9.43134
    rVSS_61 (VSS_92 VSS_94) resistor r=15.1041
    rVSS_60 (VSS_92 VSS_115) resistor r=9.96613
    rVSS_59 (VSS_93 VSS_94) resistor r=15.1041
    rVSS_58 (VSS_95 VSS_96) resistor r=12.8495
    rVSS_57 (VSS_95 VSS_116) resistor r=9.86409
    rVSS_56 (MM3_ELT_s VSS_98) resistor r=18.0507
    rVSS_55 (MM3_ELT_s VSS_101) resistor r=2.67027
    rVSS_54 (MM3_ELT_s VSS_103) resistor r=12.8495
    rVSS_53 (MM3_ELT_s VSS_103) resistor r=1.69926
    rVSS_52 (VSS_98 VSS_100) resistor r=9.43134
    rVSS_51 (VSS_99 VSS_101) resistor r=15.1041
    rVSS_50 (VSS_99 VSS_118) resistor r=11.0157
    rVSS_49 (VSS_100 VSS_101) resistor r=15.1041
    rVSS_48 (VSS_102 VSS_103) resistor r=12.8495
    rVSS_47 (VSS_102 VSS_120) resistor r=10.6787
    rVSS_46 (MM4_ELT_s VSS_107) resistor r=2.67027
    rVSS_45 (MM4_ELT_s VSS_109) resistor r=12.1643
    rVSS_44 (MM4_ELT_s VSS_109) resistor r=1.36649
    rVSS_43 (MM4_ELT_s VSS_112) resistor r=4.557
    rVSS_42 (MM4_ELT_s VSS_120) resistor r=10.6787
    rVSS_41 (VSS_105 VSS_107) resistor r=15.1041
    rVSS_40 (VSS_105 VSS_110) resistor r=9.43134
    rVSS_39 (VSS_106 VSS_107) resistor r=15.1041
    rVSS_38 (VSS_106 VSS_118) resistor r=11.0157
    rVSS_37 (VSS_108 VSS_109) resistor r=12.1643
    rVSS_36 (VSS_108 VSS_111) resistor r=9.4369
    rVSS_35 (VSS_110 VSS_112) resistor r=21.1301
    rVSS_34 (VSS_111 VSS_112) resistor r=21.1301
    rVSS_33 (VSS_117 VSS_118) resistor r=0.762262
    rVSS_32 (VSS_119 VSS_120) resistor r=0.57282
    rnet032_27 (MM8_ELT_d net032) resistor r=0.01
    rnet032_26 (net032_1 net032_10) resistor r=0.226631
    rnet032_25 (net032_1 net032_13) resistor r=0.0961166
    rnet032_24 (net032_3 net032_4) resistor r=8.66667
    rnet032_23 (net032_3 net032_7) resistor r=0.639676
    rnet032_22 (net032_4 MM5_ELT_s) resistor r=32.3614
    rnet032_21 (net032_7 net032_8) resistor r=8.66667
    rnet032_20 (net032_7 net032_10) resistor r=0.431679
    rnet032_19 (net032_8 MM5_ELT_s) resistor r=16.1807
    rnet032_18 (net032_8 net032_11) resistor r=32.3614
    rnet032_17 (net032_10 net032_11) resistor r=26
    rnet032_16 (net032_12 net032_13) resistor r=0.949246
    rnet032_15 (net032_12 net032_14) resistor r=0.0961166
    rnet032_14 (net032_14 net032_23) resistor r=0.223887
    rnet032_13 (net032_16 net032_17) resistor r=8.66667
    rnet032_12 (net032_16 net032_20) resistor r=0.639676
    rnet032_11 (net032_17 net032) resistor r=32.3614
    rnet032_10 (net032_20 net032_21) resistor r=8.66667
    rnet032_9 (net032_20 net032_23) resistor r=0.426451
    rnet032_8 (net032_21 net032) resistor r=16.1807
    rnet032_7 (net032_21 net032_24) resistor r=32.3614
    rnet032_6 (net032_23 net032_24) resistor r=26
    rnet035_15 (MM3_ELT_d net035) resistor r=0.01
    rnet035_14 (net035_1 net035_3) resistor r=0.405128
    rnet035_13 (net035_1 net035_7) resistor r=0.0961166
    rnet035_12 (net035_3 net035_4) resistor r=13
    rnet035_11 (net035_4 MM18_ELT_s) resistor r=8.44
    rnet035_10 (net035_6 net035_7) resistor r=2.23065
    rnet035_9 (net035_6 net035_8) resistor r=0.0961166
    rnet035_8 (net035_8 net035_10) resistor r=0.405128
    rnet035_7 (net035_10 net035_11) resistor r=13
    rnet035_6 (net035_11 net035) resistor r=8.44
    rY_127 (MM20_ELT_d Y) resistor r=0.01
    rY_126 (Y_22 Y_28) resistor r=58.3583
    rY_125 (Y_22 Y_28) resistor r=4.16253
    rY_124 (Y_22 Y_28) resistor r=58.3583
    rY_123 (Y_22 Y_28) resistor r=4.16253
    rY_122 (Y_25 Y_28) resistor r=58.3583
    rY_121 (Y_25 Y_28) resistor r=6.30933
    rY_120 (Y_25 Y_28) resistor r=58.3583
    rY_119 (Y_25 Y_28) resistor r=6.30933
    rY_118 (Y_28 Y_30) resistor r=14.9
    rY_117 (Y_28 Y_53) resistor r=24.8333
    rY_116 (Y_28 Y_50) resistor r=24.8333
    rY_115 (Y_28 Y_61) resistor r=24.8333
    rY_114 (Y_28 Y_58) resistor r=24.8333
    rY_113 (Y_28 Y_82) resistor r=58.3583
    rY_112 (Y_28 Y_85) resistor r=58.3583
    rY_111 (Y_28 Y_53) resistor r=4.16253
    rY_110 (Y_28 Y_30) resistor r=6.30933
    rY_109 (Y_28 Y_61) resistor r=1.63969
    rY_108 (Y_28 Y_50) resistor r=4.16253
    rY_107 (Y_28 Y_82) resistor r=4.16253
    rY_106 (Y_28 Y_58) resistor r=4.16253
    rY_105 (Y_28 Y_85) resistor r=4.16253
    rY_104 (Y_28 Y_30) resistor r=14.9
    rY_103 (Y_28 Y_185) resistor r=39.7333
    rY_102 (Y_28 Y_53) resistor r=24.8333
    rY_101 (Y_28 Y_50) resistor r=24.8333
    rY_100 (Y_28 Y_61) resistor r=24.8333
    rY_99 (Y_28 Y_58) resistor r=24.8333
    rY_98 (Y_28 Y_82) resistor r=58.3583
    rY_97 (Y_28 MM3_ELT_g) resistor r=7.45
    rY_96 (Y_28 Y_53) resistor r=4.16253
    rY_95 (Y_28 Y_30) resistor r=6.30933
    rY_94 (Y_28 Y_61) resistor r=1.63969
    rY_93 (Y_28 Y_50) resistor r=4.16253
    rY_92 (Y_28 Y_82) resistor r=4.16253
    rY_91 (Y_28 Y_58) resistor r=4.16253
    rY_90 (Y_28 Y_85) resistor r=4.16253
    rY_89 (Y_36 Y_39) resistor r=14.9
    rY_88 (Y_36 Y_39) resistor r=6.30933
    rY_87 (Y_36 Y_39) resistor r=14.9
    rY_86 (Y_36 Y_39) resistor r=6.30933
    rY_85 (Y_39 Y_42) resistor r=202.392
    rY_84 (Y_39 Y_45) resistor r=202.392
    rY_83 (Y_39 Y_69) resistor r=24.8333
    rY_82 (Y_39 Y_66) resistor r=24.8333
    rY_81 (Y_39 Y_77) resistor r=24.8333
    rY_80 (Y_39 Y_74) resistor r=24.8333
    rY_79 (Y_39 Y_90) resistor r=202.392
    rY_78 (Y_39 Y_93) resistor r=202.392
    rY_77 (Y_39 Y_42) resistor r=6.30933
    rY_76 (Y_39 Y_69) resistor r=1.63969
    rY_75 (Y_39 Y_77) resistor r=4.16253
    rY_74 (Y_39 Y_45) resistor r=4.16253
    rY_73 (Y_39 Y_66) resistor r=4.16253
    rY_72 (Y_39 Y_90) resistor r=4.16253
    rY_71 (Y_39 Y_74) resistor r=4.16253
    rY_70 (Y_39 Y_93) resistor r=4.16253
    rY_69 (Y_39 Y_187) resistor r=42.2167
    rY_68 (Y_39 Y_42) resistor r=202.392
    rY_67 (Y_39 Y_45) resistor r=202.392
    rY_66 (Y_39 Y_69) resistor r=24.8333
    rY_65 (Y_39 Y_66) resistor r=24.8333
    rY_64 (Y_39 Y_77) resistor r=24.8333
    rY_63 (Y_39 Y_74) resistor r=24.8333
    rY_62 (Y_39 Y_90) resistor r=202.392
    rY_61 (Y_39 MM8_ELT_g) resistor r=7.45
    rY_60 (Y_39 Y_42) resistor r=6.30933
    rY_59 (Y_39 Y_69) resistor r=1.63969
    rY_58 (Y_39 Y_77) resistor r=4.16253
    rY_57 (Y_39 Y_45) resistor r=4.16253
    rY_56 (Y_39 Y_66) resistor r=4.16253
    rY_55 (Y_39 Y_90) resistor r=4.16253
    rY_54 (Y_39 Y_74) resistor r=4.16253
    rY_53 (Y_39 Y_93) resistor r=4.16253
    rY_52 (Y_85 MM3_ELT_g) resistor r=50.9083
    rY_51 (Y_93 MM8_ELT_g) resistor r=194.942
    rY_50 (Y_131 Y_133) resistor r=0.442443
    rY_49 (Y_131 Y_143) resistor r=0.0963616
    rY_48 (Y_133 Y_134) resistor r=8.66667
    rY_47 (Y_133 Y_136) resistor r=0.639676
    rY_46 (Y_134 Y) resistor r=32.3614
    rY_45 (Y_136 Y_137) resistor r=8.66667
    rY_44 (Y_136 Y_139) resistor r=0.426451
    rY_43 (Y_137 Y) resistor r=16.1807
    rY_42 (Y_137 Y_140) resistor r=32.3614
    rY_41 (Y_139 Y_140) resistor r=26
    rY_40 (Y_142 Y_143) resistor r=0.63998
    rY_39 (Y_142 Y_145) resistor r=0.100289
    rY_38 (Y_144 Y_145) resistor r=0.165835
    rY_37 (Y_144 Y_160) resistor r=0.0516933
    rY_36 (Y_146 Y_148) resistor r=0.405781
    rY_35 (Y_146 Y_160) resistor r=0.0442513
    rY_34 (Y_148 Y_149) resistor r=10
    rY_33 (Y_149 Y_227) resistor r=7.45
    rY_32 (Y_151 Y_153) resistor r=0.485771
    rY_31 (Y_151 Y_159) resistor r=0.0381776
    rY_30 (Y_153 Y_154) resistor r=0.75
    rY_29 (Y_154 Y_229) resistor r=13
    rY_28 (Y_159 Y_160) resistor r=0.75
    rY_27 (Y_185 Y_227) resistor r=5.23411
    rY_26 (Y_187 Y_227) resistor r=5.23411
    rY_25 (Y_229 MM2_ELT_d) resistor r=8.44
    rnet031_45 (MM9_ELT_d net031) resistor r=0.01
    rnet031_44 (net031_1 net031_3) resistor r=0.291194
    rnet031_43 (net031_1 net031_13) resistor r=0.0961166
    rnet031_42 (net031_3 net031_4) resistor r=8.66667
    rnet031_41 (net031_3 net031_6) resistor r=0.759637
    rnet031_40 (net031_4 net031) resistor r=32.3614
    rnet031_39 (net031_6 net031_7) resistor r=8.66667
    rnet031_38 (net031_6 net031_9) resistor r=0.426451
    rnet031_37 (net031_7 net031) resistor r=16.1807
    rnet031_36 (net031_7 net031_10) resistor r=32.3614
    rnet031_35 (net031_9 net031_10) resistor r=26
    rnet031_34 (net031_12 net031_13) resistor r=1.39911
    rnet031_33 (net031_12 net031_27) resistor r=0.0189309
    rnet031_32 (net031_16 net031_18) resistor r=0.0319838
    rnet031_31 (net031_16 net031_27) resistor r=0.0728441
    rnet031_30 (net031_18 net031_25) resistor r=8.66667
    rnet031_29 (net031_18 net031_21) resistor r=0.639676
    rnet031_28 (net031_21 net031_25) resistor r=8.66667
    rnet031_27 (net031_21 net031_24) resistor r=0.639676
    rnet031_26 (net031_24 net031_25) resistor r=8.66667
    rnet031_25 (net031_25 net031_36) resistor r=26.9476
    rnet031_24 (net031_25 net031_35) resistor r=26.9476
    rnet031_23 (net031_25 MM20_ELT_s) resistor r=5.62434
    rnet031_22 (MM20_ELT_s net031_30) resistor r=12.3172
    rnet031_21 (MM20_ELT_s net031_30) resistor r=1.62887
    rnet031_20 (MM20_ELT_s net031_33) resistor r=2.55965
    rnet031_19 (MM20_ELT_s net031_34) resistor r=25.7298
    rnet031_18 (net031_29 net031_30) resistor r=12.3172
    rnet031_17 (net031_29 net031_35) resistor r=9.45545
    rnet031_16 (net031_31 net031_33) resistor r=14.4784
    rnet031_15 (net031_31 net031_34) resistor r=9.04062
    rnet031_14 (net031_32 net031_33) resistor r=14.4784
    rnet031_13 (net031_32 net031_36) resistor r=9.55325
    rCDN_212 (CDN_42 CDN_48) resistor r=58.3583
    rCDN_211 (CDN_42 CDN_48) resistor r=4.16253
    rCDN_210 (CDN_42 CDN_48) resistor r=58.3583
    rCDN_209 (CDN_42 CDN_48) resistor r=4.16253
    rCDN_208 (CDN_45 CDN_48) resistor r=58.3583
    rCDN_207 (CDN_45 CDN_48) resistor r=4.16253
    rCDN_206 (CDN_45 CDN_48) resistor r=58.3583
    rCDN_205 (CDN_45 CDN_48) resistor r=4.16253
    rCDN_204 (CDN_48 CDN_53) resistor r=24.8333
    rCDN_203 (CDN_48 CDN_50) resistor r=24.8333
    rCDN_202 (CDN_48 CDN_61) resistor r=24.8333
    rCDN_201 (CDN_48 CDN_58) resistor r=24.8333
    rCDN_200 (CDN_48 CDN_66) resistor r=14.9
    rCDN_199 (CDN_48 CDN_72) resistor r=58.3583
    rCDN_198 (CDN_48 CDN_75) resistor r=58.3583
    rCDN_197 (CDN_48 CDN_53) resistor r=4.16253
    rCDN_196 (CDN_48 CDN_61) resistor r=4.16253
    rCDN_195 (CDN_48 CDN_72) resistor r=6.30933
    rCDN_194 (CDN_48 CDN_66) resistor r=6.30933
    rCDN_193 (CDN_48 CDN_50) resistor r=1.63969
    rCDN_192 (CDN_48 CDN_58) resistor r=4.16253
    rCDN_191 (CDN_48 CDN_75) resistor r=4.16253
    rCDN_190 (CDN_48 CDN_53) resistor r=24.8333
    rCDN_189 (CDN_48 CDN_50) resistor r=24.8333
    rCDN_188 (CDN_48 CDN_61) resistor r=24.8333
    rCDN_187 (CDN_48 CDN_58) resistor r=24.8333
    rCDN_186 (CDN_48 CDN_331) resistor r=39.7333
    rCDN_185 (CDN_48 CDN_66) resistor r=14.9
    rCDN_184 (CDN_48 CDN_72) resistor r=58.3583
    rCDN_183 (CDN_48 MM23_ELT_g) resistor r=7.45
    rCDN_182 (CDN_48 CDN_53) resistor r=4.16253
    rCDN_181 (CDN_48 CDN_61) resistor r=4.16253
    rCDN_180 (CDN_48 CDN_72) resistor r=6.30933
    rCDN_179 (CDN_48 CDN_66) resistor r=6.30933
    rCDN_178 (CDN_48 CDN_50) resistor r=1.63969
    rCDN_177 (CDN_48 CDN_58) resistor r=4.16253
    rCDN_176 (CDN_48 CDN_75) resistor r=4.16253
    rCDN_175 (CDN_75 MM23_ELT_g) resistor r=50.9083
    rCDN_174 (CDN_80 CDN_86) resistor r=58.3583
    rCDN_173 (CDN_80 CDN_86) resistor r=4.16253
    rCDN_172 (CDN_80 CDN_86) resistor r=58.3583
    rCDN_171 (CDN_80 CDN_86) resistor r=4.16253
    rCDN_170 (CDN_83 CDN_86) resistor r=58.3583
    rCDN_169 (CDN_83 CDN_86) resistor r=4.16253
    rCDN_168 (CDN_83 CDN_86) resistor r=58.3583
    rCDN_167 (CDN_83 CDN_86) resistor r=4.16253
    rCDN_166 (CDN_86 CDN_99) resistor r=24.8333
    rCDN_165 (CDN_86 CDN_96) resistor r=24.8333
    rCDN_164 (CDN_86 CDN_107) resistor r=24.8333
    rCDN_163 (CDN_86 CDN_104) resistor r=24.8333
    rCDN_162 (CDN_86 CDN_128) resistor r=58.3583
    rCDN_161 (CDN_86 CDN_131) resistor r=58.3583
    rCDN_160 (CDN_86 CDN_136) resistor r=14.9
    rCDN_159 (CDN_86 CDN_99) resistor r=4.16253
    rCDN_158 (CDN_86 CDN_107) resistor r=4.16253
    rCDN_157 (CDN_86 CDN_96) resistor r=4.16253
    rCDN_156 (CDN_86 CDN_128) resistor r=4.16253
    rCDN_155 (CDN_86 CDN_136) resistor r=6.30933
    rCDN_154 (CDN_86 CDN_131) resistor r=6.30933
    rCDN_153 (CDN_86 CDN_104) resistor r=1.63969
    rCDN_152 (CDN_86 CDN_99) resistor r=24.8333
    rCDN_151 (CDN_86 CDN_96) resistor r=24.8333
    rCDN_150 (CDN_86 CDN_107) resistor r=24.8333
    rCDN_149 (CDN_86 CDN_104) resistor r=24.8333
    rCDN_148 (CDN_86 CDN_128) resistor r=58.3583
    rCDN_147 (CDN_86 MM24_ELT_g) resistor r=22.35
    rCDN_146 (CDN_86 CDN_136) resistor r=14.9
    rCDN_145 (CDN_86 CDN_365) resistor r=39.7333
    rCDN_144 (CDN_86 CDN_99) resistor r=4.16253
    rCDN_143 (CDN_86 CDN_107) resistor r=4.16253
    rCDN_142 (CDN_86 CDN_96) resistor r=4.16253
    rCDN_141 (CDN_86 CDN_128) resistor r=4.16253
    rCDN_140 (CDN_86 CDN_136) resistor r=6.30933
    rCDN_139 (CDN_86 CDN_131) resistor r=6.30933
    rCDN_138 (CDN_86 CDN_104) resistor r=1.63969
    rCDN_137 (CDN_88 CDN_94) resistor r=58.3583
    rCDN_136 (CDN_88 CDN_94) resistor r=4.16253
    rCDN_135 (CDN_88 CDN_94) resistor r=58.3583
    rCDN_134 (CDN_88 CDN_94) resistor r=4.16253
    rCDN_133 (CDN_91 CDN_94) resistor r=58.3583
    rCDN_132 (CDN_91 CDN_94) resistor r=4.16253
    rCDN_131 (CDN_91 CDN_94) resistor r=58.3583
    rCDN_130 (CDN_91 CDN_94) resistor r=4.16253
    rCDN_129 (CDN_94 CDN_115) resistor r=24.8333
    rCDN_128 (CDN_94 CDN_112) resistor r=24.8333
    rCDN_127 (CDN_94 CDN_123) resistor r=24.8333
    rCDN_126 (CDN_94 CDN_120) resistor r=24.8333
    rCDN_125 (CDN_94 CDN_142) resistor r=14.9
    rCDN_124 (CDN_94 CDN_148) resistor r=58.3583
    rCDN_123 (CDN_94 CDN_151) resistor r=58.3583
    rCDN_122 (CDN_94 CDN_115) resistor r=4.16253
    rCDN_121 (CDN_94 CDN_123) resistor r=4.16253
    rCDN_120 (CDN_94 CDN_148) resistor r=6.30933
    rCDN_119 (CDN_94 CDN_142) resistor r=6.30933
    rCDN_118 (CDN_94 CDN_112) resistor r=1.63969
    rCDN_117 (CDN_94 CDN_120) resistor r=4.16253
    rCDN_116 (CDN_94 CDN_151) resistor r=4.16253
    rCDN_115 (CDN_94 CDN_115) resistor r=24.8333
    rCDN_114 (CDN_94 CDN_112) resistor r=24.8333
    rCDN_113 (CDN_94 CDN_123) resistor r=24.8333
    rCDN_112 (CDN_94 CDN_120) resistor r=24.8333
    rCDN_111 (CDN_94 CDN_367) resistor r=264.475
    rCDN_110 (CDN_94 CDN_142) resistor r=14.9
    rCDN_109 (CDN_94 CDN_148) resistor r=58.3583
    rCDN_108 (CDN_94 MM26_ELT_g) resistor r=7.45
    rCDN_107 (CDN_94 CDN_115) resistor r=4.16253
    rCDN_106 (CDN_94 CDN_123) resistor r=4.16253
    rCDN_105 (CDN_94 CDN_148) resistor r=6.30933
    rCDN_104 (CDN_94 CDN_142) resistor r=6.30933
    rCDN_103 (CDN_94 CDN_112) resistor r=1.63969
    rCDN_102 (CDN_94 CDN_120) resistor r=4.16253
    rCDN_101 (CDN_94 CDN_151) resistor r=4.16253
    rCDN_100 (CDN_131 MM24_ELT_g) resistor r=36.0083
    rCDN_99 (CDN_151 MM26_ELT_g) resistor r=50.9083
    rCDN_98 (CDN_156 CDN_162) resistor r=58.3583
    rCDN_97 (CDN_156 CDN_162) resistor r=4.16253
    rCDN_96 (CDN_156 CDN_162) resistor r=58.3583
    rCDN_95 (CDN_156 CDN_162) resistor r=4.16253
    rCDN_94 (CDN_159 CDN_162) resistor r=58.3583
    rCDN_93 (CDN_159 CDN_162) resistor r=6.30933
    rCDN_92 (CDN_159 CDN_162) resistor r=58.3583
    rCDN_91 (CDN_159 CDN_162) resistor r=6.30933
    rCDN_90 (CDN_162 CDN_164) resistor r=14.9
    rCDN_89 (CDN_162 CDN_173) resistor r=24.8333
    rCDN_88 (CDN_162 CDN_170) resistor r=24.8333
    rCDN_87 (CDN_162 CDN_181) resistor r=24.8333
    rCDN_86 (CDN_162 CDN_178) resistor r=24.8333
    rCDN_85 (CDN_162 CDN_186) resistor r=58.3583
    rCDN_84 (CDN_162 CDN_189) resistor r=58.3583
    rCDN_83 (CDN_162 CDN_173) resistor r=4.16253
    rCDN_82 (CDN_162 CDN_164) resistor r=6.30933
    rCDN_81 (CDN_162 CDN_181) resistor r=1.63969
    rCDN_80 (CDN_162 CDN_170) resistor r=4.16253
    rCDN_79 (CDN_162 CDN_186) resistor r=4.16253
    rCDN_78 (CDN_162 CDN_178) resistor r=4.16253
    rCDN_77 (CDN_162 CDN_189) resistor r=4.16253
    rCDN_76 (CDN_162 CDN_164) resistor r=14.9
    rCDN_75 (CDN_162 CDN_381) resistor r=39.7333
    rCDN_74 (CDN_162 CDN_173) resistor r=24.8333
    rCDN_73 (CDN_162 CDN_170) resistor r=24.8333
    rCDN_72 (CDN_162 CDN_181) resistor r=24.8333
    rCDN_71 (CDN_162 CDN_178) resistor r=24.8333
    rCDN_70 (CDN_162 CDN_186) resistor r=58.3583
    rCDN_69 (CDN_162 MM18_ELT_g) resistor r=7.45
    rCDN_68 (CDN_162 CDN_173) resistor r=4.16253
    rCDN_67 (CDN_162 CDN_164) resistor r=6.30933
    rCDN_66 (CDN_162 CDN_181) resistor r=1.63969
    rCDN_65 (CDN_162 CDN_170) resistor r=4.16253
    rCDN_64 (CDN_162 CDN_186) resistor r=4.16253
    rCDN_63 (CDN_162 CDN_178) resistor r=4.16253
    rCDN_62 (CDN_162 CDN_189) resistor r=4.16253
    rCDN_61 (CDN_189 MM18_ELT_g) resistor r=50.9083
    rCDN_60 (CDN_261 CDN) resistor r=0.259029
    rCDN_59 (CDN_261 CDN_269) resistor r=0.111466
    rCDN_58 (CDN_263 CDN_264) resistor r=10
    rCDN_57 (CDN_263 CDN) resistor r=0.0588701
    rCDN_56 (CDN_264 CDN_396) resistor r=13.5455
    rCDN_55 (CDN_268 CDN_269) resistor r=0.976038
    rCDN_54 (CDN_268 CDN_271) resistor r=0.10135
    rCDN_53 (CDN_270 CDN_273) resistor r=0.158926
    rCDN_52 (CDN_270 CDN_276) resistor r=0.097165
    rCDN_51 (CDN_271 CDN_273) resistor r=0.757768
    rCDN_50 (CDN_273 CDN_274) resistor r=10
    rCDN_49 (CDN_274 CDN_407) resistor r=13.5455
    rCDN_48 (CDN_275 CDN_276) resistor r=0.0942209
    rCDN_47 (CDN_275 CDN_277) resistor r=0.103859
    rCDN_46 (CDN_277 CDN_279) resistor r=0.125804
    rCDN_45 (CDN_279 CDN_280) resistor r=10
    rCDN_44 (CDN_280 CDN_406) resistor r=37.25
    rCDN_43 (CDN_280 CDN_413) resistor r=19.6409
    rCDN_42 (CDN_331 CDN_397) resistor r=4.38767
    rCDN_41 (CDN_365 CDN_406) resistor r=9.29775
    rCDN_40 (CDN_367 CDN_408) resistor r=4.38767
    rCDN_39 (CDN_381 CDN_413) resistor r=9.29775
    rCDN_38 (CDN_396 CDN_397) resistor r=3.71511
    rCDN_37 (CDN_407 CDN_408) resistor r=3.71511
    rnet033_15 (MM24_ELT_s net033) resistor r=0.01
    rnet033_14 (net033_1 net033_3) resistor r=0.191903
    rnet033_13 (net033_1 net033_7) resistor r=0.0961166
    rnet033_12 (net033_3 net033_4) resistor r=13
    rnet033_11 (net033_4 MM1_ELT_d) resistor r=8.44
    rnet033_10 (net033_6 net033_7) resistor r=1.86144
    rnet033_9 (net033_6 net033_8) resistor r=0.0961166
    rnet033_8 (net033_8 net033_10) resistor r=0.191903
    rnet033_7 (net033_10 net033_11) resistor r=13
    rnet033_6 (net033_11 net033) resistor r=8.44
    rU_186 (U_22 U_28) resistor r=58.3583
    rU_185 (U_22 U_28) resistor r=4.16253
    rU_184 (U_22 U_28) resistor r=58.3583
    rU_183 (U_22 U_28) resistor r=4.16253
    rU_182 (U_25 U_28) resistor r=58.3583
    rU_181 (U_25 U_28) resistor r=5.53947
    rU_180 (U_25 U_28) resistor r=58.3583
    rU_179 (U_25 U_28) resistor r=5.53947
    rU_178 (U_28 U_30) resistor r=11.175
    rU_177 (U_28 U_53) resistor r=24.8333
    rU_176 (U_28 U_50) resistor r=24.8333
    rU_175 (U_28 U_69) resistor r=22.35
    rU_174 (U_28 U_66) resistor r=22.35
    rU_173 (U_28 U_82) resistor r=58.3583
    rU_172 (U_28 U_85) resistor r=58.3583
    rU_171 (U_28 U_53) resistor r=4.16253
    rU_170 (U_28 U_30) resistor r=5.53947
    rU_169 (U_28 U_69) resistor r=2.32428
    rU_168 (U_28 U_50) resistor r=4.16253
    rU_167 (U_28 U_82) resistor r=4.16253
    rU_166 (U_28 U_66) resistor r=4.16253
    rU_165 (U_28 U_85) resistor r=4.16253
    rU_164 (U_28 U_30) resistor r=11.175
    rU_163 (U_28 U_202) resistor r=29.8
    rU_162 (U_28 U_53) resistor r=24.8333
    rU_161 (U_28 U_50) resistor r=24.8333
    rU_160 (U_28 U_69) resistor r=22.35
    rU_159 (U_28 U_66) resistor r=22.35
    rU_158 (U_28 U_82) resistor r=58.3583
    rU_157 (U_28 MM4_ELT_g) resistor r=7.45
    rU_156 (U_28 U_53) resistor r=4.16253
    rU_155 (U_28 U_30) resistor r=5.53947
    rU_154 (U_28 U_69) resistor r=2.32428
    rU_153 (U_28 U_50) resistor r=4.16253
    rU_152 (U_28 U_82) resistor r=4.16253
    rU_151 (U_28 U_66) resistor r=4.16253
    rU_150 (U_28 U_85) resistor r=4.16253
    rU_149 (U_36 U_39) resistor r=11.175
    rU_148 (U_36 U_39) resistor r=5.53947
    rU_147 (U_36 U_39) resistor r=11.175
    rU_146 (U_36 U_39) resistor r=5.53947
    rU_145 (U_39 U_42) resistor r=202.392
    rU_144 (U_39 U_45) resistor r=202.392
    rU_143 (U_39 U_61) resistor r=24.8333
    rU_142 (U_39 U_58) resistor r=24.8333
    rU_141 (U_39 U_77) resistor r=22.35
    rU_140 (U_39 U_74) resistor r=22.35
    rU_139 (U_39 U_90) resistor r=202.392
    rU_138 (U_39 U_93) resistor r=202.392
    rU_137 (U_39 U_42) resistor r=5.53947
    rU_136 (U_39 U_77) resistor r=2.32428
    rU_135 (U_39 U_61) resistor r=4.16253
    rU_134 (U_39 U_45) resistor r=4.16253
    rU_133 (U_39 U_74) resistor r=4.16253
    rU_132 (U_39 U_90) resistor r=4.16253
    rU_131 (U_39 U_58) resistor r=4.16253
    rU_130 (U_39 U_93) resistor r=4.16253
    rU_129 (U_39 U_204) resistor r=31.6625
    rU_128 (U_39 U_42) resistor r=202.392
    rU_127 (U_39 U_45) resistor r=202.392
    rU_126 (U_39 U_61) resistor r=24.8333
    rU_125 (U_39 U_58) resistor r=24.8333
    rU_124 (U_39 U_77) resistor r=22.35
    rU_123 (U_39 U_74) resistor r=22.35
    rU_122 (U_39 U_90) resistor r=202.392
    rU_121 (U_39 MM7_ELT_g) resistor r=7.45
    rU_120 (U_39 U_42) resistor r=5.53947
    rU_119 (U_39 U_77) resistor r=2.32428
    rU_118 (U_39 U_61) resistor r=4.16253
    rU_117 (U_39 U_45) resistor r=4.16253
    rU_116 (U_39 U_74) resistor r=4.16253
    rU_115 (U_39 U_90) resistor r=4.16253
    rU_114 (U_39 U_58) resistor r=4.16253
    rU_113 (U_39 U_93) resistor r=4.16253
    rU_112 (U_85 MM4_ELT_g) resistor r=50.9083
    rU_111 (U_93 MM7_ELT_g) resistor r=194.942
    rU_110 (U_133 U_266) resistor r=8.66667
    rU_109 (U_133 U_149) resistor r=0.117274
    rU_108 (U_136 U_139) resistor r=0.333279
    rU_107 (U_136 U_171) resistor r=0.0963616
    rU_106 (U_137 U_142) resistor r=0.362483
    rU_105 (U_137 U_150) resistor r=0.0529359
    rU_104 (U_139 U_276) resistor r=8.66667
    rU_103 (U_139 U_142) resistor r=0.639676
    rU_102 (U_142 U_276) resistor r=8.66667
    rU_101 (U_144 U_145) resistor r=0.0976195
    rU_100 (U_144 U_153) resistor r=0.0709118
    rU_99 (U_145 U_155) resistor r=0.0963616
    rU_98 (U_148 U_149) resistor r=0.0528238
    rU_97 (U_148 U_166) resistor r=0.0415065
    rU_96 (U_150 U) resistor r=0.0104917
    rU_95 (U_153 U_154) resistor r=10
    rU_94 (U_154 U_236) resistor r=7.45
    rU_93 (U_155 U_171) resistor r=0.947073
    rU_92 (U_156 U_158) resistor r=0.361413
    rU_91 (U_156 U_162) resistor r=0.0763552
    rU_90 (U_158 U_159) resistor r=0.75
    rU_89 (U_159 U_269) resistor r=13
    rU_88 (U_161 U_162) resistor r=1.22803
    rU_87 (U_161 U_173) resistor r=0.0763552
    rU_86 (U_163 U_165) resistor r=0.512974
    rU_85 (U_163 U_168) resistor r=0.0763552
    rU_84 (U_165 U_166) resistor r=0.75
    rU_83 (U_166 U_267) resistor r=0.207533
    rU_82 (U_168 U_170) resistor r=1.11816
    rU_81 (U_170 U_171) resistor r=0.75
    rU_80 (U_173 U_175) resistor r=0.400275
    rU_79 (U_175 U) resistor r=0.75
    rU_78 (U_202 U_237) resistor r=3.725
    rU_77 (U_204 U_237) resistor r=3.725
    rU_76 (U_236 U_237) resistor r=3.725
    rU_75 (MM18_ELT_d U_247) resistor r=2.67027
    rU_74 (MM18_ELT_d U_249) resistor r=12.8495
    rU_73 (MM18_ELT_d U_249) resistor r=1.69926
    rU_72 (MM18_ELT_d U_252) resistor r=4.557
    rU_71 (MM18_ELT_d U_266) resistor r=2.94846
    rU_70 (U_245 U_247) resistor r=15.1041
    rU_69 (U_245 U_250) resistor r=9.43134
    rU_68 (U_246 U_247) resistor r=15.1041
    rU_67 (U_246 U_253) resistor r=9.96613
    rU_66 (U_248 U_249) resistor r=12.8495
    rU_65 (U_248 U_251) resistor r=9.4369
    rU_64 (U_250 U_252) resistor r=21.1301
    rU_63 (U_251 U_252) resistor r=21.1301
    rU_62 (U_253 U_266) resistor r=11.8944
    rU_61 (MM5_ELT_d U_255) resistor r=25.7298
    rU_60 (MM5_ELT_d U_258) resistor r=2.55965
    rU_59 (MM5_ELT_d U_260) resistor r=12.3172
    rU_58 (MM5_ELT_d U_260) resistor r=1.62887
    rU_57 (MM5_ELT_d U_276) resistor r=5.62434
    rU_56 (U_255 U_257) resistor r=9.04062
    rU_55 (U_256 U_258) resistor r=14.4784
    rU_54 (U_256 U_262) resistor r=9.55325
    rU_53 (U_257 U_258) resistor r=14.4784
    rU_52 (U_259 U_260) resistor r=12.3172
    rU_51 (U_259 U_261) resistor r=9.45545
    rU_50 (U_261 U_276) resistor r=26.9476
    rU_49 (U_262 U_276) resistor r=26.9476
    rU_48 (U_266 U_267) resistor r=26
    rU_47 (U_269 MM26_ELT_d) resistor r=8.09035
    rU_46 (U_276 U) resistor r=13
    rnet037_39 (net037_3 MM24_ELT_d) resistor r=4.22001
    rnet037_38 (net037_3 net037_24) resistor r=4.22001
    rnet037_37 (net037_3 MM10_ELT_s) resistor r=4.22001
    rnet037_36 (net037_3 net037_22) resistor r=4.22001
    rnet037_35 (net037_6 net037_9) resistor r=21.1301
    rnet037_34 (net037_6 net037_11) resistor r=9.43134
    rnet037_33 (net037_7 net037_9) resistor r=21.1301
    rnet037_32 (net037_7 net037_13) resistor r=9.4369
    rnet037_31 (MM10_ELT_s net037_9) resistor r=4.557
    rnet037_30 (MM10_ELT_s net037_12) resistor r=2.67027
    rnet037_29 (MM10_ELT_s net037_14) resistor r=12.8495
    rnet037_28 (MM10_ELT_s net037_14) resistor r=1.69926
    rnet037_27 (MM10_ELT_s net037) resistor r=10.6787
    rnet037_26 (net037_10 net037_12) resistor r=15.1041
    rnet037_25 (net037_10 net037_23) resistor r=11.0157
    rnet037_24 (net037_11 net037_12) resistor r=15.1041
    rnet037_23 (net037_13 net037_14) resistor r=12.8495
    rnet037_22 (MM24_ELT_d net037_18) resistor r=2.67027
    rnet037_21 (MM24_ELT_d net037_20) resistor r=12.8495
    rnet037_20 (MM24_ELT_d net037_20) resistor r=1.69926
    rnet037_19 (MM24_ELT_d net037_21) resistor r=18.0507
    rnet037_18 (net037_16 net037_18) resistor r=15.1041
    rnet037_17 (net037_16 net037_21) resistor r=9.43134
    rnet037_16 (net037_17 net037_18) resistor r=15.1041
    rnet037_15 (net037_17 net037_23) resistor r=11.0157
    rnet037_14 (net037_19 net037_20) resistor r=12.8495
    rnet037_13 (net037_19 net037) resistor r=10.6787
    rnet037_12 (net037_22 net037_23) resistor r=0.762262
    rnet037_11 (net037_24 net037) resistor r=0.57282
    rX_95 (MM23_ELT_d X) resistor r=0.01
    rX_94 (X_12 X_15) resistor r=14.9
    rX_93 (X_12 X_15) resistor r=6.30933
    rX_92 (X_12 X_15) resistor r=14.9
    rX_91 (X_12 X_15) resistor r=6.30933
    rX_90 (X_15 X_18) resistor r=202.392
    rX_89 (X_15 X_21) resistor r=202.392
    rX_88 (X_15 X_29) resistor r=24.8333
    rX_87 (X_15 X_26) resistor r=24.8333
    rX_86 (X_15 X_37) resistor r=24.8333
    rX_85 (X_15 X_34) resistor r=24.8333
    rX_84 (X_15 X_42) resistor r=202.392
    rX_83 (X_15 X_45) resistor r=202.392
    rX_82 (X_15 X_18) resistor r=6.30933
    rX_81 (X_15 X_29) resistor r=1.63969
    rX_80 (X_15 X_37) resistor r=4.16253
    rX_79 (X_15 X_21) resistor r=4.16253
    rX_78 (X_15 X_26) resistor r=4.16253
    rX_77 (X_15 X_42) resistor r=4.16253
    rX_76 (X_15 X_34) resistor r=4.16253
    rX_75 (X_15 X_45) resistor r=4.16253
    rX_74 (X_15 X_117) resistor r=42.2167
    rX_73 (X_15 X_18) resistor r=202.392
    rX_72 (X_15 X_21) resistor r=202.392
    rX_71 (X_15 X_29) resistor r=24.8333
    rX_70 (X_15 X_26) resistor r=24.8333
    rX_69 (X_15 X_37) resistor r=24.8333
    rX_68 (X_15 X_34) resistor r=24.8333
    rX_67 (X_15 X_42) resistor r=202.392
    rX_66 (X_15 MM9_ELT_g) resistor r=7.45
    rX_65 (X_15 X_18) resistor r=6.30933
    rX_64 (X_15 X_29) resistor r=1.63969
    rX_63 (X_15 X_37) resistor r=4.16253
    rX_62 (X_15 X_21) resistor r=4.16253
    rX_61 (X_15 X_26) resistor r=4.16253
    rX_60 (X_15 X_42) resistor r=4.16253
    rX_59 (X_15 X_34) resistor r=4.16253
    rX_58 (X_15 X_45) resistor r=4.16253
    rX_57 (X_45 MM9_ELT_g) resistor r=194.942
    rX_56 (X_66 X_67) resistor r=0.395616
    rX_55 (X_66 X_69) resistor r=0.111466
    rX_54 (X_67 X_85) resistor r=0.010103
    rX_53 (X_68 X_71) resistor r=0.121873
    rX_52 (X_68 X_74) resistor r=0.111466
    rX_51 (X_69 X_71) resistor r=0.0667195
    rX_50 (X_71 X_72) resistor r=10
    rX_49 (X_72 X_134) resistor r=25.0591
    rX_48 (X_73 X_74) resistor r=0.195239
    rX_47 (X_73 X_87) resistor r=0.010103
    rX_46 (X_75 X_77) resistor r=0.303846
    rX_45 (X_75 X_89) resistor r=0.010103
    rX_44 (X_77 X_78) resistor r=13
    rX_43 (X_78 MM10_ELT_d) resistor r=8.44
    rX_42 (X_82 X_100) resistor r=13
    rX_41 (X_82 MM11_ELT_d) resistor r=8.09035
    rX_40 (X_85 X_100) resistor r=0.20012
    rX_39 (X_87 X_89) resistor r=0.141548
    rX_38 (X_91 X_92) resistor r=0.559608
    rX_37 (X_91 X_94) resistor r=0.0763552
    rX_36 (X_92 X_96) resistor r=0.0763552
    rX_35 (X_93 X_94) resistor r=0.124357
    rX_34 (X_93 X_97) resistor r=0.0763552
    rX_33 (X_95 X_96) resistor r=0.124357
    rX_32 (X_95 X_105) resistor r=0.0381776
    rX_31 (X_97 X_99) resistor r=0.147674
    rX_30 (X_99 X_100) resistor r=0.75
    rX_29 (X_105 X_106) resistor r=0.75
    rX_28 (X_106 X_152) resistor r=13
    rX_27 (X_117 X_134) resistor r=9.29775
    rX_26 (X_152 X) resistor r=8.09035
    rD_96 (D_22 D_28) resistor r=58.3583
    rD_95 (D_22 D_28) resistor r=4.16253
    rD_94 (D_22 D_28) resistor r=58.3583
    rD_93 (D_22 D_28) resistor r=4.16253
    rD_92 (D_25 D_28) resistor r=58.3583
    rD_91 (D_25 D_28) resistor r=6.30933
    rD_90 (D_25 D_28) resistor r=58.3583
    rD_89 (D_25 D_28) resistor r=6.30933
    rD_88 (D_28 D_30) resistor r=14.9
    rD_87 (D_28 D_53) resistor r=24.8333
    rD_86 (D_28 D_50) resistor r=24.8333
    rD_85 (D_28 D_61) resistor r=24.8333
    rD_84 (D_28 D_58) resistor r=24.8333
    rD_83 (D_28 D_82) resistor r=58.3583
    rD_82 (D_28 D_85) resistor r=58.3583
    rD_81 (D_28 D_53) resistor r=4.16253
    rD_80 (D_28 D_30) resistor r=6.30933
    rD_79 (D_28 D_61) resistor r=1.63969
    rD_78 (D_28 D_50) resistor r=4.16253
    rD_77 (D_28 D_82) resistor r=4.16253
    rD_76 (D_28 D_58) resistor r=4.16253
    rD_75 (D_28 D_85) resistor r=4.16253
    rD_74 (D_28 D_30) resistor r=14.9
    rD_73 (D_28 D_162) resistor r=39.7333
    rD_72 (D_28 D_53) resistor r=24.8333
    rD_71 (D_28 D_50) resistor r=24.8333
    rD_70 (D_28 D_61) resistor r=24.8333
    rD_69 (D_28 D_58) resistor r=24.8333
    rD_68 (D_28 D_82) resistor r=58.3583
    rD_67 (D_28 MM1_ELT_g) resistor r=7.45
    rD_66 (D_28 D_53) resistor r=4.16253
    rD_65 (D_28 D_30) resistor r=6.30933
    rD_64 (D_28 D_61) resistor r=1.63969
    rD_63 (D_28 D_50) resistor r=4.16253
    rD_62 (D_28 D_82) resistor r=4.16253
    rD_61 (D_28 D_58) resistor r=4.16253
    rD_60 (D_28 D_85) resistor r=4.16253
    rD_59 (D_36 D_39) resistor r=14.9
    rD_58 (D_36 D_39) resistor r=6.30933
    rD_57 (D_36 D_39) resistor r=14.9
    rD_56 (D_36 D_39) resistor r=6.30933
    rD_55 (D_39 D_42) resistor r=58.3583
    rD_54 (D_39 D_45) resistor r=58.3583
    rD_53 (D_39 D_69) resistor r=24.8333
    rD_52 (D_39 D_66) resistor r=24.8333
    rD_51 (D_39 D_77) resistor r=24.8333
    rD_50 (D_39 D_74) resistor r=24.8333
    rD_49 (D_39 D_90) resistor r=58.3583
    rD_48 (D_39 D_93) resistor r=58.3583
    rD_47 (D_39 D_42) resistor r=6.30933
    rD_46 (D_39 D_69) resistor r=1.63969
    rD_45 (D_39 D_77) resistor r=4.16253
    rD_44 (D_39 D_45) resistor r=4.16253
    rD_43 (D_39 D_66) resistor r=4.16253
    rD_42 (D_39 D_90) resistor r=4.16253
    rD_41 (D_39 D_74) resistor r=4.16253
    rD_40 (D_39 D_93) resistor r=4.16253
    rD_39 (D_39 D_164) resistor r=55.875
    rD_38 (D_39 D_42) resistor r=58.3583
    rD_37 (D_39 D_45) resistor r=58.3583
    rD_36 (D_39 D_69) resistor r=24.8333
    rD_35 (D_39 D_66) resistor r=24.8333
    rD_34 (D_39 D_77) resistor r=24.8333
    rD_33 (D_39 D_74) resistor r=24.8333
    rD_32 (D_39 D_90) resistor r=58.3583
    rD_31 (D_39 MM11_ELT_g) resistor r=7.45
    rD_30 (D_39 D_42) resistor r=6.30933
    rD_29 (D_39 D_69) resistor r=1.63969
    rD_28 (D_39 D_77) resistor r=4.16253
    rD_27 (D_39 D_45) resistor r=4.16253
    rD_26 (D_39 D_66) resistor r=4.16253
    rD_25 (D_39 D_90) resistor r=4.16253
    rD_24 (D_39 D_74) resistor r=4.16253
    rD_23 (D_39 D_93) resistor r=4.16253
    rD_22 (D_85 MM1_ELT_g) resistor r=50.9083
    rD_21 (D_93 MM11_ELT_g) resistor r=50.9083
    rD_20 (D_132 D_133) resistor r=10
    rD_19 (D_132 D) resistor r=0.00230853
    rD_18 (D_133 D_194) resistor r=25.0591
    rD_17 (D_162 D_195) resistor r=10.0997
    rD_16 (D_164 D_195) resistor r=10.0997
    rD_15 (D_194 D_195) resistor r=0.877078
    rCPN_248 (MM21_ELT_d CPN) resistor r=0.01
    rCPN_247 (CPN_42 CPN_48) resistor r=58.3583
    rCPN_246 (CPN_42 CPN_48) resistor r=4.16253
    rCPN_245 (CPN_42 CPN_48) resistor r=58.3583
    rCPN_244 (CPN_42 CPN_48) resistor r=4.16253
    rCPN_243 (CPN_45 CPN_48) resistor r=58.3583
    rCPN_242 (CPN_45 CPN_48) resistor r=4.16253
    rCPN_241 (CPN_45 CPN_48) resistor r=58.3583
    rCPN_240 (CPN_45 CPN_48) resistor r=4.16253
    rCPN_239 (CPN_48 CPN_53) resistor r=24.8333
    rCPN_238 (CPN_48 CPN_50) resistor r=24.8333
    rCPN_237 (CPN_48 CPN_61) resistor r=24.8333
    rCPN_236 (CPN_48 CPN_58) resistor r=24.8333
    rCPN_235 (CPN_48 CPN_66) resistor r=58.3583
    rCPN_234 (CPN_48 CPN_69) resistor r=58.3583
    rCPN_233 (CPN_48 CPN_74) resistor r=14.9
    rCPN_232 (CPN_48 CPN_53) resistor r=4.16253
    rCPN_231 (CPN_48 CPN_61) resistor r=4.16253
    rCPN_230 (CPN_48 CPN_50) resistor r=4.16253
    rCPN_229 (CPN_48 CPN_66) resistor r=4.16253
    rCPN_228 (CPN_48 CPN_74) resistor r=6.30933
    rCPN_227 (CPN_48 CPN_69) resistor r=6.30933
    rCPN_226 (CPN_48 CPN_58) resistor r=1.63969
    rCPN_225 (CPN_48 CPN_53) resistor r=24.8333
    rCPN_224 (CPN_48 CPN_50) resistor r=24.8333
    rCPN_223 (CPN_48 CPN_61) resistor r=24.8333
    rCPN_222 (CPN_48 CPN_58) resistor r=24.8333
    rCPN_221 (CPN_48 CPN_66) resistor r=58.3583
    rCPN_220 (CPN_48 MM10_ELT_g) resistor r=22.35
    rCPN_219 (CPN_48 CPN_74) resistor r=14.9
    rCPN_218 (CPN_48 CPN_368) resistor r=39.7333
    rCPN_217 (CPN_48 CPN_53) resistor r=4.16253
    rCPN_216 (CPN_48 CPN_61) resistor r=4.16253
    rCPN_215 (CPN_48 CPN_50) resistor r=4.16253
    rCPN_214 (CPN_48 CPN_66) resistor r=4.16253
    rCPN_213 (CPN_48 CPN_74) resistor r=6.30933
    rCPN_212 (CPN_48 CPN_69) resistor r=6.30933
    rCPN_211 (CPN_48 CPN_58) resistor r=1.63969
    rCPN_210 (CPN_69 MM10_ELT_g) resistor r=36.0083
    rCPN_209 (CPN_80 CPN_86) resistor r=202.392
    rCPN_208 (CPN_80 CPN_86) resistor r=4.16253
    rCPN_207 (CPN_80 CPN_86) resistor r=202.392
    rCPN_206 (CPN_80 CPN_86) resistor r=4.16253
    rCPN_205 (CPN_83 CPN_86) resistor r=202.392
    rCPN_204 (CPN_83 CPN_86) resistor r=4.16253
    rCPN_203 (CPN_83 CPN_86) resistor r=202.392
    rCPN_202 (CPN_83 CPN_86) resistor r=4.16253
    rCPN_201 (CPN_86 CPN_91) resistor r=24.8333
    rCPN_200 (CPN_86 CPN_88) resistor r=24.8333
    rCPN_199 (CPN_86 CPN_99) resistor r=24.8333
    rCPN_198 (CPN_86 CPN_96) resistor r=24.8333
    rCPN_197 (CPN_86 CPN_104) resistor r=14.9
    rCPN_196 (CPN_86 CPN_110) resistor r=202.392
    rCPN_195 (CPN_86 CPN_113) resistor r=202.392
    rCPN_194 (CPN_86 CPN_91) resistor r=4.16253
    rCPN_193 (CPN_86 CPN_99) resistor r=4.16253
    rCPN_192 (CPN_86 CPN_110) resistor r=6.30933
    rCPN_191 (CPN_86 CPN_104) resistor r=6.30933
    rCPN_190 (CPN_86 CPN_88) resistor r=1.63969
    rCPN_189 (CPN_86 CPN_96) resistor r=4.16253
    rCPN_188 (CPN_86 CPN_113) resistor r=4.16253
    rCPN_187 (CPN_86 CPN_91) resistor r=24.8333
    rCPN_186 (CPN_86 CPN_88) resistor r=24.8333
    rCPN_185 (CPN_86 CPN_99) resistor r=24.8333
    rCPN_184 (CPN_86 CPN_96) resistor r=24.8333
    rCPN_183 (CPN_86 CPN_381) resistor r=42.2167
    rCPN_182 (CPN_86 CPN_104) resistor r=14.9
    rCPN_181 (CPN_86 CPN_110) resistor r=202.392
    rCPN_180 (CPN_86 MM20_ELT_g) resistor r=7.45
    rCPN_179 (CPN_86 CPN_91) resistor r=4.16253
    rCPN_178 (CPN_86 CPN_99) resistor r=4.16253
    rCPN_177 (CPN_86 CPN_110) resistor r=6.30933
    rCPN_176 (CPN_86 CPN_104) resistor r=6.30933
    rCPN_175 (CPN_86 CPN_88) resistor r=1.63969
    rCPN_174 (CPN_86 CPN_96) resistor r=4.16253
    rCPN_173 (CPN_86 CPN_113) resistor r=4.16253
    rCPN_172 (CPN_113 MM20_ELT_g) resistor r=194.942
    rCPN_171 (CPN_118 CPN_124) resistor r=58.3583
    rCPN_170 (CPN_118 CPN_124) resistor r=4.16253
    rCPN_169 (CPN_118 CPN_124) resistor r=58.3583
    rCPN_168 (CPN_118 CPN_124) resistor r=4.16253
    rCPN_167 (CPN_121 CPN_124) resistor r=58.3583
    rCPN_166 (CPN_121 CPN_124) resistor r=6.30933
    rCPN_165 (CPN_121 CPN_124) resistor r=58.3583
    rCPN_164 (CPN_121 CPN_124) resistor r=6.30933
    rCPN_163 (CPN_124 CPN_126) resistor r=14.9
    rCPN_162 (CPN_124 CPN_149) resistor r=24.8333
    rCPN_161 (CPN_124 CPN_146) resistor r=24.8333
    rCPN_160 (CPN_124 CPN_157) resistor r=24.8333
    rCPN_159 (CPN_124 CPN_154) resistor r=24.8333
    rCPN_158 (CPN_124 CPN_178) resistor r=58.3583
    rCPN_157 (CPN_124 CPN_181) resistor r=58.3583
    rCPN_156 (CPN_124 CPN_149) resistor r=4.16253
    rCPN_155 (CPN_124 CPN_126) resistor r=6.30933
    rCPN_154 (CPN_124 CPN_157) resistor r=1.63969
    rCPN_153 (CPN_124 CPN_146) resistor r=4.16253
    rCPN_152 (CPN_124 CPN_178) resistor r=4.16253
    rCPN_151 (CPN_124 CPN_154) resistor r=4.16253
    rCPN_150 (CPN_124 CPN_181) resistor r=4.16253
    rCPN_149 (CPN_124 CPN_126) resistor r=14.9
    rCPN_148 (CPN_124 CPN_393) resistor r=39.7333
    rCPN_147 (CPN_124 CPN_149) resistor r=24.8333
    rCPN_146 (CPN_124 CPN_146) resistor r=24.8333
    rCPN_145 (CPN_124 CPN_157) resistor r=24.8333
    rCPN_144 (CPN_124 CPN_154) resistor r=24.8333
    rCPN_143 (CPN_124 CPN_178) resistor r=58.3583
    rCPN_142 (CPN_124 MM2_ELT_g) resistor r=7.45
    rCPN_141 (CPN_124 CPN_149) resistor r=4.16253
    rCPN_140 (CPN_124 CPN_126) resistor r=6.30933
    rCPN_139 (CPN_124 CPN_157) resistor r=1.63969
    rCPN_138 (CPN_124 CPN_146) resistor r=4.16253
    rCPN_137 (CPN_124 CPN_178) resistor r=4.16253
    rCPN_136 (CPN_124 CPN_154) resistor r=4.16253
    rCPN_135 (CPN_124 CPN_181) resistor r=4.16253
    rCPN_134 (CPN_132 CPN_135) resistor r=14.9
    rCPN_133 (CPN_132 CPN_135) resistor r=6.30933
    rCPN_132 (CPN_132 CPN_135) resistor r=14.9
    rCPN_131 (CPN_132 CPN_135) resistor r=6.30933
    rCPN_130 (CPN_135 CPN_138) resistor r=202.392
    rCPN_129 (CPN_135 CPN_141) resistor r=202.392
    rCPN_128 (CPN_135 CPN_165) resistor r=24.8333
    rCPN_127 (CPN_135 CPN_162) resistor r=24.8333
    rCPN_126 (CPN_135 CPN_173) resistor r=24.8333
    rCPN_125 (CPN_135 CPN_170) resistor r=24.8333
    rCPN_124 (CPN_135 CPN_186) resistor r=202.392
    rCPN_123 (CPN_135 CPN_189) resistor r=202.392
    rCPN_122 (CPN_135 CPN_138) resistor r=6.30933
    rCPN_121 (CPN_135 CPN_165) resistor r=1.63969
    rCPN_120 (CPN_135 CPN_173) resistor r=4.16253
    rCPN_119 (CPN_135 CPN_141) resistor r=4.16253
    rCPN_118 (CPN_135 CPN_162) resistor r=4.16253
    rCPN_117 (CPN_135 CPN_186) resistor r=4.16253
    rCPN_116 (CPN_135 CPN_170) resistor r=4.16253
    rCPN_115 (CPN_135 CPN_189) resistor r=4.16253
    rCPN_114 (CPN_135 CPN_395) resistor r=42.2167
    rCPN_113 (CPN_135 CPN_138) resistor r=202.392
    rCPN_112 (CPN_135 CPN_141) resistor r=202.392
    rCPN_111 (CPN_135 CPN_165) resistor r=24.8333
    rCPN_110 (CPN_135 CPN_162) resistor r=24.8333
    rCPN_109 (CPN_135 CPN_173) resistor r=24.8333
    rCPN_108 (CPN_135 CPN_170) resistor r=24.8333
    rCPN_107 (CPN_135 CPN_186) resistor r=202.392
    rCPN_106 (CPN_135 MM5_ELT_g) resistor r=7.45
    rCPN_105 (CPN_135 CPN_138) resistor r=6.30933
    rCPN_104 (CPN_135 CPN_165) resistor r=1.63969
    rCPN_103 (CPN_135 CPN_173) resistor r=4.16253
    rCPN_102 (CPN_135 CPN_141) resistor r=4.16253
    rCPN_101 (CPN_135 CPN_162) resistor r=4.16253
    rCPN_100 (CPN_135 CPN_186) resistor r=4.16253
    rCPN_99 (CPN_135 CPN_170) resistor r=4.16253
    rCPN_98 (CPN_135 CPN_189) resistor r=4.16253
    rCPN_97 (CPN_181 MM2_ELT_g) resistor r=50.9083
    rCPN_96 (CPN_189 MM5_ELT_g) resistor r=194.942
    rCPN_95 (CPN_261 CPN_263) resistor r=0.341161
    rCPN_94 (CPN_261 CPN_279) resistor r=0.010103
    rCPN_93 (CPN_263 CPN_264) resistor r=8.66667
    rCPN_92 (CPN_263 CPN_266) resistor r=0.639676
    rCPN_91 (CPN_264 CPN) resistor r=32.3614
    rCPN_90 (CPN_266 CPN_267) resistor r=8.66667
    rCPN_89 (CPN_266 CPN_269) resistor r=0.426451
    rCPN_88 (CPN_267 CPN) resistor r=16.1807
    rCPN_87 (CPN_267 CPN_270) resistor r=32.3614
    rCPN_86 (CPN_269 CPN_270) resistor r=26
    rCPN_85 (CPN_272 CPN_273) resistor r=0.872793
    rCPN_84 (CPN_272 CPN_277) resistor r=0.000892608
    rCPN_83 (CPN_273 CPN_281) resistor r=0.000892608
    rCPN_82 (CPN_274 CPN_275) resistor r=0.000892608
    rCPN_81 (CPN_274 CPN_277) resistor r=0.131786
    rCPN_80 (CPN_275 CPN_450) resistor r=0.295734
    rCPN_79 (CPN_279 CPN_281) resistor r=0.136667
    rCPN_78 (CPN_283 CPN_285) resistor r=0.221511
    rCPN_77 (CPN_283 CPN_289) resistor r=0.0763552
    rCPN_76 (CPN_285 CPN_450) resistor r=0.75
    rCPN_75 (CPN_288 CPN_289) resistor r=1.2086
    rCPN_74 (CPN_288 CPN_310) resistor r=0.0578675
    rCPN_73 (CPN_290 CPN_292) resistor r=0.0388617
    rCPN_72 (CPN_290 CPN_311) resistor r=0.0578675
    rCPN_71 (CPN_292 CPN_293) resistor r=0.75
    rCPN_70 (CPN_293 CPN_446) resistor r=10
    rCPN_69 (CPN_295 CPN_296) resistor r=0.69951
    rCPN_68 (CPN_295 CPN_310) resistor r=0.0150388
    rCPN_67 (CPN_296 CPN_311) resistor r=0.0150388
    rCPN_66 (CPN_297 CPN_298) resistor r=0.975428
    rCPN_65 (CPN_297 CPN_306) resistor r=0.0763552
    rCPN_64 (CPN_298 CPN_310) resistor r=0.0578675
    rCPN_63 (CPN_301 CPN_303) resistor r=0.0465899
    rCPN_62 (CPN_301 CPN_312) resistor r=0.0578675
    rCPN_61 (CPN_303 CPN_304) resistor r=0.75
    rCPN_60 (CPN_304 CPN_443) resistor r=10
    rCPN_59 (CPN_306 CPN_307) resistor r=0.69951
    rCPN_58 (CPN_307 CPN_312) resistor r=0.0150388
    rCPN_57 (CPN_368 CPN_446) resistor r=5.57865
    rCPN_56 (CPN_381 CPN_429) resistor r=9.29775
    rCPN_55 (CPN_393 CPN_435) resistor r=10.0997
    rCPN_54 (CPN_395 CPN_435) resistor r=10.0997
    rCPN_53 (CPN_429 CPN_443) resistor r=10.8364
    rCPN_52 (CPN_434 CPN_435) resistor r=0.877078
    rCPN_51 (CPN_434 CPN_443) resistor r=37.9273
    rCPN_50 (CPN_449 CPN_450) resistor r=13
    rCPN_49 (CPN_449 MM22_ELT_d) resistor r=8.44
    rCP_96 (CP_22 CP_28) resistor r=58.3583
    rCP_95 (CP_22 CP_28) resistor r=4.16253
    rCP_94 (CP_22 CP_28) resistor r=58.3583
    rCP_93 (CP_22 CP_28) resistor r=4.16253
    rCP_92 (CP_25 CP_28) resistor r=58.3583
    rCP_91 (CP_25 CP_28) resistor r=6.30933
    rCP_90 (CP_25 CP_28) resistor r=58.3583
    rCP_89 (CP_25 CP_28) resistor r=6.30933
    rCP_88 (CP_28 CP_30) resistor r=14.9
    rCP_87 (CP_28 CP_53) resistor r=24.8333
    rCP_86 (CP_28 CP_50) resistor r=24.8333
    rCP_85 (CP_28 CP_61) resistor r=24.8333
    rCP_84 (CP_28 CP_58) resistor r=24.8333
    rCP_83 (CP_28 CP_82) resistor r=58.3583
    rCP_82 (CP_28 CP_85) resistor r=58.3583
    rCP_81 (CP_28 CP_53) resistor r=4.16253
    rCP_80 (CP_28 CP_30) resistor r=6.30933
    rCP_79 (CP_28 CP_61) resistor r=1.63969
    rCP_78 (CP_28 CP_50) resistor r=4.16253
    rCP_77 (CP_28 CP_82) resistor r=4.16253
    rCP_76 (CP_28 CP_58) resistor r=4.16253
    rCP_75 (CP_28 CP_85) resistor r=4.16253
    rCP_74 (CP_28 CP_30) resistor r=14.9
    rCP_73 (CP_28 CP_162) resistor r=40.975
    rCP_72 (CP_28 CP_53) resistor r=24.8333
    rCP_71 (CP_28 CP_50) resistor r=24.8333
    rCP_70 (CP_28 CP_61) resistor r=24.8333
    rCP_69 (CP_28 CP_58) resistor r=24.8333
    rCP_68 (CP_28 CP_82) resistor r=58.3583
    rCP_67 (CP_28 MM22_ELT_g) resistor r=7.45
    rCP_66 (CP_28 CP_53) resistor r=4.16253
    rCP_65 (CP_28 CP_30) resistor r=6.30933
    rCP_64 (CP_28 CP_61) resistor r=1.63969
    rCP_63 (CP_28 CP_50) resistor r=4.16253
    rCP_62 (CP_28 CP_82) resistor r=4.16253
    rCP_61 (CP_28 CP_58) resistor r=4.16253
    rCP_60 (CP_28 CP_85) resistor r=4.16253
    rCP_59 (CP_36 CP_39) resistor r=14.9
    rCP_58 (CP_36 CP_39) resistor r=6.30933
    rCP_57 (CP_36 CP_39) resistor r=14.9
    rCP_56 (CP_36 CP_39) resistor r=6.30933
    rCP_55 (CP_39 CP_42) resistor r=202.392
    rCP_54 (CP_39 CP_45) resistor r=202.392
    rCP_53 (CP_39 CP_69) resistor r=24.8333
    rCP_52 (CP_39 CP_66) resistor r=24.8333
    rCP_51 (CP_39 CP_77) resistor r=24.8333
    rCP_50 (CP_39 CP_74) resistor r=24.8333
    rCP_49 (CP_39 CP_90) resistor r=202.392
    rCP_48 (CP_39 CP_93) resistor r=202.392
    rCP_47 (CP_39 CP_42) resistor r=6.30933
    rCP_46 (CP_39 CP_69) resistor r=1.63969
    rCP_45 (CP_39 CP_77) resistor r=4.16253
    rCP_44 (CP_39 CP_45) resistor r=4.16253
    rCP_43 (CP_39 CP_66) resistor r=4.16253
    rCP_42 (CP_39 CP_90) resistor r=4.16253
    rCP_41 (CP_39 CP_74) resistor r=4.16253
    rCP_40 (CP_39 CP_93) resistor r=4.16253
    rCP_39 (CP_39 CP_164) resistor r=40.975
    rCP_38 (CP_39 CP_42) resistor r=202.392
    rCP_37 (CP_39 CP_45) resistor r=202.392
    rCP_36 (CP_39 CP_69) resistor r=24.8333
    rCP_35 (CP_39 CP_66) resistor r=24.8333
    rCP_34 (CP_39 CP_77) resistor r=24.8333
    rCP_33 (CP_39 CP_74) resistor r=24.8333
    rCP_32 (CP_39 CP_90) resistor r=202.392
    rCP_31 (CP_39 MM21_ELT_g) resistor r=7.45
    rCP_30 (CP_39 CP_42) resistor r=6.30933
    rCP_29 (CP_39 CP_69) resistor r=1.63969
    rCP_28 (CP_39 CP_77) resistor r=4.16253
    rCP_27 (CP_39 CP_45) resistor r=4.16253
    rCP_26 (CP_39 CP_66) resistor r=4.16253
    rCP_25 (CP_39 CP_90) resistor r=4.16253
    rCP_24 (CP_39 CP_74) resistor r=4.16253
    rCP_23 (CP_39 CP_93) resistor r=4.16253
    rCP_22 (CP_85 MM22_ELT_g) resistor r=50.9083
    rCP_21 (CP_93 MM21_ELT_g) resistor r=194.942
    rCP_20 (CP_132 CP_133) resistor r=10
    rCP_19 (CP_132 CP) resistor r=0.0875788
    rCP_18 (CP_133 CP_196) resistor r=13.5455
    rCP_17 (CP_162 CP_197) resistor r=3.725
    rCP_16 (CP_164 CP_197) resistor r=3.725
    rCP_15 (CP_196 CP_197) resistor r=3.725
ends DDFCNQD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: NR4UB2AD1_LVT_ELT
// View name: calibre
subckt NR4UB2AD1_LVT_ELT A1 A2 A3 A4 VDD VSS ZN
    MM22_ELT (MM22_ELT_d MM22_ELT_g MM22_ELT_s MM22_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.8675e-13 pd=1.34e-06 \
        ps=5.73e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM21_ELT (MM21_ELT_d MM21_ELT_g MM21_ELT_s MM21_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.8675e-13 pd=1.34e-06 \
        ps=5.73e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.8675e-13 pd=1.34e-06 \
        ps=5.73e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.8675e-13 pd=1.34e-06 \
        ps=5.73e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM16_ELT (MM16_ELT_d MM16_ELT_g MM16_ELT_s MM16_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM20_ELT (MM20_ELT_d MM20_ELT_g MM20_ELT_s MM20_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM19_ELT (MM19_ELT_d MM19_ELT_g MM19_ELT_s MM19_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.94775e-13 pd=3.66e-06 \
        ps=7.315e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet026_17 (net026_3 VSS) capacitor c=2.16319e-16
    cinet026_16 (net026_10 VSS) capacitor c=3.43917e-16
    cinet026_15 (net026_12 VSS) capacitor c=1.0443e-16
    cinet026_14 (net026_13 VSS) capacitor c=8.57514e-18
    cinet026_13 (net026_16 VSS) capacitor c=1.67931e-16
    cinet026_12 (net026_17 VSS) capacitor c=3.26907e-16
    cinet026_11 (net026_25 VSS) capacitor c=7.99748e-17
    cinet026_10 (net026_29 VSS) capacitor c=1.88316e-16
    cinet026_9 (net026_30 VSS) capacitor c=3.26704e-16
    cinet026_8 (net026_38 VSS) capacitor c=1.33782e-17
    cinet026_7 (net026_42 VSS) capacitor c=2.24908e-17
    cinet026_6 (net026_44 VSS) capacitor c=1.07074e-18
    cinet026_5 (net026_46 VSS) capacitor c=1.42934e-18
    cinet026_4 (net026_47 VSS) capacitor c=4.79047e-18
    cinet026_3 (net026_51 VSS) capacitor c=6.16123e-18
    cinet026_2 (net026_53 VSS) capacitor c=1.07074e-18
    cinet026_1 (net026_56 VSS) capacitor c=1.32762e-17
    cinet026_0 (net026_58 VSS) capacitor c=2.23492e-18
    ciVDD_11 (VDD_2 VSS) capacitor c=4.9091e-16
    ciVDD_10 (VDD_29 VSS) capacitor c=2.24488e-16
    ciVDD_9 (VDD_37 VSS) capacitor c=3.4485e-16
    ciVDD_8 (VDD_43 VSS) capacitor c=7.04006e-17
    ciVDD_7 (VDD_46 VSS) capacitor c=6.77184e-18
    ciVDD_6 (VDD_52 VSS) capacitor c=2.24908e-17
    ciVDD_5 (VDD_53 VSS) capacitor c=1.46047e-18
    ciVDD_4 (VDD_54 VSS) capacitor c=4.05131e-18
    ciVDD_3 (VDD_57 VSS) capacitor c=1.11099e-18
    ciVDD_2 (VDD_61 VSS) capacitor c=1.11099e-18
    ciVDD_1 (VDD_63 VSS) capacitor c=6.12289e-18
    ciVDD_0 (VDD_66 VSS) capacitor c=1.32762e-17
    ciZN_27 (ZN_3 VSS) capacitor c=5.34056e-17
    ciZN_26 (ZN_4 VSS) capacitor c=1.11612e-16
    ciZN_25 (ZN_8 VSS) capacitor c=1.90292e-16
    ciZN_24 (ZN_9 VSS) capacitor c=3.29485e-16
    ciZN_23 (ZN_17 VSS) capacitor c=2.00661e-17
    ciZN_22 (ZN_18 VSS) capacitor c=1.43047e-17
    ciZN_21 (ZN_19 VSS) capacitor c=1.47567e-17
    ciZN_20 (ZN_20 VSS) capacitor c=1.12021e-17
    ciZN_19 (ZN_22 VSS) capacitor c=2.98493e-17
    ciZN_18 (ZN_23 VSS) capacitor c=9.11534e-17
    ciZN_17 (ZN_25 VSS) capacitor c=2.27846e-17
    ciZN_16 (ZN_29 VSS) capacitor c=2.17488e-16
    ciZN_15 (ZN_30 VSS) capacitor c=3.42052e-16
    ciZN_14 (ZN_40 VSS) capacitor c=4.93176e-17
    ciZN_13 (ZN_41 VSS) capacitor c=1.11989e-16
    ciZN_12 (ZN_43 VSS) capacitor c=1.38996e-16
    ciZN_11 (ZN_47 VSS) capacitor c=4.93176e-17
    ciZN_10 (ZN_48 VSS) capacitor c=1.11989e-16
    ciZN_9 (ZN_50 VSS) capacitor c=1.4516e-16
    ciZN_8 (ZN_54 VSS) capacitor c=4.9582e-17
    ciZN_7 (ZN_55 VSS) capacitor c=1.11989e-16
    ciZN_6 (ZN_57 VSS) capacitor c=5.91716e-17
    ciZN_5 (ZN_59 VSS) capacitor c=4.47251e-17
    ciZN_4 (ZN_62 VSS) capacitor c=1.1192e-17
    ciZN_3 (ZN_63 VSS) capacitor c=9.33598e-18
    ciZN_2 (ZN_64 VSS) capacitor c=1.19824e-17
    ciZN_1 (ZN_65 VSS) capacitor c=1.19877e-17
    ciZN_0 (ZN_66 VSS) capacitor c=1.19824e-17
    ciVSS_26 (VSS_2 VSS) capacitor c=6.19136e-17
    ciVSS_25 (VSS_11 VSS) capacitor c=5.10978e-17
    ciVSS_24 (VSS_14 VSS) capacitor c=8.41791e-17
    ciVSS_23 (VSS_24 VSS) capacitor c=4.91677e-17
    ciVSS_22 (VSS_27 VSS) capacitor c=8.47613e-17
    ciVSS_21 (VSS_37 VSS) capacitor c=4.91677e-17
    ciVSS_20 (VSS_40 VSS) capacitor c=8.36951e-17
    ciVSS_19 (VSS_50 VSS) capacitor c=4.57304e-17
    ciVSS_18 (VSS_58 VSS) capacitor c=6.96275e-17
    ciVSS_17 (VSS_61 VSS) capacitor c=3.58509e-18
    ciVSS_16 (VSS_62 VSS) capacitor c=3.58509e-18
    ciVSS_15 (VSS_63 VSS) capacitor c=3.58509e-18
    ciVSS_14 (VSS_64 VSS) capacitor c=3.58509e-18
    ciVSS_13 (VSS_73 VSS) capacitor c=2.89064e-18
    ciVSS_12 (VSS_77 VSS) capacitor c=4.13255e-18
    ciVSS_11 (VSS_81 VSS) capacitor c=1.42647e-18
    ciVSS_10 (VSS_82 VSS) capacitor c=2.59797e-18
    ciVSS_9 (VSS_86 VSS) capacitor c=4.13255e-18
    ciVSS_8 (VSS_90 VSS) capacitor c=1.18268e-18
    ciVSS_7 (VSS_91 VSS) capacitor c=2.15935e-18
    ciVSS_6 (VSS_95 VSS) capacitor c=4.13255e-18
    ciVSS_5 (VSS_99 VSS) capacitor c=1.42647e-18
    ciVSS_4 (VSS_100 VSS) capacitor c=2.64401e-18
    ciVSS_3 (VSS_101 VSS) capacitor c=9.80172e-17
    ciVSS_2 (VSS_102 VSS) capacitor c=1.01594e-16
    ciVSS_1 (VSS_103 VSS) capacitor c=9.9539e-17
    ciVSS_0 (VSS_104 VSS) capacitor c=8.06646e-17
    ciA4_20 (A4_32 VSS) capacitor c=2.19038e-18
    ciA4_19 (A4_35 VSS) capacitor c=3.12083e-18
    ciA4_18 (A4_38 VSS) capacitor c=1.89124e-16
    ciA4_17 (A4_40 VSS) capacitor c=4.53212e-18
    ciA4_16 (A4_43 VSS) capacitor c=4.22299e-18
    ciA4_15 (A4_46 VSS) capacitor c=6.00563e-16
    ciA4_14 (A4_48 VSS) capacitor c=2.23697e-17
    ciA4_13 (A4_56 VSS) capacitor c=2.42417e-17
    ciA4_12 (A4_64 VSS) capacitor c=1.32776e-17
    ciA4_11 (A4_72 VSS) capacitor c=1.51948e-17
    ciA4_10 (A4_80 VSS) capacitor c=2.96645e-18
    ciA4_9 (A4_103 VSS) capacitor c=3.00572e-18
    ciA4_8 (A4_111 VSS) capacitor c=5.54334e-16
    ciA4_7 (A4_117 VSS) capacitor c=3.00572e-18
    ciA4_6 (A4_122 VSS) capacitor c=1.90122e-17
    ciA4_5 (A4_130 VSS) capacitor c=1.51948e-17
    ciA4_4 (A4_141 VSS) capacitor c=2.22299e-18
    ciA4_3 (A4 VSS) capacitor c=6.67885e-17
    ciA4_2 (A4_267 VSS) capacitor c=3.77556e-17
    ciA4_1 (A4_292 VSS) capacitor c=3.95883e-17
    ciA4_0 (A4_293 VSS) capacitor c=7.12206e-19
    cinet027_17 (net027_3 VSS) capacitor c=2.16281e-16
    cinet027_16 (net027_11 VSS) capacitor c=3.41643e-16
    cinet027_15 (net027_12 VSS) capacitor c=1.35854e-16
    cinet027_14 (net027_13 VSS) capacitor c=1.1927e-17
    cinet027_13 (net027_16 VSS) capacitor c=1.52416e-16
    cinet027_12 (net027_17 VSS) capacitor c=3.27054e-16
    cinet027_11 (net027_25 VSS) capacitor c=9.27354e-17
    cinet027_10 (net027_29 VSS) capacitor c=1.5873e-16
    cinet027_9 (net027_30 VSS) capacitor c=3.37331e-16
    cinet027_8 (net027_38 VSS) capacitor c=1.56292e-17
    cinet027_7 (net027_42 VSS) capacitor c=2.49506e-17
    cinet027_6 (net027_43 VSS) capacitor c=1.4472e-18
    cinet027_5 (net027_44 VSS) capacitor c=4.05856e-18
    cinet027_4 (net027_46 VSS) capacitor c=2.23677e-18
    cinet027_3 (net027_47 VSS) capacitor c=1.11099e-18
    cinet027_2 (net027_51 VSS) capacitor c=1.11099e-18
    cinet027_1 (net027_53 VSS) capacitor c=7.38101e-18
    cinet027_0 (net027_56 VSS) capacitor c=1.32762e-17
    ciA3_21 (A3_32 VSS) capacitor c=2.19038e-18
    ciA3_20 (A3_35 VSS) capacitor c=3.12083e-18
    ciA3_19 (A3_38 VSS) capacitor c=1.85874e-16
    ciA3_18 (A3_40 VSS) capacitor c=2e-18
    ciA3_17 (A3_43 VSS) capacitor c=7.45262e-18
    ciA3_16 (A3_46 VSS) capacitor c=5.71404e-16
    ciA3_15 (A3_48 VSS) capacitor c=2.2416e-17
    ciA3_14 (A3_56 VSS) capacitor c=2.14169e-17
    ciA3_13 (A3_64 VSS) capacitor c=8.69531e-18
    ciA3_12 (A3_72 VSS) capacitor c=2.27132e-17
    ciA3_11 (A3_80 VSS) capacitor c=3.00043e-18
    ciA3_10 (A3_103 VSS) capacitor c=5.80827e-18
    ciA3_9 (A3_111 VSS) capacitor c=5.84705e-16
    ciA3_8 (A3_117 VSS) capacitor c=5.80827e-18
    ciA3_7 (A3_122 VSS) capacitor c=2.17776e-17
    ciA3_6 (A3_130 VSS) capacitor c=2.22788e-17
    ciA3_5 (A3_138 VSS) capacitor c=6.48499e-18
    ciA3_4 (A3_141 VSS) capacitor c=4.21727e-18
    ciA3_3 (A3 VSS) capacitor c=4.34676e-17
    ciA3_2 (A3_267 VSS) capacitor c=3.69412e-17
    ciA3_1 (A3_292 VSS) capacitor c=3.28202e-17
    ciA3_0 (A3_293 VSS) capacitor c=7.12206e-19
    cinet29_18 (net29_3 VSS) capacitor c=2.38508e-16
    cinet29_17 (net29_11 VSS) capacitor c=3.8903e-16
    cinet29_16 (net29_12 VSS) capacitor c=1.02129e-16
    cinet29_15 (net29_13 VSS) capacitor c=1.15273e-17
    cinet29_14 (net29_15 VSS) capacitor c=7.39969e-17
    cinet29_13 (net29_16 VSS) capacitor c=2.51328e-17
    cinet29_12 (net29_17 VSS) capacitor c=1.38192e-17
    cinet29_11 (net29_20 VSS) capacitor c=8.22899e-17
    cinet29_10 (net29_21 VSS) capacitor c=3.27054e-16
    cinet29_9 (net29_29 VSS) capacitor c=7.60361e-17
    cinet29_8 (net29_33 VSS) capacitor c=2.60675e-16
    cinet29_7 (net29_34 VSS) capacitor c=3.37066e-16
    cinet29_6 (net29_42 VSS) capacitor c=1.33782e-17
    cinet29_5 (net29_46 VSS) capacitor c=1.32762e-17
    cinet29_4 (net29_48 VSS) capacitor c=4.26933e-18
    cinet29_3 (net29_51 VSS) capacitor c=1.11099e-18
    cinet29_2 (net29_55 VSS) capacitor c=1.11099e-18
    cinet29_1 (net29_57 VSS) capacitor c=6.09145e-18
    cinet29_0 (net29_60 VSS) capacitor c=1.32762e-17
    ciA2_21 (A2_32 VSS) capacitor c=2.19038e-18
    ciA2_20 (A2_35 VSS) capacitor c=3.12083e-18
    ciA2_19 (A2_38 VSS) capacitor c=1.8467e-16
    ciA2_18 (A2_40 VSS) capacitor c=5.0777e-18
    ciA2_17 (A2_43 VSS) capacitor c=4.34066e-18
    ciA2_16 (A2_46 VSS) capacitor c=6.44941e-16
    ciA2_15 (A2_48 VSS) capacitor c=2.2416e-17
    ciA2_14 (A2_56 VSS) capacitor c=2.16333e-17
    ciA2_13 (A2_64 VSS) capacitor c=1.32776e-17
    ciA2_12 (A2_72 VSS) capacitor c=1.52235e-17
    ciA2_11 (A2_80 VSS) capacitor c=3.00043e-18
    ciA2_10 (A2_103 VSS) capacitor c=2.8962e-18
    ciA2_9 (A2_111 VSS) capacitor c=5.8459e-16
    ciA2_8 (A2_117 VSS) capacitor c=5.82006e-18
    ciA2_7 (A2_122 VSS) capacitor c=1.92627e-17
    ciA2_6 (A2_130 VSS) capacitor c=2.48588e-17
    ciA2_5 (A2_138 VSS) capacitor c=3.16802e-18
    ciA2_4 (A2_141 VSS) capacitor c=7.45262e-18
    ciA2_3 (A2 VSS) capacitor c=6.36858e-17
    ciA2_2 (A2_267 VSS) capacitor c=3.61043e-17
    ciA2_1 (A2_292 VSS) capacitor c=3.93125e-17
    ciA2_0 (A2_293 VSS) capacitor c=7.12206e-19
    ciA1_19 (A1_32 VSS) capacitor c=2.22299e-18
    ciA1_18 (A1_38 VSS) capacitor c=1.84558e-16
    ciA1_17 (A1_43 VSS) capacitor c=2.22299e-18
    ciA1_16 (A1_46 VSS) capacitor c=5.54475e-16
    ciA1_15 (A1_48 VSS) capacitor c=2.2416e-17
    ciA1_14 (A1_56 VSS) capacitor c=2.18598e-17
    ciA1_13 (A1_64 VSS) capacitor c=1.36965e-17
    ciA1_12 (A1_72 VSS) capacitor c=1.51948e-17
    ciA1_11 (A1_80 VSS) capacitor c=4.24886e-18
    ciA1_10 (A1_103 VSS) capacitor c=2.8962e-18
    ciA1_9 (A1_111 VSS) capacitor c=6.16849e-16
    ciA1_8 (A1_117 VSS) capacitor c=5.6586e-18
    ciA1_7 (A1_122 VSS) capacitor c=1.72738e-17
    ciA1_6 (A1_130 VSS) capacitor c=2.48588e-17
    ciA1_5 (A1_138 VSS) capacitor c=3.5418e-18
    ciA1_4 (A1_141 VSS) capacitor c=7.89217e-18
    ciA1_3 (A1 VSS) capacitor c=3.90874e-17
    ciA1_2 (A1_267 VSS) capacitor c=4.24615e-17
    ciA1_1 (A1_292 VSS) capacitor c=2.715e-17
    ciA1_0 (A1_293 VSS) capacitor c=7.12206e-19
    rnet026_77 (MM18_ELT_d net026) resistor r=0.01
    rnet026_76 (net026_1 net026_3) resistor r=0.368491
    rnet026_75 (net026_1 net026_13) resistor r=0.101293
    rnet026_74 (net026_3 net026_10) resistor r=8.66667
    rnet026_73 (net026_3 net026_6) resistor r=0.701887
    rnet026_72 (net026_6 net026_10) resistor r=8.66667
    rnet026_71 (net026_6 net026_9) resistor r=0.467925
    rnet026_70 (net026_9 net026_10) resistor r=26
    rnet026_69 (net026_10 MM17_ELT_s) resistor r=0.850556
    rnet026_68 (net026_10 MM15_ELT_s) resistor r=0.850556
    rnet026_67 (net026_10 net026_57) resistor r=13.0961
    rnet026_66 (net026_12 net026_13) resistor r=0.904492
    rnet026_65 (net026_12 net026_38) resistor r=0.0493155
    rnet026_64 (net026_14 net026_16) resistor r=0.481245
    rnet026_63 (net026_14 net026_38) resistor r=0.0420801
    rnet026_62 (net026_16 net026_17) resistor r=8.66667
    rnet026_61 (net026_16 net026_19) resistor r=0.704261
    rnet026_60 (net026_17 MM16_ELT_d) resistor r=32.3614
    rnet026_59 (net026_19 net026_20) resistor r=8.66667
    rnet026_58 (net026_19 net026_22) resistor r=0.469507
    rnet026_57 (net026_20 MM16_ELT_d) resistor r=16.1807
    rnet026_56 (net026_20 net026_23) resistor r=32.3614
    rnet026_55 (net026_22 net026_23) resistor r=26
    rnet026_54 (net026_25 net026_26) resistor r=0.431759
    rnet026_53 (net026_25 net026_27) resistor r=0.101293
    rnet026_52 (net026_26 net026_38) resistor r=0.0493155
    rnet026_51 (net026_27 net026_29) resistor r=0.481245
    rnet026_50 (net026_29 net026_30) resistor r=8.66667
    rnet026_49 (net026_29 net026_32) resistor r=0.704261
    rnet026_48 (net026_30 net026) resistor r=32.3614
    rnet026_47 (net026_32 net026_33) resistor r=8.66667
    rnet026_46 (net026_32 net026_35) resistor r=0.469507
    rnet026_45 (net026_33 net026) resistor r=16.1807
    rnet026_44 (net026_33 net026_36) resistor r=32.3614
    rnet026_43 (net026_35 net026_36) resistor r=26
    rnet026_42 (net026_39 net026_42) resistor r=31.2341
    rnet026_41 (net026_39 net026_43) resistor r=9.04595
    rnet026_40 (net026_40 net026_42) resistor r=31.2341
    rnet026_39 (net026_40 net026_46) resistor r=9.04062
    rnet026_38 (MM15_ELT_s net026_42) resistor r=6.12113
    rnet026_37 (MM15_ELT_s net026_44) resistor r=12.3172
    rnet026_36 (MM15_ELT_s net026_44) resistor r=1.62887
    rnet026_35 (MM15_ELT_s net026_47) resistor r=2.55965
    rnet026_34 (net026_43 net026_44) resistor r=12.3172
    rnet026_33 (net026_45 net026_47) resistor r=14.4784
    rnet026_32 (net026_45 net026_58) resistor r=10.5593
    rnet026_31 (net026_46 net026_47) resistor r=14.4784
    rnet026_30 (MM17_ELT_s net026_51) resistor r=2.55965
    rnet026_29 (MM17_ELT_s net026_53) resistor r=12.3172
    rnet026_28 (MM17_ELT_s net026_53) resistor r=1.62887
    rnet026_27 (MM17_ELT_s net026_56) resistor r=6.12113
    rnet026_26 (net026_49 net026_51) resistor r=14.4784
    rnet026_25 (net026_49 net026_55) resistor r=9.04062
    rnet026_24 (net026_50 net026_51) resistor r=14.4784
    rnet026_23 (net026_50 net026_58) resistor r=10.5593
    rnet026_22 (net026_52 net026_53) resistor r=12.3172
    rnet026_21 (net026_52 net026_54) resistor r=9.04595
    rnet026_20 (net026_54 net026_56) resistor r=31.2341
    rnet026_19 (net026_55 net026_56) resistor r=31.2341
    rnet026_18 (net026_57 net026_58) resistor r=0.730683
    rVDD_78 (MM19_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_77 (MM11_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_76 (MM20_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_75 (MM15_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_74 (MM17_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_73 (MM16_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_72 (MM18_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_71 (MM10_ELT_b VDD_19) resistor r=8.66667
    rVDD_70 (MM10_ELT_b VDD_22) resistor r=8.66667
    rVDD_69 (MM10_ELT_b VDD_25) resistor r=8.66667
    rVDD_68 (MM10_ELT_b VDD_40) resistor r=8.66667
    rVDD_67 (MM10_ELT_b VDD_43) resistor r=26
    rVDD_66 (MM10_ELT_b VDD_17) resistor r=45.0133
    rVDD_65 (VDD_2 VDD_25) resistor r=0.0988182
    rVDD_64 (VDD_2 VDD_46) resistor r=0.040191
    rVDD_63 (VDD VDD_7) resistor r=0.102771
    rVDD_62 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_61 (VDD_7 VDD_10) resistor r=0.237505
    rVDD_60 (VDD_8 VDD_11) resistor r=67.52
    rVDD_59 (VDD_10 VDD_11) resistor r=8.66667
    rVDD_58 (VDD_10 VDD_13) resistor r=0.237505
    rVDD_57 (VDD_11 VDD_14) resistor r=67.52
    rVDD_56 (VDD_13 VDD_14) resistor r=8.66667
    rVDD_55 (VDD_13 VDD_16) resistor r=0.237505
    rVDD_54 (VDD_14 VDD_17) resistor r=67.52
    rVDD_53 (VDD_16 VDD_17) resistor r=8.66667
    rVDD_52 (VDD_16 VDD_19) resistor r=0.237505
    rVDD_51 (VDD_19 VDD_22) resistor r=0.237505
    rVDD_50 (VDD_22 VDD_25) resistor r=0.237505
    rVDD_49 (VDD_27 VDD_36) resistor r=0.322982
    rVDD_48 (VDD_27 VDD_46) resistor r=0.0530988
    rVDD_47 (VDD_29 VDD_37) resistor r=8.66667
    rVDD_46 (VDD_29 VDD_33) resistor r=0.530929
    rVDD_45 (VDD_33 VDD_37) resistor r=8.66667
    rVDD_44 (VDD_33 VDD_36) resistor r=0.353953
    rVDD_43 (VDD_36 VDD_37) resistor r=26
    rVDD_42 (VDD_37 MM18_ELT_s) resistor r=0.850556
    rVDD_41 (VDD_37 MM16_ELT_s) resistor r=0.850556
    rVDD_40 (VDD_37 VDD_67) resistor r=13.0961
    rVDD_39 (VDD_38 VDD_40) resistor r=0.0711491
    rVDD_38 (VDD_38 VDD_46) resistor r=0.040191
    rVDD_37 (VDD_40 VDD_43) resistor r=0.158109
    rVDD_36 (VDD_49 VDD_52) resistor r=31.2341
    rVDD_35 (VDD_49 VDD_53) resistor r=9.04595
    rVDD_34 (VDD_50 VDD_52) resistor r=31.2341
    rVDD_33 (VDD_50 VDD_56) resistor r=9.04062
    rVDD_32 (MM16_ELT_s VDD_52) resistor r=6.12113
    rVDD_31 (MM16_ELT_s VDD_54) resistor r=12.3172
    rVDD_30 (MM16_ELT_s VDD_54) resistor r=1.62887
    rVDD_29 (MM16_ELT_s VDD_57) resistor r=2.55965
    rVDD_28 (VDD_53 VDD_54) resistor r=12.3172
    rVDD_27 (VDD_55 VDD_57) resistor r=14.4784
    rVDD_26 (VDD_55 VDD_68) resistor r=10.5593
    rVDD_25 (VDD_56 VDD_57) resistor r=14.4784
    rVDD_24 (MM18_ELT_s VDD_61) resistor r=2.55965
    rVDD_23 (MM18_ELT_s VDD_63) resistor r=12.3172
    rVDD_22 (MM18_ELT_s VDD_63) resistor r=1.62887
    rVDD_21 (MM18_ELT_s VDD_66) resistor r=6.12113
    rVDD_20 (VDD_59 VDD_61) resistor r=14.4784
    rVDD_19 (VDD_59 VDD_65) resistor r=9.04062
    rVDD_18 (VDD_60 VDD_61) resistor r=14.4784
    rVDD_17 (VDD_60 VDD_68) resistor r=10.5593
    rVDD_16 (VDD_62 VDD_63) resistor r=12.3172
    rVDD_15 (VDD_62 VDD_64) resistor r=9.04595
    rVDD_14 (VDD_64 VDD_66) resistor r=31.2341
    rVDD_13 (VDD_65 VDD_66) resistor r=31.2341
    rVDD_12 (VDD_67 VDD_68) resistor r=0.730683
    rZN_85 (ZN_1 ZN_3) resistor r=0.399564
    rZN_84 (ZN_1 ZN_18) resistor r=0.0988854
    rZN_83 (ZN_3 ZN_4) resistor r=13
    rZN_82 (ZN_4 MM2_ELT_d) resistor r=8.44
    rZN_81 (ZN_6 ZN_8) resistor r=0.522097
    rZN_80 (ZN_6 ZN_20) resistor r=0.0960605
    rZN_79 (ZN_8 ZN_9) resistor r=8.66667
    rZN_78 (ZN_8 ZN_11) resistor r=0.639302
    rZN_77 (ZN_9 MM10_ELT_d) resistor r=32.3614
    rZN_76 (ZN_11 ZN_12) resistor r=8.66667
    rZN_75 (ZN_11 ZN_14) resistor r=0.426202
    rZN_74 (ZN_12 MM10_ELT_d) resistor r=16.1807
    rZN_73 (ZN_12 ZN_15) resistor r=32.3614
    rZN_72 (ZN_14 ZN_15) resistor r=26
    rZN_71 (ZN_17 ZN_18) resistor r=0.152871
    rZN_70 (ZN_17 ZN_62) resistor r=0.0546575
    rZN_69 (ZN_19 ZN_20) resistor r=0.165856
    rZN_68 (ZN_19 ZN_63) resistor r=0.0728016
    rZN_67 (ZN_21 ZN_22) resistor r=0.368427
    rZN_66 (ZN_21 ZN_62) resistor r=0.036054
    rZN_65 (ZN_22 ZN_63) resistor r=0.0189199
    rZN_64 (ZN_23 ZN_24) resistor r=0.88714
    rZN_63 (ZN_23 ZN_64) resistor r=0.0546575
    rZN_62 (ZN_24 ZN_62) resistor r=0.0546575
    rZN_61 (ZN_25 ZN_26) resistor r=0.165856
    rZN_60 (ZN_25 ZN_27) resistor r=0.0960605
    rZN_59 (ZN_26 ZN_63) resistor r=0.0728016
    rZN_58 (ZN_27 ZN_29) resistor r=0.539932
    rZN_57 (ZN_29 ZN_30) resistor r=8.66667
    rZN_56 (ZN_29 ZN_32) resistor r=0.661141
    rZN_55 (ZN_30 MM19_ELT_d) resistor r=32.3614
    rZN_54 (ZN_32 ZN_33) resistor r=8.66667
    rZN_53 (ZN_32 ZN_35) resistor r=0.440761
    rZN_52 (ZN_33 MM19_ELT_d) resistor r=16.1807
    rZN_51 (ZN_33 ZN_36) resistor r=32.3614
    rZN_50 (ZN_35 ZN_36) resistor r=26
    rZN_49 (ZN_38 ZN_40) resistor r=0.399564
    rZN_48 (ZN_38 ZN_64) resistor r=0.036054
    rZN_47 (ZN_40 ZN_41) resistor r=13
    rZN_46 (ZN_41 MM1_ELT_d) resistor r=8.44
    rZN_45 (ZN_43 ZN_44) resistor r=1.36577
    rZN_44 (ZN_43 ZN_65) resistor r=0.0546575
    rZN_43 (ZN_44 ZN_64) resistor r=0.0546575
    rZN_42 (ZN_45 ZN_47) resistor r=0.399564
    rZN_41 (ZN_45 ZN_65) resistor r=0.036054
    rZN_40 (ZN_47 ZN_48) resistor r=13
    rZN_39 (ZN_48 MM21_ELT_d) resistor r=8.44
    rZN_38 (ZN_50 ZN_51) resistor r=1.36577
    rZN_37 (ZN_50 ZN_66) resistor r=0.0546575
    rZN_36 (ZN_51 ZN_65) resistor r=0.0546575
    rZN_35 (ZN_52 ZN_54) resistor r=0.399564
    rZN_34 (ZN_52 ZN_66) resistor r=0.036054
    rZN_33 (ZN_54 ZN_55) resistor r=13
    rZN_32 (ZN_55 MM22_ELT_d) resistor r=8.44
    rZN_31 (ZN_57 ZN_58) resistor r=0.313108
    rZN_30 (ZN_57 ZN_59) resistor r=0.0959533
    rZN_29 (ZN_58 ZN_66) resistor r=0.0546575
    rZN_28 (ZN_59 ZN) resistor r=0.0792031
    rVSS_131 (MM1_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_130 (MM21_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_129 (MM22_ELT_b MM2_ELT_b) resistor r=0.01
    rVSS_128 (MM2_ELT_b VSS_33) resistor r=8.66667
    rVSS_127 (MM2_ELT_b VSS_43) resistor r=8.66667
    rVSS_126 (MM2_ELT_b VSS_46) resistor r=8.66667
    rVSS_125 (MM2_ELT_b VSS_55) resistor r=8.66667
    rVSS_124 (MM2_ELT_b VSS_58) resistor r=26
    rVSS_123 (MM2_ELT_b VSS_31) resistor r=43.1485
    rVSS_122 (VSS_2 VSS_7) resistor r=0.114629
    rVSS_121 (VSS_2 VSS_61) resistor r=0.0221536
    rVSS_120 (VSS VSS_7) resistor r=0.100795
    rVSS_119 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_118 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_117 (VSS_9 VSS_11) resistor r=0.404892
    rVSS_116 (VSS_9 VSS_61) resistor r=0.0882043
    rVSS_115 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_114 (VSS_12 MM2_ELT_s) resistor r=4.46703
    rVSS_113 (VSS_12 VSS_101) resistor r=5.00251
    rVSS_112 (VSS_14 VSS_20) resistor r=0.114629
    rVSS_111 (VSS_14 VSS_62) resistor r=0.0221536
    rVSS_110 (VSS_15 VSS_17) resistor r=0.08696
    rVSS_109 (VSS_15 VSS_61) resistor r=0.0221536
    rVSS_108 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_107 (VSS_17 VSS_20) resistor r=0.237164
    rVSS_106 (VSS_18 VSS_21) resistor r=64.7228
    rVSS_105 (VSS_20 VSS_21) resistor r=8.66667
    rVSS_104 (VSS_21 VSS_31) resistor r=64.7228
    rVSS_103 (VSS_22 VSS_24) resistor r=0.404892
    rVSS_102 (VSS_22 VSS_62) resistor r=0.0882043
    rVSS_101 (VSS_24 VSS_25) resistor r=8.66667
    rVSS_100 (VSS_25 MM1_ELT_s) resistor r=4.46703
    rVSS_99 (VSS_25 VSS_102) resistor r=5.00251
    rVSS_98 (VSS_27 VSS_33) resistor r=0.114629
    rVSS_97 (VSS_27 VSS_63) resistor r=0.0221536
    rVSS_96 (VSS_28 VSS_30) resistor r=0.08696
    rVSS_95 (VSS_28 VSS_62) resistor r=0.0221536
    rVSS_94 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_93 (VSS_30 VSS_33) resistor r=0.237164
    rVSS_92 (VSS_35 VSS_37) resistor r=0.404892
    rVSS_91 (VSS_35 VSS_63) resistor r=0.0882043
    rVSS_90 (VSS_37 VSS_38) resistor r=8.66667
    rVSS_89 (VSS_38 MM21_ELT_s) resistor r=4.46703
    rVSS_88 (VSS_38 VSS_103) resistor r=5.00251
    rVSS_87 (VSS_40 VSS_46) resistor r=0.114629
    rVSS_86 (VSS_40 VSS_64) resistor r=0.0221536
    rVSS_85 (VSS_41 VSS_43) resistor r=0.08696
    rVSS_84 (VSS_41 VSS_63) resistor r=0.0221536
    rVSS_83 (VSS_43 VSS_46) resistor r=0.237164
    rVSS_82 (VSS_48 VSS_50) resistor r=0.404892
    rVSS_81 (VSS_48 VSS_64) resistor r=0.0882043
    rVSS_80 (VSS_50 VSS_51) resistor r=8.66667
    rVSS_79 (VSS_51 MM22_ELT_s) resistor r=4.46703
    rVSS_78 (VSS_51 VSS_104) resistor r=5.00251
    rVSS_77 (VSS_53 VSS_55) resistor r=0.08696
    rVSS_76 (VSS_53 VSS_64) resistor r=0.0221536
    rVSS_75 (VSS_55 VSS_58) resistor r=0.158109
    rVSS_74 (VSS_65 VSS_68) resistor r=21.1301
    rVSS_73 (VSS_65 VSS_70) resistor r=9.43134
    rVSS_72 (VSS_66 VSS_68) resistor r=21.1301
    rVSS_71 (VSS_66 VSS_72) resistor r=9.4369
    rVSS_70 (MM2_ELT_s VSS_68) resistor r=4.557
    rVSS_69 (MM2_ELT_s VSS_71) resistor r=2.67027
    rVSS_68 (MM2_ELT_s VSS_73) resistor r=12.8495
    rVSS_67 (MM2_ELT_s VSS_73) resistor r=1.69926
    rVSS_66 (VSS_69 VSS_71) resistor r=15.1041
    rVSS_65 (VSS_69 VSS_101) resistor r=17.1506
    rVSS_64 (VSS_70 VSS_71) resistor r=15.1041
    rVSS_63 (VSS_72 VSS_73) resistor r=12.8495
    rVSS_62 (VSS_74 VSS_77) resistor r=21.1301
    rVSS_61 (VSS_74 VSS_79) resistor r=9.43134
    rVSS_60 (VSS_75 VSS_77) resistor r=21.1301
    rVSS_59 (VSS_75 VSS_81) resistor r=9.4369
    rVSS_58 (MM1_ELT_s VSS_77) resistor r=4.557
    rVSS_57 (MM1_ELT_s VSS_80) resistor r=2.67027
    rVSS_56 (MM1_ELT_s VSS_82) resistor r=12.8495
    rVSS_55 (MM1_ELT_s VSS_82) resistor r=1.69926
    rVSS_54 (VSS_78 VSS_80) resistor r=15.1041
    rVSS_53 (VSS_78 VSS_102) resistor r=17.1506
    rVSS_52 (VSS_79 VSS_80) resistor r=15.1041
    rVSS_51 (VSS_81 VSS_82) resistor r=12.8495
    rVSS_50 (VSS_83 VSS_86) resistor r=21.1301
    rVSS_49 (VSS_83 VSS_88) resistor r=9.43134
    rVSS_48 (VSS_84 VSS_86) resistor r=21.1301
    rVSS_47 (VSS_84 VSS_90) resistor r=9.4369
    rVSS_46 (MM21_ELT_s VSS_86) resistor r=4.557
    rVSS_45 (MM21_ELT_s VSS_89) resistor r=2.67027
    rVSS_44 (MM21_ELT_s VSS_91) resistor r=12.8495
    rVSS_43 (MM21_ELT_s VSS_91) resistor r=1.69926
    rVSS_42 (VSS_87 VSS_89) resistor r=15.1041
    rVSS_41 (VSS_87 VSS_103) resistor r=17.1506
    rVSS_40 (VSS_88 VSS_89) resistor r=15.1041
    rVSS_39 (VSS_90 VSS_91) resistor r=12.8495
    rVSS_38 (VSS_92 VSS_95) resistor r=21.1301
    rVSS_37 (VSS_92 VSS_97) resistor r=9.43134
    rVSS_36 (VSS_93 VSS_95) resistor r=21.1301
    rVSS_35 (VSS_93 VSS_99) resistor r=9.4369
    rVSS_34 (MM22_ELT_s VSS_95) resistor r=4.557
    rVSS_33 (MM22_ELT_s VSS_98) resistor r=2.67027
    rVSS_32 (MM22_ELT_s VSS_100) resistor r=12.8495
    rVSS_31 (MM22_ELT_s VSS_100) resistor r=1.69926
    rVSS_30 (VSS_96 VSS_98) resistor r=15.1041
    rVSS_29 (VSS_96 VSS_104) resistor r=17.1506
    rVSS_28 (VSS_97 VSS_98) resistor r=15.1041
    rVSS_27 (VSS_99 VSS_100) resistor r=12.8495
    rA4_143 (A4_32 A4_38) resistor r=58.3583
    rA4_142 (A4_32 A4_38) resistor r=4.16253
    rA4_141 (A4_32 A4_38) resistor r=58.3583
    rA4_140 (A4_32 A4_38) resistor r=4.16253
    rA4_139 (A4_35 A4_38) resistor r=58.3583
    rA4_138 (A4_35 A4_38) resistor r=4.16253
    rA4_137 (A4_35 A4_38) resistor r=58.3583
    rA4_136 (A4_35 A4_38) resistor r=4.16253
    rA4_135 (A4_38 A4_51) resistor r=24.8333
    rA4_134 (A4_38 A4_48) resistor r=24.8333
    rA4_133 (A4_38 A4_59) resistor r=24.8333
    rA4_132 (A4_38 A4_56) resistor r=24.8333
    rA4_131 (A4_38 A4_80) resistor r=58.3583
    rA4_130 (A4_38 A4_83) resistor r=58.3583
    rA4_129 (A4_38 A4_88) resistor r=14.9
    rA4_128 (A4_38 A4_51) resistor r=4.16253
    rA4_127 (A4_38 A4_59) resistor r=4.16253
    rA4_126 (A4_38 A4_48) resistor r=4.16253
    rA4_125 (A4_38 A4_80) resistor r=4.16253
    rA4_124 (A4_38 A4_88) resistor r=6.30933
    rA4_123 (A4_38 A4_83) resistor r=6.30933
    rA4_122 (A4_38 A4_56) resistor r=1.63969
    rA4_121 (A4_38 A4_51) resistor r=24.8333
    rA4_120 (A4_38 A4_48) resistor r=24.8333
    rA4_119 (A4_38 A4_59) resistor r=24.8333
    rA4_118 (A4_38 A4_56) resistor r=24.8333
    rA4_117 (A4_38 A4_80) resistor r=58.3583
    rA4_116 (A4_38 MM22_ELT_g) resistor r=22.35
    rA4_115 (A4_38 A4_88) resistor r=14.9
    rA4_114 (A4_38 A4_257) resistor r=40.975
    rA4_113 (A4_38 A4_51) resistor r=4.16253
    rA4_112 (A4_38 A4_59) resistor r=4.16253
    rA4_111 (A4_38 A4_48) resistor r=4.16253
    rA4_110 (A4_38 A4_80) resistor r=4.16253
    rA4_109 (A4_38 A4_88) resistor r=6.30933
    rA4_108 (A4_38 A4_83) resistor r=6.30933
    rA4_107 (A4_38 A4_56) resistor r=1.63969
    rA4_106 (A4_40 A4_46) resistor r=202.392
    rA4_105 (A4_40 A4_46) resistor r=4.16253
    rA4_104 (A4_40 A4_46) resistor r=202.392
    rA4_103 (A4_40 A4_46) resistor r=4.16253
    rA4_102 (A4_43 A4_46) resistor r=202.392
    rA4_101 (A4_43 A4_46) resistor r=4.16253
    rA4_100 (A4_43 A4_46) resistor r=202.392
    rA4_99 (A4_43 A4_46) resistor r=4.16253
    rA4_98 (A4_46 A4_67) resistor r=24.8333
    rA4_97 (A4_46 A4_64) resistor r=24.8333
    rA4_96 (A4_46 A4_75) resistor r=24.8333
    rA4_95 (A4_46 A4_72) resistor r=24.8333
    rA4_94 (A4_46 A4_94) resistor r=14.9
    rA4_93 (A4_46 A4_100) resistor r=202.392
    rA4_92 (A4_46 A4_103) resistor r=202.392
    rA4_91 (A4_46 A4_67) resistor r=4.16253
    rA4_90 (A4_46 A4_75) resistor r=4.16253
    rA4_89 (A4_46 A4_100) resistor r=6.30933
    rA4_88 (A4_46 A4_94) resistor r=6.30933
    rA4_87 (A4_46 A4_64) resistor r=1.63969
    rA4_86 (A4_46 A4_72) resistor r=4.16253
    rA4_85 (A4_46 A4_103) resistor r=4.16253
    rA4_84 (A4_46 A4_67) resistor r=24.8333
    rA4_83 (A4_46 A4_64) resistor r=24.8333
    rA4_82 (A4_46 A4_75) resistor r=24.8333
    rA4_81 (A4_46 A4_72) resistor r=24.8333
    rA4_80 (A4_46 A4_259) resistor r=40.975
    rA4_79 (A4_46 A4_94) resistor r=14.9
    rA4_78 (A4_46 A4_100) resistor r=202.392
    rA4_77 (A4_46 MM16_ELT_g) resistor r=7.45
    rA4_76 (A4_46 A4_67) resistor r=4.16253
    rA4_75 (A4_46 A4_75) resistor r=4.16253
    rA4_74 (A4_46 A4_100) resistor r=6.30933
    rA4_73 (A4_46 A4_94) resistor r=6.30933
    rA4_72 (A4_46 A4_64) resistor r=1.63969
    rA4_71 (A4_46 A4_72) resistor r=4.16253
    rA4_70 (A4_46 A4_103) resistor r=4.16253
    rA4_69 (A4_83 MM22_ELT_g) resistor r=36.0083
    rA4_68 (A4_103 MM16_ELT_g) resistor r=194.942
    rA4_67 (A4_108 A4_111) resistor r=14.9
    rA4_66 (A4_108 A4_111) resistor r=6.30933
    rA4_65 (A4_108 A4_111) resistor r=14.9
    rA4_64 (A4_108 A4_111) resistor r=6.30933
    rA4_63 (A4_111 A4_114) resistor r=202.392
    rA4_62 (A4_111 A4_117) resistor r=202.392
    rA4_61 (A4_111 A4_125) resistor r=24.8333
    rA4_60 (A4_111 A4_122) resistor r=24.8333
    rA4_59 (A4_111 A4_133) resistor r=24.8333
    rA4_58 (A4_111 A4_130) resistor r=24.8333
    rA4_57 (A4_111 A4_138) resistor r=202.392
    rA4_56 (A4_111 A4_141) resistor r=202.392
    rA4_55 (A4_111 A4_114) resistor r=6.30933
    rA4_54 (A4_111 A4_125) resistor r=1.63969
    rA4_53 (A4_111 A4_133) resistor r=4.16253
    rA4_52 (A4_111 A4_117) resistor r=4.16253
    rA4_51 (A4_111 A4_122) resistor r=4.16253
    rA4_50 (A4_111 A4_138) resistor r=4.16253
    rA4_49 (A4_111 A4_130) resistor r=4.16253
    rA4_48 (A4_111 A4_141) resistor r=4.16253
    rA4_47 (A4_111 A4_269) resistor r=40.975
    rA4_46 (A4_111 A4_114) resistor r=202.392
    rA4_45 (A4_111 A4_117) resistor r=202.392
    rA4_44 (A4_111 A4_125) resistor r=24.8333
    rA4_43 (A4_111 A4_122) resistor r=24.8333
    rA4_42 (A4_111 A4_133) resistor r=24.8333
    rA4_41 (A4_111 A4_130) resistor r=24.8333
    rA4_40 (A4_111 A4_138) resistor r=202.392
    rA4_39 (A4_111 MM18_ELT_g) resistor r=7.45
    rA4_38 (A4_111 A4_114) resistor r=6.30933
    rA4_37 (A4_111 A4_125) resistor r=1.63969
    rA4_36 (A4_111 A4_133) resistor r=4.16253
    rA4_35 (A4_111 A4_117) resistor r=4.16253
    rA4_34 (A4_111 A4_122) resistor r=4.16253
    rA4_33 (A4_111 A4_138) resistor r=4.16253
    rA4_32 (A4_111 A4_130) resistor r=4.16253
    rA4_31 (A4_111 A4_141) resistor r=4.16253
    rA4_30 (A4_141 MM18_ELT_g) resistor r=194.942
    rA4_29 (A4_197 A4_198) resistor r=10
    rA4_28 (A4_197 A4) resistor r=0.0890647
    rA4_27 (A4_198 A4_292) resistor r=41.3136
    rA4_26 (A4_257 A4_293) resistor r=3.725
    rA4_25 (A4_259 A4_293) resistor r=3.725
    rA4_24 (A4_267 A4_268) resistor r=27.0909
    rA4_23 (A4_267 A4_269) resistor r=9.29775
    rA4_22 (A4_268 A4_293) resistor r=3.725
    rA4_21 (A4_292 A4_293) resistor r=3.725
    rnet027_77 (MM17_ELT_d net027) resistor r=0.01
    rnet027_76 (net027_1 net027_10) resistor r=0.134528
    rnet027_75 (net027_1 net027_13) resistor r=0.101293
    rnet027_74 (net027_3 net027_11) resistor r=8.66667
    rnet027_73 (net027_3 net027_7) resistor r=0.701887
    rnet027_72 (net027_7 net027_11) resistor r=8.66667
    rnet027_71 (net027_7 net027_10) resistor r=0.467925
    rnet027_70 (net027_10 net027_11) resistor r=26
    rnet027_69 (net027_11 MM20_ELT_s) resistor r=0.850556
    rnet027_68 (net027_11 MM11_ELT_s) resistor r=0.850556
    rnet027_67 (net027_11 net027_57) resistor r=13.0961
    rnet027_66 (net027_12 net027_13) resistor r=0.913108
    rnet027_65 (net027_12 net027_38) resistor r=0.0493155
    rnet027_64 (net027_14 net027_23) resistor r=0.223756
    rnet027_63 (net027_14 net027_38) resistor r=0.0420801
    rnet027_62 (net027_16 net027_17) resistor r=8.66667
    rnet027_61 (net027_16 net027_20) resistor r=0.639302
    rnet027_60 (net027_17 MM15_ELT_d) resistor r=32.3614
    rnet027_59 (net027_20 net027_21) resistor r=8.66667
    rnet027_58 (net027_20 net027_23) resistor r=0.426202
    rnet027_57 (net027_21 MM15_ELT_d) resistor r=16.1807
    rnet027_56 (net027_21 net027_24) resistor r=32.3614
    rnet027_55 (net027_23 net027_24) resistor r=26
    rnet027_54 (net027_25 net027_26) resistor r=0.435727
    rnet027_53 (net027_25 net027_27) resistor r=0.101293
    rnet027_52 (net027_26 net027_38) resistor r=0.0493155
    rnet027_51 (net027_27 net027_36) resistor r=0.223756
    rnet027_50 (net027_29 net027_30) resistor r=8.66667
    rnet027_49 (net027_29 net027_33) resistor r=0.639302
    rnet027_48 (net027_30 net027) resistor r=32.3614
    rnet027_47 (net027_33 net027_34) resistor r=8.66667
    rnet027_46 (net027_33 net027_36) resistor r=0.426202
    rnet027_45 (net027_34 net027) resistor r=16.1807
    rnet027_44 (net027_34 net027_37) resistor r=32.3614
    rnet027_43 (net027_36 net027_37) resistor r=26
    rnet027_42 (net027_39 net027_42) resistor r=31.2341
    rnet027_41 (net027_39 net027_43) resistor r=9.04595
    rnet027_40 (net027_40 net027_42) resistor r=31.2341
    rnet027_39 (net027_40 net027_46) resistor r=9.04062
    rnet027_38 (MM11_ELT_s net027_42) resistor r=6.12113
    rnet027_37 (MM11_ELT_s net027_44) resistor r=12.3172
    rnet027_36 (MM11_ELT_s net027_44) resistor r=1.62887
    rnet027_35 (MM11_ELT_s net027_47) resistor r=2.55965
    rnet027_34 (net027_43 net027_44) resistor r=12.3172
    rnet027_33 (net027_45 net027_47) resistor r=14.4784
    rnet027_32 (net027_45 net027_58) resistor r=10.5593
    rnet027_31 (net027_46 net027_47) resistor r=14.4784
    rnet027_30 (MM20_ELT_s net027_51) resistor r=2.55965
    rnet027_29 (MM20_ELT_s net027_53) resistor r=12.3172
    rnet027_28 (MM20_ELT_s net027_53) resistor r=1.62887
    rnet027_27 (MM20_ELT_s net027_56) resistor r=6.12113
    rnet027_26 (net027_49 net027_51) resistor r=14.4784
    rnet027_25 (net027_49 net027_55) resistor r=9.04062
    rnet027_24 (net027_50 net027_51) resistor r=14.4784
    rnet027_23 (net027_50 net027_58) resistor r=10.5593
    rnet027_22 (net027_52 net027_53) resistor r=12.3172
    rnet027_21 (net027_52 net027_54) resistor r=9.04595
    rnet027_20 (net027_54 net027_56) resistor r=31.2341
    rnet027_19 (net027_55 net027_56) resistor r=31.2341
    rnet027_18 (net027_57 net027_58) resistor r=0.730683
    rA3_144 (A3_32 A3_38) resistor r=58.3583
    rA3_143 (A3_32 A3_38) resistor r=4.16253
    rA3_142 (A3_32 A3_38) resistor r=58.3583
    rA3_141 (A3_32 A3_38) resistor r=4.16253
    rA3_140 (A3_35 A3_38) resistor r=58.3583
    rA3_139 (A3_35 A3_38) resistor r=4.16253
    rA3_138 (A3_35 A3_38) resistor r=58.3583
    rA3_137 (A3_35 A3_38) resistor r=4.16253
    rA3_136 (A3_38 A3_51) resistor r=24.8333
    rA3_135 (A3_38 A3_48) resistor r=24.8333
    rA3_134 (A3_38 A3_59) resistor r=24.8333
    rA3_133 (A3_38 A3_56) resistor r=24.8333
    rA3_132 (A3_38 A3_80) resistor r=58.3583
    rA3_131 (A3_38 A3_83) resistor r=58.3583
    rA3_130 (A3_38 A3_88) resistor r=14.9
    rA3_129 (A3_38 A3_51) resistor r=4.16253
    rA3_128 (A3_38 A3_59) resistor r=4.16253
    rA3_127 (A3_38 A3_48) resistor r=4.16253
    rA3_126 (A3_38 A3_80) resistor r=4.16253
    rA3_125 (A3_38 A3_88) resistor r=6.30933
    rA3_124 (A3_38 A3_83) resistor r=6.30933
    rA3_123 (A3_38 A3_56) resistor r=1.63969
    rA3_122 (A3_38 A3_51) resistor r=24.8333
    rA3_121 (A3_38 A3_48) resistor r=24.8333
    rA3_120 (A3_38 A3_59) resistor r=24.8333
    rA3_119 (A3_38 A3_56) resistor r=24.8333
    rA3_118 (A3_38 A3_80) resistor r=58.3583
    rA3_117 (A3_38 MM21_ELT_g) resistor r=22.35
    rA3_116 (A3_38 A3_88) resistor r=14.9
    rA3_115 (A3_38 A3_257) resistor r=40.975
    rA3_114 (A3_38 A3_51) resistor r=4.16253
    rA3_113 (A3_38 A3_59) resistor r=4.16253
    rA3_112 (A3_38 A3_48) resistor r=4.16253
    rA3_111 (A3_38 A3_80) resistor r=4.16253
    rA3_110 (A3_38 A3_88) resistor r=6.30933
    rA3_109 (A3_38 A3_83) resistor r=6.30933
    rA3_108 (A3_38 A3_56) resistor r=1.63969
    rA3_107 (A3_40 A3_46) resistor r=202.392
    rA3_106 (A3_40 A3_46) resistor r=4.16253
    rA3_105 (A3_40 A3_46) resistor r=202.392
    rA3_104 (A3_40 A3_46) resistor r=4.16253
    rA3_103 (A3_43 A3_46) resistor r=202.392
    rA3_102 (A3_43 A3_46) resistor r=4.16253
    rA3_101 (A3_43 A3_46) resistor r=202.392
    rA3_100 (A3_43 A3_46) resistor r=4.16253
    rA3_99 (A3_46 A3_67) resistor r=24.8333
    rA3_98 (A3_46 A3_64) resistor r=24.8333
    rA3_97 (A3_46 A3_75) resistor r=24.8333
    rA3_96 (A3_46 A3_72) resistor r=24.8333
    rA3_95 (A3_46 A3_94) resistor r=14.9
    rA3_94 (A3_46 A3_100) resistor r=202.392
    rA3_93 (A3_46 A3_103) resistor r=202.392
    rA3_92 (A3_46 A3_67) resistor r=4.16253
    rA3_91 (A3_46 A3_75) resistor r=4.16253
    rA3_90 (A3_46 A3_100) resistor r=6.30933
    rA3_89 (A3_46 A3_94) resistor r=6.30933
    rA3_88 (A3_46 A3_64) resistor r=1.63969
    rA3_87 (A3_46 A3_72) resistor r=4.16253
    rA3_86 (A3_46 A3_103) resistor r=4.16253
    rA3_85 (A3_46 A3_67) resistor r=24.8333
    rA3_84 (A3_46 A3_64) resistor r=24.8333
    rA3_83 (A3_46 A3_75) resistor r=24.8333
    rA3_82 (A3_46 A3_72) resistor r=24.8333
    rA3_81 (A3_46 A3_259) resistor r=40.975
    rA3_80 (A3_46 A3_94) resistor r=14.9
    rA3_79 (A3_46 A3_100) resistor r=202.392
    rA3_78 (A3_46 MM15_ELT_g) resistor r=7.45
    rA3_77 (A3_46 A3_67) resistor r=4.16253
    rA3_76 (A3_46 A3_75) resistor r=4.16253
    rA3_75 (A3_46 A3_100) resistor r=6.30933
    rA3_74 (A3_46 A3_94) resistor r=6.30933
    rA3_73 (A3_46 A3_64) resistor r=1.63969
    rA3_72 (A3_46 A3_72) resistor r=4.16253
    rA3_71 (A3_46 A3_103) resistor r=4.16253
    rA3_70 (A3_83 MM21_ELT_g) resistor r=36.0083
    rA3_69 (A3_103 MM15_ELT_g) resistor r=194.942
    rA3_68 (A3_108 A3_111) resistor r=14.9
    rA3_67 (A3_108 A3_111) resistor r=6.30933
    rA3_66 (A3_108 A3_111) resistor r=14.9
    rA3_65 (A3_108 A3_111) resistor r=6.30933
    rA3_64 (A3_111 A3_114) resistor r=202.392
    rA3_63 (A3_111 A3_117) resistor r=202.392
    rA3_62 (A3_111 A3_125) resistor r=24.8333
    rA3_61 (A3_111 A3_122) resistor r=24.8333
    rA3_60 (A3_111 A3_133) resistor r=24.8333
    rA3_59 (A3_111 A3_130) resistor r=24.8333
    rA3_58 (A3_111 A3_138) resistor r=202.392
    rA3_57 (A3_111 A3_141) resistor r=202.392
    rA3_56 (A3_111 A3_114) resistor r=6.30933
    rA3_55 (A3_111 A3_125) resistor r=1.63969
    rA3_54 (A3_111 A3_133) resistor r=4.16253
    rA3_53 (A3_111 A3_117) resistor r=4.16253
    rA3_52 (A3_111 A3_122) resistor r=4.16253
    rA3_51 (A3_111 A3_138) resistor r=4.16253
    rA3_50 (A3_111 A3_130) resistor r=4.16253
    rA3_49 (A3_111 A3_141) resistor r=4.16253
    rA3_48 (A3_111 A3_269) resistor r=40.975
    rA3_47 (A3_111 A3_114) resistor r=202.392
    rA3_46 (A3_111 A3_117) resistor r=202.392
    rA3_45 (A3_111 A3_125) resistor r=24.8333
    rA3_44 (A3_111 A3_122) resistor r=24.8333
    rA3_43 (A3_111 A3_133) resistor r=24.8333
    rA3_42 (A3_111 A3_130) resistor r=24.8333
    rA3_41 (A3_111 A3_138) resistor r=202.392
    rA3_40 (A3_111 MM17_ELT_g) resistor r=7.45
    rA3_39 (A3_111 A3_114) resistor r=6.30933
    rA3_38 (A3_111 A3_125) resistor r=1.63969
    rA3_37 (A3_111 A3_133) resistor r=4.16253
    rA3_36 (A3_111 A3_117) resistor r=4.16253
    rA3_35 (A3_111 A3_122) resistor r=4.16253
    rA3_34 (A3_111 A3_138) resistor r=4.16253
    rA3_33 (A3_111 A3_130) resistor r=4.16253
    rA3_32 (A3_111 A3_141) resistor r=4.16253
    rA3_31 (A3_141 MM17_ELT_g) resistor r=194.942
    rA3_30 (A3_197 A3_198) resistor r=10
    rA3_29 (A3_197 A3) resistor r=0.0869026
    rA3_28 (A3_198 A3_292) resistor r=41.3136
    rA3_27 (A3_257 A3_293) resistor r=3.725
    rA3_26 (A3_259 A3_293) resistor r=3.725
    rA3_25 (A3_267 A3_268) resistor r=27.0909
    rA3_24 (A3_267 A3_269) resistor r=9.29775
    rA3_23 (A3_268 A3_293) resistor r=3.725
    rA3_22 (A3_292 A3_293) resistor r=3.725
    rnet29_82 (MM20_ELT_d net29) resistor r=0.01
    rnet29_81 (net29_1 net29_10) resistor r=0.356792
    rnet29_80 (net29_1 net29_13) resistor r=0.101293
    rnet29_79 (net29_3 net29_11) resistor r=8.66667
    rnet29_78 (net29_3 net29_7) resistor r=0.701887
    rnet29_77 (net29_7 net29_11) resistor r=8.66667
    rnet29_76 (net29_7 net29_10) resistor r=0.467925
    rnet29_75 (net29_10 net29_11) resistor r=13
    rnet29_74 (net29_11 MM19_ELT_s) resistor r=0.850556
    rnet29_73 (net29_11 MM10_ELT_s) resistor r=0.850556
    rnet29_72 (net29_11 net29_61) resistor r=13.0961
    rnet29_71 (net29_12 net29_13) resistor r=0.521008
    rnet29_70 (net29_12 net29_15) resistor r=0.0953142
    rnet29_69 (net29_14 net29_15) resistor r=1.45327
    rnet29_68 (net29_14 net29_17) resistor r=0.0953142
    rnet29_67 (net29_16 net29_17) resistor r=0.214685
    rnet29_66 (net29_16 net29_42) resistor r=0.0493155
    rnet29_65 (net29_18 net29_20) resistor r=0.45178
    rnet29_64 (net29_18 net29_42) resistor r=0.0420801
    rnet29_63 (net29_20 net29_21) resistor r=8.66667
    rnet29_62 (net29_20 net29_23) resistor r=0.661141
    rnet29_61 (net29_21 MM11_ELT_d) resistor r=32.3614
    rnet29_60 (net29_23 net29_24) resistor r=8.66667
    rnet29_59 (net29_23 net29_26) resistor r=0.440761
    rnet29_58 (net29_24 MM11_ELT_d) resistor r=16.1807
    rnet29_57 (net29_24 net29_27) resistor r=32.3614
    rnet29_56 (net29_26 net29_27) resistor r=26
    rnet29_55 (net29_29 net29_30) resistor r=0.391969
    rnet29_54 (net29_29 net29_31) resistor r=0.101293
    rnet29_53 (net29_30 net29_42) resistor r=0.0493155
    rnet29_52 (net29_31 net29_33) resistor r=0.436857
    rnet29_51 (net29_33 net29_34) resistor r=8.66667
    rnet29_50 (net29_33 net29_36) resistor r=0.639302
    rnet29_49 (net29_34 net29) resistor r=32.3614
    rnet29_48 (net29_36 net29_37) resistor r=8.66667
    rnet29_47 (net29_36 net29_39) resistor r=0.426202
    rnet29_46 (net29_37 net29) resistor r=16.1807
    rnet29_45 (net29_37 net29_40) resistor r=32.3614
    rnet29_44 (net29_39 net29_40) resistor r=26
    rnet29_43 (net29_43 net29_46) resistor r=31.2341
    rnet29_42 (net29_43 net29_47) resistor r=9.04595
    rnet29_41 (net29_44 net29_46) resistor r=31.2341
    rnet29_40 (net29_44 net29_50) resistor r=9.04062
    rnet29_39 (MM10_ELT_s net29_46) resistor r=6.12113
    rnet29_38 (MM10_ELT_s net29_48) resistor r=12.3172
    rnet29_37 (MM10_ELT_s net29_48) resistor r=1.62887
    rnet29_36 (MM10_ELT_s net29_51) resistor r=2.55965
    rnet29_35 (net29_47 net29_48) resistor r=12.3172
    rnet29_34 (net29_49 net29_51) resistor r=14.4784
    rnet29_33 (net29_49 net29_62) resistor r=10.5593
    rnet29_32 (net29_50 net29_51) resistor r=14.4784
    rnet29_31 (MM19_ELT_s net29_55) resistor r=2.55965
    rnet29_30 (MM19_ELT_s net29_57) resistor r=12.3172
    rnet29_29 (MM19_ELT_s net29_57) resistor r=1.62887
    rnet29_28 (MM19_ELT_s net29_60) resistor r=6.12113
    rnet29_27 (net29_53 net29_55) resistor r=14.4784
    rnet29_26 (net29_53 net29_59) resistor r=9.04062
    rnet29_25 (net29_54 net29_55) resistor r=14.4784
    rnet29_24 (net29_54 net29_62) resistor r=10.5593
    rnet29_23 (net29_56 net29_57) resistor r=12.3172
    rnet29_22 (net29_56 net29_58) resistor r=9.04595
    rnet29_21 (net29_58 net29_60) resistor r=31.2341
    rnet29_20 (net29_59 net29_60) resistor r=31.2341
    rnet29_19 (net29_61 net29_62) resistor r=0.730683
    rA2_144 (A2_32 A2_38) resistor r=58.3583
    rA2_143 (A2_32 A2_38) resistor r=4.16253
    rA2_142 (A2_32 A2_38) resistor r=58.3583
    rA2_141 (A2_32 A2_38) resistor r=4.16253
    rA2_140 (A2_35 A2_38) resistor r=58.3583
    rA2_139 (A2_35 A2_38) resistor r=4.16253
    rA2_138 (A2_35 A2_38) resistor r=58.3583
    rA2_137 (A2_35 A2_38) resistor r=4.16253
    rA2_136 (A2_38 A2_51) resistor r=24.8333
    rA2_135 (A2_38 A2_48) resistor r=24.8333
    rA2_134 (A2_38 A2_59) resistor r=24.8333
    rA2_133 (A2_38 A2_56) resistor r=24.8333
    rA2_132 (A2_38 A2_80) resistor r=58.3583
    rA2_131 (A2_38 A2_83) resistor r=58.3583
    rA2_130 (A2_38 A2_88) resistor r=14.9
    rA2_129 (A2_38 A2_51) resistor r=4.16253
    rA2_128 (A2_38 A2_59) resistor r=4.16253
    rA2_127 (A2_38 A2_48) resistor r=4.16253
    rA2_126 (A2_38 A2_80) resistor r=4.16253
    rA2_125 (A2_38 A2_88) resistor r=6.30933
    rA2_124 (A2_38 A2_83) resistor r=6.30933
    rA2_123 (A2_38 A2_56) resistor r=1.63969
    rA2_122 (A2_38 A2_51) resistor r=24.8333
    rA2_121 (A2_38 A2_48) resistor r=24.8333
    rA2_120 (A2_38 A2_59) resistor r=24.8333
    rA2_119 (A2_38 A2_56) resistor r=24.8333
    rA2_118 (A2_38 A2_80) resistor r=58.3583
    rA2_117 (A2_38 MM1_ELT_g) resistor r=22.35
    rA2_116 (A2_38 A2_88) resistor r=14.9
    rA2_115 (A2_38 A2_257) resistor r=40.975
    rA2_114 (A2_38 A2_51) resistor r=4.16253
    rA2_113 (A2_38 A2_59) resistor r=4.16253
    rA2_112 (A2_38 A2_48) resistor r=4.16253
    rA2_111 (A2_38 A2_80) resistor r=4.16253
    rA2_110 (A2_38 A2_88) resistor r=6.30933
    rA2_109 (A2_38 A2_83) resistor r=6.30933
    rA2_108 (A2_38 A2_56) resistor r=1.63969
    rA2_107 (A2_40 A2_46) resistor r=202.392
    rA2_106 (A2_40 A2_46) resistor r=4.16253
    rA2_105 (A2_40 A2_46) resistor r=202.392
    rA2_104 (A2_40 A2_46) resistor r=4.16253
    rA2_103 (A2_43 A2_46) resistor r=202.392
    rA2_102 (A2_43 A2_46) resistor r=4.16253
    rA2_101 (A2_43 A2_46) resistor r=202.392
    rA2_100 (A2_43 A2_46) resistor r=4.16253
    rA2_99 (A2_46 A2_67) resistor r=24.8333
    rA2_98 (A2_46 A2_64) resistor r=24.8333
    rA2_97 (A2_46 A2_75) resistor r=24.8333
    rA2_96 (A2_46 A2_72) resistor r=24.8333
    rA2_95 (A2_46 A2_94) resistor r=14.9
    rA2_94 (A2_46 A2_100) resistor r=202.392
    rA2_93 (A2_46 A2_103) resistor r=202.392
    rA2_92 (A2_46 A2_67) resistor r=4.16253
    rA2_91 (A2_46 A2_75) resistor r=4.16253
    rA2_90 (A2_46 A2_100) resistor r=6.30933
    rA2_89 (A2_46 A2_94) resistor r=6.30933
    rA2_88 (A2_46 A2_64) resistor r=1.63969
    rA2_87 (A2_46 A2_72) resistor r=4.16253
    rA2_86 (A2_46 A2_103) resistor r=4.16253
    rA2_85 (A2_46 A2_67) resistor r=24.8333
    rA2_84 (A2_46 A2_64) resistor r=24.8333
    rA2_83 (A2_46 A2_75) resistor r=24.8333
    rA2_82 (A2_46 A2_72) resistor r=24.8333
    rA2_81 (A2_46 A2_259) resistor r=40.975
    rA2_80 (A2_46 A2_94) resistor r=14.9
    rA2_79 (A2_46 A2_100) resistor r=202.392
    rA2_78 (A2_46 MM11_ELT_g) resistor r=7.45
    rA2_77 (A2_46 A2_67) resistor r=4.16253
    rA2_76 (A2_46 A2_75) resistor r=4.16253
    rA2_75 (A2_46 A2_100) resistor r=6.30933
    rA2_74 (A2_46 A2_94) resistor r=6.30933
    rA2_73 (A2_46 A2_64) resistor r=1.63969
    rA2_72 (A2_46 A2_72) resistor r=4.16253
    rA2_71 (A2_46 A2_103) resistor r=4.16253
    rA2_70 (A2_83 MM1_ELT_g) resistor r=36.0083
    rA2_69 (A2_103 MM11_ELT_g) resistor r=194.942
    rA2_68 (A2_108 A2_111) resistor r=14.9
    rA2_67 (A2_108 A2_111) resistor r=6.30933
    rA2_66 (A2_108 A2_111) resistor r=14.9
    rA2_65 (A2_108 A2_111) resistor r=6.30933
    rA2_64 (A2_111 A2_114) resistor r=202.392
    rA2_63 (A2_111 A2_117) resistor r=202.392
    rA2_62 (A2_111 A2_125) resistor r=24.8333
    rA2_61 (A2_111 A2_122) resistor r=24.8333
    rA2_60 (A2_111 A2_133) resistor r=24.8333
    rA2_59 (A2_111 A2_130) resistor r=24.8333
    rA2_58 (A2_111 A2_138) resistor r=202.392
    rA2_57 (A2_111 A2_141) resistor r=202.392
    rA2_56 (A2_111 A2_114) resistor r=6.30933
    rA2_55 (A2_111 A2_125) resistor r=1.63969
    rA2_54 (A2_111 A2_133) resistor r=4.16253
    rA2_53 (A2_111 A2_117) resistor r=4.16253
    rA2_52 (A2_111 A2_122) resistor r=4.16253
    rA2_51 (A2_111 A2_138) resistor r=4.16253
    rA2_50 (A2_111 A2_130) resistor r=4.16253
    rA2_49 (A2_111 A2_141) resistor r=4.16253
    rA2_48 (A2_111 A2_269) resistor r=40.975
    rA2_47 (A2_111 A2_114) resistor r=202.392
    rA2_46 (A2_111 A2_117) resistor r=202.392
    rA2_45 (A2_111 A2_125) resistor r=24.8333
    rA2_44 (A2_111 A2_122) resistor r=24.8333
    rA2_43 (A2_111 A2_133) resistor r=24.8333
    rA2_42 (A2_111 A2_130) resistor r=24.8333
    rA2_41 (A2_111 A2_138) resistor r=202.392
    rA2_40 (A2_111 MM20_ELT_g) resistor r=7.45
    rA2_39 (A2_111 A2_114) resistor r=6.30933
    rA2_38 (A2_111 A2_125) resistor r=1.63969
    rA2_37 (A2_111 A2_133) resistor r=4.16253
    rA2_36 (A2_111 A2_117) resistor r=4.16253
    rA2_35 (A2_111 A2_122) resistor r=4.16253
    rA2_34 (A2_111 A2_138) resistor r=4.16253
    rA2_33 (A2_111 A2_130) resistor r=4.16253
    rA2_32 (A2_111 A2_141) resistor r=4.16253
    rA2_31 (A2_141 MM20_ELT_g) resistor r=194.942
    rA2_30 (A2_197 A2_198) resistor r=10
    rA2_29 (A2_197 A2) resistor r=0.0890647
    rA2_28 (A2_198 A2_292) resistor r=41.3136
    rA2_27 (A2_257 A2_293) resistor r=3.725
    rA2_26 (A2_259 A2_293) resistor r=3.725
    rA2_25 (A2_267 A2_268) resistor r=27.0909
    rA2_24 (A2_267 A2_269) resistor r=9.29775
    rA2_23 (A2_268 A2_293) resistor r=3.725
    rA2_22 (A2_292 A2_293) resistor r=3.725
    rA1_142 (A1_32 A1_38) resistor r=58.3583
    rA1_141 (A1_32 A1_38) resistor r=4.16253
    rA1_140 (A1_32 A1_38) resistor r=58.3583
    rA1_139 (A1_32 A1_38) resistor r=4.16253
    rA1_138 (A1_35 A1_38) resistor r=58.3583
    rA1_137 (A1_35 A1_38) resistor r=4.16253
    rA1_136 (A1_35 A1_38) resistor r=58.3583
    rA1_135 (A1_35 A1_38) resistor r=4.16253
    rA1_134 (A1_38 A1_51) resistor r=24.8333
    rA1_133 (A1_38 A1_48) resistor r=24.8333
    rA1_132 (A1_38 A1_59) resistor r=24.8333
    rA1_131 (A1_38 A1_56) resistor r=24.8333
    rA1_130 (A1_38 A1_80) resistor r=58.3583
    rA1_129 (A1_38 A1_83) resistor r=58.3583
    rA1_128 (A1_38 A1_88) resistor r=14.9
    rA1_127 (A1_38 A1_51) resistor r=4.16253
    rA1_126 (A1_38 A1_59) resistor r=4.16253
    rA1_125 (A1_38 A1_48) resistor r=4.16253
    rA1_124 (A1_38 A1_80) resistor r=4.16253
    rA1_123 (A1_38 A1_88) resistor r=6.30933
    rA1_122 (A1_38 A1_83) resistor r=6.30933
    rA1_121 (A1_38 A1_56) resistor r=1.63969
    rA1_120 (A1_38 A1_51) resistor r=24.8333
    rA1_119 (A1_38 A1_48) resistor r=24.8333
    rA1_118 (A1_38 A1_59) resistor r=24.8333
    rA1_117 (A1_38 A1_56) resistor r=24.8333
    rA1_116 (A1_38 A1_80) resistor r=58.3583
    rA1_115 (A1_38 MM2_ELT_g) resistor r=22.35
    rA1_114 (A1_38 A1_88) resistor r=14.9
    rA1_113 (A1_38 A1_257) resistor r=40.975
    rA1_112 (A1_38 A1_51) resistor r=4.16253
    rA1_111 (A1_38 A1_59) resistor r=4.16253
    rA1_110 (A1_38 A1_48) resistor r=4.16253
    rA1_109 (A1_38 A1_80) resistor r=4.16253
    rA1_108 (A1_38 A1_88) resistor r=6.30933
    rA1_107 (A1_38 A1_83) resistor r=6.30933
    rA1_106 (A1_38 A1_56) resistor r=1.63969
    rA1_105 (A1_40 A1_46) resistor r=202.392
    rA1_104 (A1_40 A1_46) resistor r=4.16253
    rA1_103 (A1_40 A1_46) resistor r=202.392
    rA1_102 (A1_40 A1_46) resistor r=4.16253
    rA1_101 (A1_43 A1_46) resistor r=202.392
    rA1_100 (A1_43 A1_46) resistor r=4.16253
    rA1_99 (A1_43 A1_46) resistor r=202.392
    rA1_98 (A1_43 A1_46) resistor r=4.16253
    rA1_97 (A1_46 A1_67) resistor r=24.8333
    rA1_96 (A1_46 A1_64) resistor r=24.8333
    rA1_95 (A1_46 A1_75) resistor r=24.8333
    rA1_94 (A1_46 A1_72) resistor r=24.8333
    rA1_93 (A1_46 A1_94) resistor r=14.9
    rA1_92 (A1_46 A1_100) resistor r=202.392
    rA1_91 (A1_46 A1_103) resistor r=202.392
    rA1_90 (A1_46 A1_67) resistor r=4.16253
    rA1_89 (A1_46 A1_75) resistor r=4.16253
    rA1_88 (A1_46 A1_100) resistor r=6.30933
    rA1_87 (A1_46 A1_94) resistor r=6.30933
    rA1_86 (A1_46 A1_64) resistor r=1.63969
    rA1_85 (A1_46 A1_72) resistor r=4.16253
    rA1_84 (A1_46 A1_103) resistor r=4.16253
    rA1_83 (A1_46 A1_67) resistor r=24.8333
    rA1_82 (A1_46 A1_64) resistor r=24.8333
    rA1_81 (A1_46 A1_75) resistor r=24.8333
    rA1_80 (A1_46 A1_72) resistor r=24.8333
    rA1_79 (A1_46 A1_259) resistor r=40.975
    rA1_78 (A1_46 A1_94) resistor r=14.9
    rA1_77 (A1_46 A1_100) resistor r=202.392
    rA1_76 (A1_46 MM10_ELT_g) resistor r=7.45
    rA1_75 (A1_46 A1_67) resistor r=4.16253
    rA1_74 (A1_46 A1_75) resistor r=4.16253
    rA1_73 (A1_46 A1_100) resistor r=6.30933
    rA1_72 (A1_46 A1_94) resistor r=6.30933
    rA1_71 (A1_46 A1_64) resistor r=1.63969
    rA1_70 (A1_46 A1_72) resistor r=4.16253
    rA1_69 (A1_46 A1_103) resistor r=4.16253
    rA1_68 (A1_83 MM2_ELT_g) resistor r=36.0083
    rA1_67 (A1_103 MM10_ELT_g) resistor r=194.942
    rA1_66 (A1_108 A1_111) resistor r=14.9
    rA1_65 (A1_108 A1_111) resistor r=6.30933
    rA1_64 (A1_108 A1_111) resistor r=14.9
    rA1_63 (A1_108 A1_111) resistor r=6.30933
    rA1_62 (A1_111 A1_114) resistor r=202.392
    rA1_61 (A1_111 A1_117) resistor r=202.392
    rA1_60 (A1_111 A1_125) resistor r=24.8333
    rA1_59 (A1_111 A1_122) resistor r=24.8333
    rA1_58 (A1_111 A1_133) resistor r=24.8333
    rA1_57 (A1_111 A1_130) resistor r=24.8333
    rA1_56 (A1_111 A1_138) resistor r=202.392
    rA1_55 (A1_111 A1_141) resistor r=202.392
    rA1_54 (A1_111 A1_114) resistor r=6.30933
    rA1_53 (A1_111 A1_125) resistor r=1.63969
    rA1_52 (A1_111 A1_133) resistor r=4.16253
    rA1_51 (A1_111 A1_117) resistor r=4.16253
    rA1_50 (A1_111 A1_122) resistor r=4.16253
    rA1_49 (A1_111 A1_138) resistor r=4.16253
    rA1_48 (A1_111 A1_130) resistor r=4.16253
    rA1_47 (A1_111 A1_141) resistor r=4.16253
    rA1_46 (A1_111 A1_269) resistor r=40.975
    rA1_45 (A1_111 A1_114) resistor r=202.392
    rA1_44 (A1_111 A1_117) resistor r=202.392
    rA1_43 (A1_111 A1_125) resistor r=24.8333
    rA1_42 (A1_111 A1_122) resistor r=24.8333
    rA1_41 (A1_111 A1_133) resistor r=24.8333
    rA1_40 (A1_111 A1_130) resistor r=24.8333
    rA1_39 (A1_111 A1_138) resistor r=202.392
    rA1_38 (A1_111 MM19_ELT_g) resistor r=7.45
    rA1_37 (A1_111 A1_114) resistor r=6.30933
    rA1_36 (A1_111 A1_125) resistor r=1.63969
    rA1_35 (A1_111 A1_133) resistor r=4.16253
    rA1_34 (A1_111 A1_117) resistor r=4.16253
    rA1_33 (A1_111 A1_122) resistor r=4.16253
    rA1_32 (A1_111 A1_138) resistor r=4.16253
    rA1_31 (A1_111 A1_130) resistor r=4.16253
    rA1_30 (A1_111 A1_141) resistor r=4.16253
    rA1_29 (A1_141 MM19_ELT_g) resistor r=194.942
    rA1_28 (A1_197 A1_198) resistor r=10
    rA1_27 (A1_197 A1) resistor r=0.0846443
    rA1_26 (A1_198 A1_292) resistor r=41.3136
    rA1_25 (A1_257 A1_293) resistor r=3.725
    rA1_24 (A1_259 A1_293) resistor r=3.725
    rA1_23 (A1_267 A1_268) resistor r=27.0909
    rA1_22 (A1_267 A1_269) resistor r=9.29775
    rA1_21 (A1_268 A1_293) resistor r=3.725
    rA1_20 (A1_292 A1_293) resistor r=3.725
ends NR4UB2AD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: CKBD16_LVT_ELT
// View name: calibre
subckt CKBD16_LVT_ELT I Z VDD VSS
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM16_ELT (MM16_ELT_d MM16_ELT_g MM16_ELT_s MM16_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM19_ELT (MM19_ELT_d MM19_ELT_g MM19_ELT_s MM19_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM25_ELT (MM25_ELT_d MM25_ELT_g MM25_ELT_s MM25_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM26_ELT (MM26_ELT_d MM26_ELT_g MM26_ELT_s MM26_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM27_ELT (MM27_ELT_d MM27_ELT_g MM27_ELT_s MM27_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM28_ELT (MM28_ELT_d MM28_ELT_g MM28_ELT_s MM28_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM29_ELT (MM29_ELT_d MM29_ELT_g MM29_ELT_s MM29_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM30_ELT (MM30_ELT_d MM30_ELT_g MM30_ELT_s MM30_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM31_ELT (MM31_ELT_d MM31_ELT_g MM31_ELT_s MM31_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM32_ELT (MM32_ELT_d MM32_ELT_g MM32_ELT_s MM32_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM21_ELT (MM21_ELT_d MM21_ELT_g MM21_ELT_s MM21_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM22_ELT (MM22_ELT_d MM22_ELT_g MM22_ELT_s MM22_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.34237e-13 pd=1.34e-06 \
        ps=3.0655e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM20_ELT (MM20_ELT_d MM20_ELT_g MM20_ELT_s MM20_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM33_ELT (MM33_ELT_d MM33_ELT_g MM33_ELT_s MM33_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM34_ELT (MM34_ELT_d MM34_ELT_g MM34_ELT_s MM34_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM35_ELT (MM35_ELT_d MM35_ELT_g MM35_ELT_s MM35_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM36_ELT (MM36_ELT_d MM36_ELT_g MM36_ELT_s MM36_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM37_ELT (MM37_ELT_d MM37_ELT_g MM37_ELT_s MM37_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM38_ELT (MM38_ELT_d MM38_ELT_g MM38_ELT_s MM38_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM39_ELT (MM39_ELT_d MM39_ELT_g MM39_ELT_s MM39_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM40_ELT (MM40_ELT_d MM40_ELT_g MM40_ELT_s MM40_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM23_ELT (MM23_ELT_d MM23_ELT_g MM23_ELT_s MM23_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM24_ELT (MM24_ELT_d MM24_ELT_g MM24_ELT_s MM24_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.67977e-13 pd=3.66e-06 \
        ps=5.5015e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    ciZ_126 (Z_3 VSS) capacitor c=6.76954e-17
    ciZ_125 (Z_4 VSS) capacitor c=1.17382e-16
    ciZ_124 (Z_8 VSS) capacitor c=2.36844e-16
    ciZ_123 (Z_9 VSS) capacitor c=3.53834e-16
    ciZ_122 (Z_17 VSS) capacitor c=7.15175e-17
    ciZ_121 (Z_18 VSS) capacitor c=1.81882e-17
    ciZ_120 (Z_19 VSS) capacitor c=6.98562e-17
    ciZ_119 (Z_20 VSS) capacitor c=1.71814e-17
    ciZ_118 (Z_23 VSS) capacitor c=6.6019e-17
    ciZ_117 (Z_24 VSS) capacitor c=1.1736e-16
    ciZ_116 (Z_28 VSS) capacitor c=2.35197e-16
    ciZ_115 (Z_29 VSS) capacitor c=3.53761e-16
    ciZ_114 (Z_37 VSS) capacitor c=8.77623e-17
    ciZ_113 (Z_39 VSS) capacitor c=8.6288e-17
    ciZ_112 (Z_43 VSS) capacitor c=6.6019e-17
    ciZ_111 (Z_44 VSS) capacitor c=1.1736e-16
    ciZ_110 (Z_48 VSS) capacitor c=2.35197e-16
    ciZ_109 (Z_49 VSS) capacitor c=3.53761e-16
    ciZ_108 (Z_57 VSS) capacitor c=7.15502e-17
    ciZ_107 (Z_59 VSS) capacitor c=6.98889e-17
    ciZ_106 (Z_63 VSS) capacitor c=6.6019e-17
    ciZ_105 (Z_64 VSS) capacitor c=1.1736e-16
    ciZ_104 (Z_68 VSS) capacitor c=2.35197e-16
    ciZ_103 (Z_69 VSS) capacitor c=3.53761e-16
    ciZ_102 (Z_77 VSS) capacitor c=8.75596e-17
    ciZ_101 (Z_79 VSS) capacitor c=8.60435e-17
    ciZ_100 (Z_83 VSS) capacitor c=6.6019e-17
    ciZ_99 (Z_84 VSS) capacitor c=1.1736e-16
    ciZ_98 (Z_88 VSS) capacitor c=2.35197e-16
    ciZ_97 (Z_89 VSS) capacitor c=3.53761e-16
    ciZ_96 (Z_97 VSS) capacitor c=7.15502e-17
    ciZ_95 (Z_99 VSS) capacitor c=6.98889e-17
    ciZ_94 (Z_103 VSS) capacitor c=6.6019e-17
    ciZ_93 (Z_104 VSS) capacitor c=1.1736e-16
    ciZ_92 (Z_108 VSS) capacitor c=2.35197e-16
    ciZ_91 (Z_109 VSS) capacitor c=3.53761e-16
    ciZ_90 (Z_117 VSS) capacitor c=8.75596e-17
    ciZ_89 (Z_119 VSS) capacitor c=8.60435e-17
    ciZ_88 (Z_123 VSS) capacitor c=6.6019e-17
    ciZ_87 (Z_124 VSS) capacitor c=1.1736e-16
    ciZ_86 (Z_128 VSS) capacitor c=2.35197e-16
    ciZ_85 (Z_129 VSS) capacitor c=3.53761e-16
    ciZ_84 (Z_137 VSS) capacitor c=7.15342e-17
    ciZ_83 (Z_139 VSS) capacitor c=6.9873e-17
    ciZ_82 (Z_143 VSS) capacitor c=6.6019e-17
    ciZ_81 (Z_144 VSS) capacitor c=1.1736e-16
    ciZ_80 (Z_148 VSS) capacitor c=2.35197e-16
    ciZ_79 (Z_149 VSS) capacitor c=3.53761e-16
    ciZ_78 (Z_157 VSS) capacitor c=8.75596e-17
    ciZ_77 (Z_159 VSS) capacitor c=8.60435e-17
    ciZ_76 (Z_163 VSS) capacitor c=6.6019e-17
    ciZ_75 (Z_164 VSS) capacitor c=1.1736e-16
    ciZ_74 (Z_168 VSS) capacitor c=2.35197e-16
    ciZ_73 (Z_169 VSS) capacitor c=3.53761e-16
    ciZ_72 (Z_177 VSS) capacitor c=7.15502e-17
    ciZ_71 (Z_179 VSS) capacitor c=6.98889e-17
    ciZ_70 (Z_183 VSS) capacitor c=6.6019e-17
    ciZ_69 (Z_184 VSS) capacitor c=1.1736e-16
    ciZ_68 (Z_188 VSS) capacitor c=2.35197e-16
    ciZ_67 (Z_189 VSS) capacitor c=3.53761e-16
    ciZ_66 (Z_197 VSS) capacitor c=8.74616e-17
    ciZ_65 (Z_199 VSS) capacitor c=8.59455e-17
    ciZ_64 (Z_203 VSS) capacitor c=6.6019e-17
    ciZ_63 (Z_204 VSS) capacitor c=1.1736e-16
    ciZ_62 (Z_208 VSS) capacitor c=2.35197e-16
    ciZ_61 (Z_209 VSS) capacitor c=3.53761e-16
    ciZ_60 (Z_217 VSS) capacitor c=7.15175e-17
    ciZ_59 (Z_219 VSS) capacitor c=6.98562e-17
    ciZ_58 (Z_223 VSS) capacitor c=6.6019e-17
    ciZ_57 (Z_224 VSS) capacitor c=1.1736e-16
    ciZ_56 (Z_228 VSS) capacitor c=2.35197e-16
    ciZ_55 (Z_229 VSS) capacitor c=3.53761e-16
    ciZ_54 (Z_237 VSS) capacitor c=8.78518e-17
    ciZ_53 (Z_239 VSS) capacitor c=8.63776e-17
    ciZ_52 (Z_243 VSS) capacitor c=6.6019e-17
    ciZ_51 (Z_244 VSS) capacitor c=1.1736e-16
    ciZ_50 (Z_248 VSS) capacitor c=2.35197e-16
    ciZ_49 (Z_249 VSS) capacitor c=3.53761e-16
    ciZ_48 (Z_257 VSS) capacitor c=7.15502e-17
    ciZ_47 (Z_259 VSS) capacitor c=6.98889e-17
    ciZ_46 (Z_263 VSS) capacitor c=6.6019e-17
    ciZ_45 (Z_264 VSS) capacitor c=1.1736e-16
    ciZ_44 (Z_268 VSS) capacitor c=2.35197e-16
    ciZ_43 (Z_269 VSS) capacitor c=3.53761e-16
    ciZ_42 (Z_277 VSS) capacitor c=8.75596e-17
    ciZ_41 (Z_279 VSS) capacitor c=8.60435e-17
    ciZ_40 (Z_283 VSS) capacitor c=6.6019e-17
    ciZ_39 (Z_284 VSS) capacitor c=1.1736e-16
    ciZ_38 (Z_288 VSS) capacitor c=2.35197e-16
    ciZ_37 (Z_289 VSS) capacitor c=3.53761e-16
    ciZ_36 (Z_297 VSS) capacitor c=6.26265e-17
    ciZ_35 (Z_299 VSS) capacitor c=5.91308e-17
    ciZ_34 (Z_303 VSS) capacitor c=4.74914e-17
    ciZ_33 (Z_304 VSS) capacitor c=1.1105e-16
    ciZ_32 (Z VSS) capacitor c=4.75908e-17
    ciZ_31 (Z_312 VSS) capacitor c=1.73708e-16
    ciZ_30 (Z_313 VSS) capacitor c=3.2943e-16
    ciZ_29 (Z_321 VSS) capacitor c=1.21372e-17
    ciZ_28 (Z_322 VSS) capacitor c=1.18257e-17
    ciZ_27 (Z_323 VSS) capacitor c=1.21372e-17
    ciZ_26 (Z_324 VSS) capacitor c=1.18257e-17
    ciZ_25 (Z_325 VSS) capacitor c=1.21372e-17
    ciZ_24 (Z_326 VSS) capacitor c=1.18257e-17
    ciZ_23 (Z_327 VSS) capacitor c=1.21372e-17
    ciZ_22 (Z_328 VSS) capacitor c=1.18257e-17
    ciZ_21 (Z_329 VSS) capacitor c=1.21372e-17
    ciZ_20 (Z_330 VSS) capacitor c=1.18257e-17
    ciZ_19 (Z_331 VSS) capacitor c=1.21372e-17
    ciZ_18 (Z_332 VSS) capacitor c=1.18257e-17
    ciZ_17 (Z_333 VSS) capacitor c=1.21372e-17
    ciZ_16 (Z_334 VSS) capacitor c=1.18257e-17
    ciZ_15 (Z_335 VSS) capacitor c=1.21372e-17
    ciZ_14 (Z_336 VSS) capacitor c=1.18257e-17
    ciZ_13 (Z_337 VSS) capacitor c=1.21372e-17
    ciZ_12 (Z_338 VSS) capacitor c=1.18257e-17
    ciZ_11 (Z_339 VSS) capacitor c=1.22948e-17
    ciZ_10 (Z_340 VSS) capacitor c=1.19833e-17
    ciZ_9 (Z_341 VSS) capacitor c=1.21372e-17
    ciZ_8 (Z_342 VSS) capacitor c=1.18257e-17
    ciZ_7 (Z_343 VSS) capacitor c=1.21372e-17
    ciZ_6 (Z_344 VSS) capacitor c=1.18257e-17
    ciZ_5 (Z_345 VSS) capacitor c=1.21372e-17
    ciZ_4 (Z_346 VSS) capacitor c=1.18257e-17
    ciZ_3 (Z_347 VSS) capacitor c=1.21372e-17
    ciZ_2 (Z_348 VSS) capacitor c=1.18257e-17
    ciZ_1 (Z_349 VSS) capacitor c=2.94122e-17
    ciZ_0 (Z_351 VSS) capacitor c=3.52915e-17
    ciVDD_145 (VDD_2 VSS) capacitor c=6.33948e-17
    ciVDD_144 (VDD_11 VSS) capacitor c=2.46976e-16
    ciVDD_143 (VDD_19 VSS) capacitor c=2.44661e-17
    ciVDD_142 (VDD_20 VSS) capacitor c=2.99228e-17
    ciVDD_141 (VDD_27 VSS) capacitor c=2.35983e-16
    ciVDD_140 (VDD_35 VSS) capacitor c=1.64325e-17
    ciVDD_139 (VDD_36 VSS) capacitor c=2.99228e-17
    ciVDD_138 (VDD_43 VSS) capacitor c=2.41288e-16
    ciVDD_137 (VDD_51 VSS) capacitor c=2.26065e-17
    ciVDD_136 (VDD_52 VSS) capacitor c=2.99228e-17
    ciVDD_135 (VDD_59 VSS) capacitor c=2.36054e-16
    ciVDD_134 (VDD_67 VSS) capacitor c=1.64325e-17
    ciVDD_133 (VDD_68 VSS) capacitor c=2.99228e-17
    ciVDD_132 (VDD_72 VSS) capacitor c=2.41355e-16
    ciVDD_131 (VDD_80 VSS) capacitor c=1.91089e-17
    ciVDD_130 (VDD_81 VSS) capacitor c=2.99228e-17
    ciVDD_129 (VDD_85 VSS) capacitor c=2.41355e-16
    ciVDD_128 (VDD_93 VSS) capacitor c=2.40827e-17
    ciVDD_127 (VDD_94 VSS) capacitor c=2.99228e-17
    ciVDD_126 (VDD_101 VSS) capacitor c=2.41355e-16
    ciVDD_125 (VDD_109 VSS) capacitor c=1.91089e-17
    ciVDD_124 (VDD_110 VSS) capacitor c=2.99228e-17
    ciVDD_123 (VDD_117 VSS) capacitor c=2.41355e-16
    ciVDD_122 (VDD_125 VSS) capacitor c=2.40827e-17
    ciVDD_121 (VDD_126 VSS) capacitor c=2.99228e-17
    ciVDD_120 (VDD_133 VSS) capacitor c=2.41355e-16
    ciVDD_119 (VDD_141 VSS) capacitor c=1.91089e-17
    ciVDD_118 (VDD_142 VSS) capacitor c=2.99228e-17
    ciVDD_117 (VDD_149 VSS) capacitor c=2.41355e-16
    ciVDD_116 (VDD_157 VSS) capacitor c=2.40827e-17
    ciVDD_115 (VDD_158 VSS) capacitor c=2.99228e-17
    ciVDD_114 (VDD_165 VSS) capacitor c=2.41355e-16
    ciVDD_113 (VDD_173 VSS) capacitor c=1.91089e-17
    ciVDD_112 (VDD_174 VSS) capacitor c=2.99228e-17
    ciVDD_111 (VDD_181 VSS) capacitor c=2.41355e-16
    ciVDD_110 (VDD_189 VSS) capacitor c=2.40827e-17
    ciVDD_109 (VDD_190 VSS) capacitor c=2.99228e-17
    ciVDD_108 (VDD_194 VSS) capacitor c=2.41355e-16
    ciVDD_107 (VDD_202 VSS) capacitor c=1.91089e-17
    ciVDD_106 (VDD_203 VSS) capacitor c=2.99228e-17
    ciVDD_105 (VDD_207 VSS) capacitor c=2.41355e-16
    ciVDD_104 (VDD_215 VSS) capacitor c=2.40827e-17
    ciVDD_103 (VDD_216 VSS) capacitor c=2.99228e-17
    ciVDD_102 (VDD_223 VSS) capacitor c=2.41355e-16
    ciVDD_101 (VDD_231 VSS) capacitor c=1.91089e-17
    ciVDD_100 (VDD_232 VSS) capacitor c=2.99228e-17
    ciVDD_99 (VDD_239 VSS) capacitor c=2.41355e-16
    ciVDD_98 (VDD_247 VSS) capacitor c=2.40827e-17
    ciVDD_97 (VDD_248 VSS) capacitor c=2.99228e-17
    ciVDD_96 (VDD_255 VSS) capacitor c=2.41355e-16
    ciVDD_95 (VDD_263 VSS) capacitor c=1.91089e-17
    ciVDD_94 (VDD_264 VSS) capacitor c=2.99228e-17
    ciVDD_93 (VDD_271 VSS) capacitor c=2.41355e-16
    ciVDD_92 (VDD_279 VSS) capacitor c=2.40827e-17
    ciVDD_91 (VDD_280 VSS) capacitor c=2.99228e-17
    ciVDD_90 (VDD_287 VSS) capacitor c=2.46976e-16
    ciVDD_89 (VDD_295 VSS) capacitor c=1.91089e-17
    ciVDD_88 (VDD_298 VSS) capacitor c=6.10604e-17
    ciVDD_87 (VDD_301 VSS) capacitor c=3.58509e-18
    ciVDD_86 (VDD_302 VSS) capacitor c=3.58509e-18
    ciVDD_85 (VDD_303 VSS) capacitor c=3.58509e-18
    ciVDD_84 (VDD_304 VSS) capacitor c=3.58509e-18
    ciVDD_83 (VDD_306 VSS) capacitor c=3.58509e-18
    ciVDD_82 (VDD_308 VSS) capacitor c=3.58509e-18
    ciVDD_81 (VDD_309 VSS) capacitor c=3.58509e-18
    ciVDD_80 (VDD_310 VSS) capacitor c=3.58509e-18
    ciVDD_79 (VDD_311 VSS) capacitor c=3.58509e-18
    ciVDD_78 (VDD_312 VSS) capacitor c=3.58509e-18
    ciVDD_77 (VDD_313 VSS) capacitor c=3.58509e-18
    ciVDD_76 (VDD_314 VSS) capacitor c=3.58509e-18
    ciVDD_75 (VDD_316 VSS) capacitor c=3.58509e-18
    ciVDD_74 (VDD_318 VSS) capacitor c=3.58509e-18
    ciVDD_73 (VDD_319 VSS) capacitor c=3.58509e-18
    ciVDD_72 (VDD_320 VSS) capacitor c=3.58509e-18
    ciVDD_71 (VDD_321 VSS) capacitor c=3.58509e-18
    ciVDD_70 (VDD_322 VSS) capacitor c=3.58509e-18
    ciVDD_69 (VDD_323 VSS) capacitor c=3.58509e-18
    ciVDD_68 (VDD_329 VSS) capacitor c=1.32762e-17
    ciVDD_67 (VDD_331 VSS) capacitor c=3.73024e-18
    ciVDD_66 (VDD_334 VSS) capacitor c=1.11099e-18
    ciVDD_65 (VDD_338 VSS) capacitor c=1.11099e-18
    ciVDD_64 (VDD_340 VSS) capacitor c=3.7308e-18
    ciVDD_63 (VDD_343 VSS) capacitor c=4.4347e-18
    ciVDD_62 (VDD_346 VSS) capacitor c=1.11099e-18
    ciVDD_61 (VDD_350 VSS) capacitor c=1.11099e-18
    ciVDD_60 (VDD_352 VSS) capacitor c=4.42768e-18
    ciVDD_59 (VDD_356 VSS) capacitor c=1.11099e-18
    ciVDD_58 (VDD_358 VSS) capacitor c=4.39776e-18
    ciVDD_57 (VDD_361 VSS) capacitor c=3.41486e-18
    ciVDD_56 (VDD_364 VSS) capacitor c=1.11099e-18
    ciVDD_55 (VDD_368 VSS) capacitor c=1.11099e-18
    ciVDD_54 (VDD_370 VSS) capacitor c=3.41486e-18
    ciVDD_53 (VDD_373 VSS) capacitor c=3.41486e-18
    ciVDD_52 (VDD_376 VSS) capacitor c=1.11099e-18
    ciVDD_51 (VDD_380 VSS) capacitor c=1.11099e-18
    ciVDD_50 (VDD_382 VSS) capacitor c=3.41486e-18
    ciVDD_49 (VDD_385 VSS) capacitor c=3.41486e-18
    ciVDD_48 (VDD_388 VSS) capacitor c=1.11099e-18
    ciVDD_47 (VDD_392 VSS) capacitor c=1.11099e-18
    ciVDD_46 (VDD_394 VSS) capacitor c=3.41486e-18
    ciVDD_45 (VDD_397 VSS) capacitor c=3.41486e-18
    ciVDD_44 (VDD_400 VSS) capacitor c=1.11099e-18
    ciVDD_43 (VDD_404 VSS) capacitor c=1.11099e-18
    ciVDD_42 (VDD_406 VSS) capacitor c=3.41486e-18
    ciVDD_41 (VDD_409 VSS) capacitor c=3.41486e-18
    ciVDD_40 (VDD_412 VSS) capacitor c=1.11099e-18
    ciVDD_39 (VDD_416 VSS) capacitor c=1.11099e-18
    ciVDD_38 (VDD_418 VSS) capacitor c=3.41486e-18
    ciVDD_37 (VDD_421 VSS) capacitor c=3.41486e-18
    ciVDD_36 (VDD_424 VSS) capacitor c=1.11099e-18
    ciVDD_35 (VDD_428 VSS) capacitor c=1.11099e-18
    ciVDD_34 (VDD_430 VSS) capacitor c=3.41486e-18
    ciVDD_33 (VDD_433 VSS) capacitor c=3.41486e-18
    ciVDD_32 (VDD_436 VSS) capacitor c=1.11099e-18
    ciVDD_31 (VDD_440 VSS) capacitor c=1.11099e-18
    ciVDD_30 (VDD_442 VSS) capacitor c=3.41486e-18
    ciVDD_29 (MM14_ELT_s VSS) capacitor c=1.75793e-17
    ciVDD_28 (VDD_445 VSS) capacitor c=2.79493e-18
    ciVDD_27 (VDD_448 VSS) capacitor c=1.11099e-18
    ciVDD_26 (VDD_451 VSS) capacitor c=3.76541e-16
    ciVDD_25 (VDD_455 VSS) capacitor c=3.75326e-16
    ciVDD_24 (VDD_457 VSS) capacitor c=3.75358e-16
    ciVDD_23 (VDD_461 VSS) capacitor c=3.73768e-16
    ciVDD_22 (VDD_463 VSS) capacitor c=1.79226e-18
    ciVDD_21 (VDD_465 VSS) capacitor c=3.76541e-16
    ciVDD_20 (VDD_467 VSS) capacitor c=3.76541e-16
    ciVDD_19 (VDD_469 VSS) capacitor c=1.79226e-18
    ciVDD_18 (VDD_471 VSS) capacitor c=3.76541e-16
    ciVDD_17 (VDD_473 VSS) capacitor c=3.76541e-16
    ciVDD_16 (VDD_475 VSS) capacitor c=1.79226e-18
    ciVDD_15 (VDD_477 VSS) capacitor c=3.76541e-16
    ciVDD_14 (VDD_479 VSS) capacitor c=3.76541e-16
    ciVDD_13 (VDD_481 VSS) capacitor c=1.79226e-18
    ciVDD_12 (VDD_483 VSS) capacitor c=3.76541e-16
    ciVDD_11 (VDD_485 VSS) capacitor c=3.76541e-16
    ciVDD_10 (VDD_487 VSS) capacitor c=1.79226e-18
    ciVDD_9 (VDD_489 VSS) capacitor c=3.76541e-16
    ciVDD_8 (VDD_491 VSS) capacitor c=3.76541e-16
    ciVDD_7 (VDD_493 VSS) capacitor c=1.79226e-18
    ciVDD_6 (VDD_495 VSS) capacitor c=3.76541e-16
    ciVDD_5 (VDD_497 VSS) capacitor c=3.76541e-16
    ciVDD_4 (VDD_499 VSS) capacitor c=1.79226e-18
    ciVDD_3 (VDD_501 VSS) capacitor c=3.76541e-16
    ciVDD_2 (VDD_503 VSS) capacitor c=3.76541e-16
    ciVDD_1 (VDD_505 VSS) capacitor c=1.89644e-18
    ciVDD_0 (VDD_507 VSS) capacitor c=3.76541e-16
    ciVSS_105 (VSS_2 VSS) capacitor c=6.17014e-17
    ciVSS_104 (VSS_11 VSS) capacitor c=7.60187e-17
    ciVSS_103 (VSS_12 VSS) capacitor c=1.25652e-16
    ciVSS_102 (VSS_14 VSS) capacitor c=2.92901e-17
    ciVSS_101 (VSS_21 VSS) capacitor c=6.60985e-17
    ciVSS_100 (VSS_22 VSS) capacitor c=1.17048e-16
    ciVSS_99 (VSS_24 VSS) capacitor c=2.86937e-17
    ciVSS_98 (VSS_31 VSS) capacitor c=7.15545e-17
    ciVSS_97 (VSS_32 VSS) capacitor c=1.23258e-16
    ciVSS_96 (VSS_34 VSS) capacitor c=2.86937e-17
    ciVSS_95 (VSS_41 VSS) capacitor c=6.61588e-17
    ciVSS_94 (VSS_42 VSS) capacitor c=1.15631e-16
    ciVSS_93 (VSS_44 VSS) capacitor c=2.86937e-17
    ciVSS_92 (VSS_48 VSS) capacitor c=7.16193e-17
    ciVSS_91 (VSS_49 VSS) capacitor c=1.20772e-16
    ciVSS_90 (VSS_51 VSS) capacitor c=2.86937e-17
    ciVSS_89 (VSS_55 VSS) capacitor c=7.16193e-17
    ciVSS_88 (VSS_56 VSS) capacitor c=1.25763e-16
    ciVSS_87 (VSS_58 VSS) capacitor c=2.86937e-17
    ciVSS_86 (VSS_65 VSS) capacitor c=7.16193e-17
    ciVSS_85 (VSS_66 VSS) capacitor c=1.20772e-16
    ciVSS_84 (VSS_68 VSS) capacitor c=2.86937e-17
    ciVSS_83 (VSS_75 VSS) capacitor c=7.16193e-17
    ciVSS_82 (VSS_76 VSS) capacitor c=1.25763e-16
    ciVSS_81 (VSS_78 VSS) capacitor c=2.86937e-17
    ciVSS_80 (VSS_85 VSS) capacitor c=7.16193e-17
    ciVSS_79 (VSS_86 VSS) capacitor c=1.20772e-16
    ciVSS_78 (VSS_88 VSS) capacitor c=2.86937e-17
    ciVSS_77 (VSS_95 VSS) capacitor c=7.16193e-17
    ciVSS_76 (VSS_96 VSS) capacitor c=1.25763e-16
    ciVSS_75 (VSS_98 VSS) capacitor c=2.86937e-17
    ciVSS_74 (VSS_105 VSS) capacitor c=7.16193e-17
    ciVSS_73 (VSS_106 VSS) capacitor c=1.20772e-16
    ciVSS_72 (VSS_108 VSS) capacitor c=2.86937e-17
    ciVSS_71 (VSS_115 VSS) capacitor c=7.16193e-17
    ciVSS_70 (VSS_116 VSS) capacitor c=1.25763e-16
    ciVSS_69 (VSS_118 VSS) capacitor c=2.86937e-17
    ciVSS_68 (VSS_122 VSS) capacitor c=7.16193e-17
    ciVSS_67 (VSS_123 VSS) capacitor c=1.20772e-16
    ciVSS_66 (VSS_125 VSS) capacitor c=2.86937e-17
    ciVSS_65 (VSS_129 VSS) capacitor c=7.16193e-17
    ciVSS_64 (VSS_130 VSS) capacitor c=1.25763e-16
    ciVSS_63 (VSS_132 VSS) capacitor c=2.86937e-17
    ciVSS_62 (VSS_139 VSS) capacitor c=7.16193e-17
    ciVSS_61 (VSS_140 VSS) capacitor c=1.20772e-16
    ciVSS_60 (VSS_142 VSS) capacitor c=2.86937e-17
    ciVSS_59 (VSS_149 VSS) capacitor c=7.16193e-17
    ciVSS_58 (VSS_150 VSS) capacitor c=1.25763e-16
    ciVSS_57 (VSS_152 VSS) capacitor c=2.86937e-17
    ciVSS_56 (VSS_159 VSS) capacitor c=7.16193e-17
    ciVSS_55 (VSS_160 VSS) capacitor c=1.20772e-16
    ciVSS_54 (VSS_162 VSS) capacitor c=2.86937e-17
    ciVSS_53 (VSS_169 VSS) capacitor c=7.16193e-17
    ciVSS_52 (VSS_170 VSS) capacitor c=1.25763e-16
    ciVSS_51 (VSS_172 VSS) capacitor c=2.86937e-17
    ciVSS_50 (VSS_179 VSS) capacitor c=7.60187e-17
    ciVSS_49 (VSS_180 VSS) capacitor c=1.21868e-16
    ciVSS_48 (VSS_184 VSS) capacitor c=5.90206e-17
    ciVSS_47 (VSS_187 VSS) capacitor c=3.58509e-18
    ciVSS_46 (VSS_188 VSS) capacitor c=3.58509e-18
    ciVSS_45 (VSS_189 VSS) capacitor c=3.58509e-18
    ciVSS_44 (VSS_190 VSS) capacitor c=3.58509e-18
    ciVSS_43 (VSS_192 VSS) capacitor c=3.58509e-18
    ciVSS_42 (VSS_194 VSS) capacitor c=3.58509e-18
    ciVSS_41 (VSS_195 VSS) capacitor c=3.58509e-18
    ciVSS_40 (VSS_196 VSS) capacitor c=3.58509e-18
    ciVSS_39 (VSS_197 VSS) capacitor c=3.58509e-18
    ciVSS_38 (VSS_198 VSS) capacitor c=3.58509e-18
    ciVSS_37 (VSS_199 VSS) capacitor c=3.58509e-18
    ciVSS_36 (VSS_200 VSS) capacitor c=3.58509e-18
    ciVSS_35 (VSS_202 VSS) capacitor c=3.58509e-18
    ciVSS_34 (VSS_204 VSS) capacitor c=3.58509e-18
    ciVSS_33 (VSS_205 VSS) capacitor c=3.58509e-18
    ciVSS_32 (VSS_206 VSS) capacitor c=3.58509e-18
    ciVSS_31 (VSS_207 VSS) capacitor c=3.58509e-18
    ciVSS_30 (VSS_208 VSS) capacitor c=3.58509e-18
    ciVSS_29 (VSS_209 VSS) capacitor c=3.58509e-18
    ciVSS_28 (VSS_218 VSS) capacitor c=2.62471e-18
    ciVSS_27 (VSS_224 VSS) capacitor c=2.66006e-18
    ciVSS_26 (VSS_230 VSS) capacitor c=3.39806e-18
    ciVSS_25 (VSS_236 VSS) capacitor c=3.32467e-18
    ciVSS_24 (VSS_242 VSS) capacitor c=3.29332e-18
    ciVSS_23 (VSS_248 VSS) capacitor c=2.31042e-18
    ciVSS_22 (VSS_254 VSS) capacitor c=2.31042e-18
    ciVSS_21 (VSS_260 VSS) capacitor c=2.31042e-18
    ciVSS_20 (VSS_266 VSS) capacitor c=2.31042e-18
    ciVSS_19 (VSS_272 VSS) capacitor c=2.31042e-18
    ciVSS_18 (VSS_278 VSS) capacitor c=2.31042e-18
    ciVSS_17 (VSS_284 VSS) capacitor c=2.31042e-18
    ciVSS_16 (VSS_290 VSS) capacitor c=2.31042e-18
    ciVSS_15 (VSS_296 VSS) capacitor c=2.31042e-18
    ciVSS_14 (VSS_302 VSS) capacitor c=2.31042e-18
    ciVSS_13 (VSS_308 VSS) capacitor c=2.31042e-18
    ciVSS_12 (VSS_314 VSS) capacitor c=2.31042e-18
    ciVSS_11 (VSS_320 VSS) capacitor c=2.31042e-18
    ciVSS_10 (VSS_326 VSS) capacitor c=2.31042e-18
    ciVSS_9 (MM15_ELT_s VSS) capacitor c=3.51765e-18
    ciVSS_8 (VSS_332 VSS) capacitor c=1.66339e-18
    ciVSS_7 (VSS_349 VSS) capacitor c=1.80133e-18
    ciVSS_6 (VSS_355 VSS) capacitor c=1.80133e-18
    ciVSS_5 (VSS_361 VSS) capacitor c=1.80133e-18
    ciVSS_4 (VSS_367 VSS) capacitor c=1.80133e-18
    ciVSS_3 (VSS_373 VSS) capacitor c=1.80133e-18
    ciVSS_2 (VSS_379 VSS) capacitor c=1.80133e-18
    ciVSS_1 (VSS_385 VSS) capacitor c=1.80133e-18
    ciVSS_0 (VSS_391 VSS) capacitor c=1.90066e-18
    cinet11_258 (net11_322 VSS) capacitor c=3.00043e-18
    cinet11_257 (net11_328 VSS) capacitor c=2.47633e-16
    cinet11_256 (net11_339 VSS) capacitor c=7.70883e-16
    cinet11_255 (net11_345 VSS) capacitor c=3.00043e-18
    cinet11_254 (net11_350 VSS) capacitor c=2.2416e-17
    cinet11_253 (net11_358 VSS) capacitor c=1.99976e-17
    cinet11_252 (net11_366 VSS) capacitor c=1.34072e-17
    cinet11_251 (net11_374 VSS) capacitor c=1.51948e-17
    cinet11_250 (net11_382 VSS) capacitor c=3.00043e-18
    cinet11_249 (net11_385 VSS) capacitor c=3.24288e-18
    cinet11_248 (net11_390 VSS) capacitor c=2.75982e-18
    cinet11_247 (net11_393 VSS) capacitor c=3.00043e-18
    cinet11_246 (net11_398 VSS) capacitor c=3.00043e-18
    cinet11_245 (net11_401 VSS) capacitor c=3.24288e-18
    cinet11_244 (net11_404 VSS) capacitor c=2.40662e-16
    cinet11_243 (net11_406 VSS) capacitor c=2.75982e-18
    cinet11_242 (net11_409 VSS) capacitor c=3.00043e-18
    cinet11_241 (net11_412 VSS) capacitor c=7.64189e-16
    cinet11_240 (net11_414 VSS) capacitor c=2.2416e-17
    cinet11_239 (net11_422 VSS) capacitor c=2.10003e-17
    cinet11_238 (net11_430 VSS) capacitor c=1.45586e-17
    cinet11_237 (net11_438 VSS) capacitor c=1.51948e-17
    cinet11_236 (net11_446 VSS) capacitor c=3.00043e-18
    cinet11_235 (net11_469 VSS) capacitor c=3.00043e-18
    cinet11_234 (net11_474 VSS) capacitor c=3.00043e-18
    cinet11_233 (net11_480 VSS) capacitor c=2.40752e-16
    cinet11_232 (net11_491 VSS) capacitor c=7.64278e-16
    cinet11_231 (net11_497 VSS) capacitor c=3.00043e-18
    cinet11_230 (net11_502 VSS) capacitor c=2.2416e-17
    cinet11_229 (net11_510 VSS) capacitor c=2.10003e-17
    cinet11_228 (net11_518 VSS) capacitor c=1.45586e-17
    cinet11_227 (net11_526 VSS) capacitor c=1.51948e-17
    cinet11_226 (net11_534 VSS) capacitor c=3.00043e-18
    cinet11_225 (net11_537 VSS) capacitor c=3.24288e-18
    cinet11_224 (net11_542 VSS) capacitor c=2.75982e-18
    cinet11_223 (net11_545 VSS) capacitor c=3.00043e-18
    cinet11_222 (net11_550 VSS) capacitor c=3.00043e-18
    cinet11_221 (net11_553 VSS) capacitor c=3.24288e-18
    cinet11_220 (net11_556 VSS) capacitor c=2.40752e-16
    cinet11_219 (net11_558 VSS) capacitor c=2.75982e-18
    cinet11_218 (net11_561 VSS) capacitor c=3.00043e-18
    cinet11_217 (net11_564 VSS) capacitor c=7.64278e-16
    cinet11_216 (net11_566 VSS) capacitor c=2.2416e-17
    cinet11_215 (net11_574 VSS) capacitor c=2.10003e-17
    cinet11_214 (net11_582 VSS) capacitor c=1.45586e-17
    cinet11_213 (net11_590 VSS) capacitor c=1.51948e-17
    cinet11_212 (net11_598 VSS) capacitor c=3.00043e-18
    cinet11_211 (net11_621 VSS) capacitor c=3.00043e-18
    cinet11_210 (net11_626 VSS) capacitor c=3.00043e-18
    cinet11_209 (net11_632 VSS) capacitor c=2.40752e-16
    cinet11_208 (net11_643 VSS) capacitor c=7.64278e-16
    cinet11_207 (net11_649 VSS) capacitor c=3.00043e-18
    cinet11_206 (net11_654 VSS) capacitor c=2.2416e-17
    cinet11_205 (net11_662 VSS) capacitor c=2.10003e-17
    cinet11_204 (net11_670 VSS) capacitor c=1.45586e-17
    cinet11_203 (net11_678 VSS) capacitor c=1.51948e-17
    cinet11_202 (net11_686 VSS) capacitor c=3.00043e-18
    cinet11_201 (net11_689 VSS) capacitor c=3.24288e-18
    cinet11_200 (net11_694 VSS) capacitor c=2.75982e-18
    cinet11_199 (net11_697 VSS) capacitor c=3.00043e-18
    cinet11_198 (net11_702 VSS) capacitor c=3.00043e-18
    cinet11_197 (net11_705 VSS) capacitor c=3.24288e-18
    cinet11_196 (net11_708 VSS) capacitor c=2.40752e-16
    cinet11_195 (net11_710 VSS) capacitor c=2.75982e-18
    cinet11_194 (net11_713 VSS) capacitor c=3.00043e-18
    cinet11_193 (net11_716 VSS) capacitor c=7.64278e-16
    cinet11_192 (net11_718 VSS) capacitor c=2.2416e-17
    cinet11_191 (net11_726 VSS) capacitor c=2.10003e-17
    cinet11_190 (net11_734 VSS) capacitor c=1.45586e-17
    cinet11_189 (net11_742 VSS) capacitor c=1.51948e-17
    cinet11_188 (net11_750 VSS) capacitor c=3.00043e-18
    cinet11_187 (net11_773 VSS) capacitor c=3.00043e-18
    cinet11_186 (net11_778 VSS) capacitor c=3.00043e-18
    cinet11_185 (net11_784 VSS) capacitor c=2.40752e-16
    cinet11_184 (net11_795 VSS) capacitor c=7.64278e-16
    cinet11_183 (net11_801 VSS) capacitor c=3.00043e-18
    cinet11_182 (net11_806 VSS) capacitor c=2.2416e-17
    cinet11_181 (net11_814 VSS) capacitor c=2.10003e-17
    cinet11_180 (net11_822 VSS) capacitor c=1.45586e-17
    cinet11_179 (net11_830 VSS) capacitor c=1.51948e-17
    cinet11_178 (net11_838 VSS) capacitor c=3.00043e-18
    cinet11_177 (net11_841 VSS) capacitor c=3.24288e-18
    cinet11_176 (net11_846 VSS) capacitor c=2.75982e-18
    cinet11_175 (net11_849 VSS) capacitor c=3.00043e-18
    cinet11_174 (net11_854 VSS) capacitor c=3.00043e-18
    cinet11_173 (net11_857 VSS) capacitor c=3.24288e-18
    cinet11_172 (net11_860 VSS) capacitor c=2.40752e-16
    cinet11_171 (net11_862 VSS) capacitor c=2.75982e-18
    cinet11_170 (net11_865 VSS) capacitor c=3.00043e-18
    cinet11_169 (net11_868 VSS) capacitor c=7.64278e-16
    cinet11_168 (net11_870 VSS) capacitor c=2.2416e-17
    cinet11_167 (net11_878 VSS) capacitor c=2.10003e-17
    cinet11_166 (net11_886 VSS) capacitor c=1.45586e-17
    cinet11_165 (net11_894 VSS) capacitor c=1.51948e-17
    cinet11_164 (net11_902 VSS) capacitor c=3.00043e-18
    cinet11_163 (net11_925 VSS) capacitor c=3.00043e-18
    cinet11_162 (net11_930 VSS) capacitor c=3.00043e-18
    cinet11_161 (net11_936 VSS) capacitor c=2.40752e-16
    cinet11_160 (net11_947 VSS) capacitor c=7.64278e-16
    cinet11_159 (net11_953 VSS) capacitor c=3.00043e-18
    cinet11_158 (net11_958 VSS) capacitor c=2.2416e-17
    cinet11_157 (net11_966 VSS) capacitor c=2.10003e-17
    cinet11_156 (net11_974 VSS) capacitor c=1.45586e-17
    cinet11_155 (net11_982 VSS) capacitor c=1.51948e-17
    cinet11_154 (net11_990 VSS) capacitor c=3.00043e-18
    cinet11_153 (net11_993 VSS) capacitor c=3.24288e-18
    cinet11_152 (net11_998 VSS) capacitor c=2.75982e-18
    cinet11_151 (net11_1001 VSS) capacitor c=3.00043e-18
    cinet11_150 (net11_1006 VSS) capacitor c=3.00043e-18
    cinet11_149 (net11_1009 VSS) capacitor c=3.24288e-18
    cinet11_148 (net11_1012 VSS) capacitor c=2.40752e-16
    cinet11_147 (net11_1014 VSS) capacitor c=2.75982e-18
    cinet11_146 (net11_1017 VSS) capacitor c=3.00043e-18
    cinet11_145 (net11_1020 VSS) capacitor c=7.64278e-16
    cinet11_144 (net11_1022 VSS) capacitor c=2.2416e-17
    cinet11_143 (net11_1030 VSS) capacitor c=2.09023e-17
    cinet11_142 (net11_1038 VSS) capacitor c=1.44606e-17
    cinet11_141 (net11_1046 VSS) capacitor c=1.51948e-17
    cinet11_140 (net11_1054 VSS) capacitor c=3.00043e-18
    cinet11_139 (net11_1077 VSS) capacitor c=3.00043e-18
    cinet11_138 (net11_1082 VSS) capacitor c=3.00043e-18
    cinet11_137 (net11_1088 VSS) capacitor c=2.40752e-16
    cinet11_136 (net11_1099 VSS) capacitor c=7.64278e-16
    cinet11_135 (net11_1105 VSS) capacitor c=3.00043e-18
    cinet11_134 (net11_1110 VSS) capacitor c=2.2416e-17
    cinet11_133 (net11_1118 VSS) capacitor c=2.10003e-17
    cinet11_132 (net11_1126 VSS) capacitor c=1.45586e-17
    cinet11_131 (net11_1134 VSS) capacitor c=1.51948e-17
    cinet11_130 (net11_1142 VSS) capacitor c=3.00043e-18
    cinet11_129 (net11_1145 VSS) capacitor c=3.24288e-18
    cinet11_128 (net11_1150 VSS) capacitor c=2.75982e-18
    cinet11_127 (net11_1153 VSS) capacitor c=3.00043e-18
    cinet11_126 (net11_1158 VSS) capacitor c=3.00043e-18
    cinet11_125 (net11_1161 VSS) capacitor c=3.24288e-18
    cinet11_124 (net11_1164 VSS) capacitor c=2.40752e-16
    cinet11_123 (net11_1166 VSS) capacitor c=2.75982e-18
    cinet11_122 (net11_1169 VSS) capacitor c=3.00043e-18
    cinet11_121 (net11_1172 VSS) capacitor c=7.64278e-16
    cinet11_120 (net11_1174 VSS) capacitor c=2.2416e-17
    cinet11_119 (net11_1182 VSS) capacitor c=2.10003e-17
    cinet11_118 (net11_1190 VSS) capacitor c=1.45586e-17
    cinet11_117 (net11_1198 VSS) capacitor c=1.51948e-17
    cinet11_116 (net11_1206 VSS) capacitor c=3.00043e-18
    cinet11_115 (net11_1229 VSS) capacitor c=3.00043e-18
    cinet11_114 (net11_1234 VSS) capacitor c=3.00043e-18
    cinet11_113 (net11_1240 VSS) capacitor c=2.40752e-16
    cinet11_112 (net11_1251 VSS) capacitor c=7.64278e-16
    cinet11_111 (net11_1257 VSS) capacitor c=3.00043e-18
    cinet11_110 (net11_1262 VSS) capacitor c=2.2416e-17
    cinet11_109 (net11_1270 VSS) capacitor c=2.10003e-17
    cinet11_108 (net11_1278 VSS) capacitor c=1.45586e-17
    cinet11_107 (net11_1286 VSS) capacitor c=1.51948e-17
    cinet11_106 (net11_1294 VSS) capacitor c=3.00043e-18
    cinet11_105 (net11_1297 VSS) capacitor c=3.24288e-18
    cinet11_104 (net11_1302 VSS) capacitor c=2.75982e-18
    cinet11_103 (net11_1305 VSS) capacitor c=3.00043e-18
    cinet11_102 (net11_1310 VSS) capacitor c=3.00043e-18
    cinet11_101 (net11_1313 VSS) capacitor c=3.24288e-18
    cinet11_100 (net11_1316 VSS) capacitor c=2.40752e-16
    cinet11_99 (net11_1318 VSS) capacitor c=2.75982e-18
    cinet11_98 (net11_1321 VSS) capacitor c=3.00043e-18
    cinet11_97 (net11_1324 VSS) capacitor c=7.64278e-16
    cinet11_96 (net11_1326 VSS) capacitor c=2.2416e-17
    cinet11_95 (net11_1334 VSS) capacitor c=2.10003e-17
    cinet11_94 (net11_1342 VSS) capacitor c=1.45586e-17
    cinet11_93 (net11_1350 VSS) capacitor c=1.51948e-17
    cinet11_92 (net11_1358 VSS) capacitor c=3.00043e-18
    cinet11_91 (net11_1381 VSS) capacitor c=3.00043e-18
    cinet11_90 (net11_1386 VSS) capacitor c=3.00043e-18
    cinet11_89 (net11_1392 VSS) capacitor c=2.40752e-16
    cinet11_88 (net11_1403 VSS) capacitor c=7.64278e-16
    cinet11_87 (net11_1409 VSS) capacitor c=3.00043e-18
    cinet11_86 (net11_1414 VSS) capacitor c=2.2416e-17
    cinet11_85 (net11_1422 VSS) capacitor c=2.10003e-17
    cinet11_84 (net11_1430 VSS) capacitor c=1.45586e-17
    cinet11_83 (net11_1438 VSS) capacitor c=1.51948e-17
    cinet11_82 (net11_1446 VSS) capacitor c=3.00043e-18
    cinet11_81 (net11_1449 VSS) capacitor c=3.24095e-18
    cinet11_80 (net11_1454 VSS) capacitor c=2.75982e-18
    cinet11_79 (net11_1457 VSS) capacitor c=3.00043e-18
    cinet11_78 (net11_1462 VSS) capacitor c=4.24886e-18
    cinet11_77 (net11_1465 VSS) capacitor c=3.22008e-18
    cinet11_76 (net11_1468 VSS) capacitor c=1.86446e-16
    cinet11_75 (net11_1470 VSS) capacitor c=3.00036e-18
    cinet11_74 (net11_1473 VSS) capacitor c=4.28147e-18
    cinet11_73 (net11_1476 VSS) capacitor c=5.73739e-16
    cinet11_72 (net11_1478 VSS) capacitor c=2.23559e-17
    cinet11_71 (net11_1486 VSS) capacitor c=2.27059e-17
    cinet11_70 (net11_1494 VSS) capacitor c=1.64637e-17
    cinet11_69 (net11_1502 VSS) capacitor c=1.51948e-17
    cinet11_68 (net11_1510 VSS) capacitor c=2.11871e-18
    cinet11_67 (net11_1533 VSS) capacitor c=2.22299e-18
    cinet11_66 (net11_2083 VSS) capacitor c=5.3709e-17
    cinet11_65 (net11_2084 VSS) capacitor c=1.11612e-16
    cinet11_64 (net11_2088 VSS) capacitor c=1.8747e-16
    cinet11_63 (net11_2089 VSS) capacitor c=3.2986e-16
    cinet11_62 (net11_2097 VSS) capacitor c=6.7778e-17
    cinet11_61 (net11_2098 VSS) capacitor c=1.47023e-17
    cinet11_60 (net11_2099 VSS) capacitor c=6.6241e-17
    cinet11_59 (net11_2100 VSS) capacitor c=1.36403e-17
    cinet11_58 (net11_2102 VSS) capacitor c=5.2339e-18
    cinet11_57 (net11_2104 VSS) capacitor c=5.2339e-18
    cinet11_56 (net11_2107 VSS) capacitor c=6.6019e-17
    cinet11_55 (net11_2108 VSS) capacitor c=1.16798e-16
    cinet11_54 (net11_2112 VSS) capacitor c=2.35197e-16
    cinet11_53 (net11_2113 VSS) capacitor c=3.53332e-16
    cinet11_52 (net11_2121 VSS) capacitor c=7.31391e-17
    cinet11_51 (net11_2125 VSS) capacitor c=6.6019e-17
    cinet11_50 (net11_2126 VSS) capacitor c=1.16798e-16
    cinet11_49 (net11_2130 VSS) capacitor c=2.35197e-16
    cinet11_48 (net11_2131 VSS) capacitor c=3.53332e-16
    cinet11_47 (net11_2139 VSS) capacitor c=8.77555e-18
    cinet11_46 (net11_2140 VSS) capacitor c=6.06946e-18
    cinet11_45 (net11_2142 VSS) capacitor c=1.76069e-18
    cinet11_44 (net11_2144 VSS) capacitor c=1.76069e-18
    cinet11_43 (net11_2145 VSS) capacitor c=2.19463e-17
    cinet11_42 (net11_2146 VSS) capacitor c=3.15796e-17
    cinet11_41 (net11_2159 VSS) capacitor c=1.65369e-18
    cinet11_40 (net11_2180 VSS) capacitor c=7.12206e-19
    cinet11_39 (net11_2185 VSS) capacitor c=1.67807e-15
    cinet11_38 (net11_2188 VSS) capacitor c=2.04969e-17
    cinet11_37 (net11_2192 VSS) capacitor c=6.68513e-17
    cinet11_36 (net11_2193 VSS) capacitor c=1.1682e-16
    cinet11_35 (net11_2197 VSS) capacitor c=2.35943e-16
    cinet11_34 (net11_2198 VSS) capacitor c=3.53405e-16
    cinet11_33 (net11_2206 VSS) capacitor c=1.11642e-17
    cinet11_32 (net11_2207 VSS) capacitor c=2.60216e-17
    cinet11_31 (net11_2208 VSS) capacitor c=1.01774e-17
    cinet11_30 (net11_2212 VSS) capacitor c=1.13026e-17
    cinet11_29 (net11_2213 VSS) capacitor c=1.50518e-17
    cinet11_28 (net11_2670 VSS) capacitor c=1.72103e-17
    cinet11_27 (net11_2740 VSS) capacitor c=1.72103e-17
    cinet11_26 (net11_2810 VSS) capacitor c=1.78365e-17
    cinet11_25 (net11_2948 VSS) capacitor c=1.78365e-17
    cinet11_24 (net11_3018 VSS) capacitor c=1.72103e-17
    cinet11_23 (net11_3091 VSS) capacitor c=3.46855e-18
    cinet11_22 (net11_3105 VSS) capacitor c=5.4682e-17
    cinet11_21 (net11_3106 VSS) capacitor c=7.12206e-19
    cinet11_20 (net11_3112 VSS) capacitor c=1.78365e-17
    cinet11_19 (net11_3113 VSS) capacitor c=7.12206e-19
    cinet11_18 (net11_3126 VSS) capacitor c=5.54869e-17
    cinet11_17 (net11_3127 VSS) capacitor c=7.12206e-19
    cinet11_16 (net11_3144 VSS) capacitor c=5.45454e-17
    cinet11_15 (net11_3145 VSS) capacitor c=7.12206e-19
    cinet11_14 (net11_3151 VSS) capacitor c=1.65369e-18
    cinet11_13 (net11_3164 VSS) capacitor c=5.45135e-17
    cinet11_12 (net11_3165 VSS) capacitor c=1.02743e-18
    cinet11_11 (net11_3171 VSS) capacitor c=7.12206e-19
    cinet11_10 (net11_3185 VSS) capacitor c=5.45454e-17
    cinet11_9 (net11_3186 VSS) capacitor c=7.12206e-19
    cinet11_8 (net11_3192 VSS) capacitor c=1.78365e-17
    cinet11_7 (net11_3193 VSS) capacitor c=7.12206e-19
    cinet11_6 (net11_3206 VSS) capacitor c=5.51104e-17
    cinet11_5 (net11_3207 VSS) capacitor c=7.12206e-19
    cinet11_4 (net11_3224 VSS) capacitor c=5.54869e-17
    cinet11_3 (net11_3225 VSS) capacitor c=7.12206e-19
    cinet11_2 (net11_3231 VSS) capacitor c=1.65369e-18
    cinet11_1 (net11_3244 VSS) capacitor c=6.30141e-17
    cinet11_0 (net11_3245 VSS) capacitor c=6.69133e-18
    ciI_54 (I_82 VSS) capacitor c=2.22299e-18
    ciI_53 (I_88 VSS) capacitor c=1.76646e-16
    ciI_52 (I_93 VSS) capacitor c=2.22299e-18
    ciI_51 (I_96 VSS) capacitor c=5.60711e-16
    ciI_50 (I_98 VSS) capacitor c=2.2416e-17
    ciI_49 (I_106 VSS) capacitor c=2.11422e-17
    ciI_48 (I_114 VSS) capacitor c=1.4359e-17
    ciI_47 (I_122 VSS) capacitor c=1.51948e-17
    ciI_46 (I_130 VSS) capacitor c=4.24886e-18
    ciI_45 (I_153 VSS) capacitor c=4.28147e-18
    ciI_44 (I_158 VSS) capacitor c=3.00043e-18
    ciI_43 (I_164 VSS) capacitor c=2.4399e-16
    ciI_42 (I_175 VSS) capacitor c=7.67537e-16
    ciI_41 (I_181 VSS) capacitor c=3.00043e-18
    ciI_40 (I_186 VSS) capacitor c=2.2416e-17
    ciI_39 (I_194 VSS) capacitor c=2.1787e-17
    ciI_38 (I_202 VSS) capacitor c=1.51932e-17
    ciI_37 (I_210 VSS) capacitor c=1.51948e-17
    ciI_36 (I_218 VSS) capacitor c=3.00043e-18
    ciI_35 (I_221 VSS) capacitor c=7.27663e-19
    ciI_34 (I_226 VSS) capacitor c=7.27663e-19
    ciI_33 (I_229 VSS) capacitor c=3.00043e-18
    ciI_32 (I_234 VSS) capacitor c=3.00043e-18
    ciI_31 (I_237 VSS) capacitor c=7.27663e-19
    ciI_30 (I_240 VSS) capacitor c=2.45347e-16
    ciI_29 (I_242 VSS) capacitor c=7.27663e-19
    ciI_28 (I_245 VSS) capacitor c=3.00043e-18
    ciI_27 (I_248 VSS) capacitor c=7.68779e-16
    ciI_26 (I_250 VSS) capacitor c=2.2416e-17
    ciI_25 (I_258 VSS) capacitor c=2.23063e-17
    ciI_24 (I_266 VSS) capacitor c=1.56276e-17
    ciI_23 (I_274 VSS) capacitor c=1.51948e-17
    ciI_22 (I_282 VSS) capacitor c=3.00043e-18
    ciI_21 (I_305 VSS) capacitor c=3.00043e-18
    ciI_20 (I_310 VSS) capacitor c=3.00043e-18
    ciI_19 (I_316 VSS) capacitor c=2.51121e-16
    ciI_18 (I_327 VSS) capacitor c=7.73898e-16
    ciI_17 (I_333 VSS) capacitor c=3.00043e-18
    ciI_16 (I_338 VSS) capacitor c=2.2416e-17
    ciI_15 (I_346 VSS) capacitor c=2.40729e-17
    ciI_14 (I_354 VSS) capacitor c=1.74825e-17
    ciI_13 (I_362 VSS) capacitor c=1.51948e-17
    ciI_12 (I_370 VSS) capacitor c=3.00043e-18
    ciI_11 (I_373 VSS) capacitor c=4.61887e-18
    ciI_10 (I_378 VSS) capacitor c=4.61887e-18
    ciI_9 (I_381 VSS) capacitor c=3.00043e-18
    ciI_8 (I VSS) capacitor c=1.04958e-16
    ciI_7 (I_641 VSS) capacitor c=1.79419e-17
    ciI_6 (I_661 VSS) capacitor c=7.4151e-17
    ciI_5 (I_713 VSS) capacitor c=2.51165e-17
    ciI_4 (I_755 VSS) capacitor c=2.62598e-17
    ciI_3 (I_756 VSS) capacitor c=7.12206e-19
    ciI_2 (I_761 VSS) capacitor c=2.31931e-18
    ciI_1 (I_774 VSS) capacitor c=2.20941e-18
    ciI_0 (I_779 VSS) capacitor c=8.42065e-18
    rZ_442 (Z_1 Z_3) resistor r=0.440166
    rZ_441 (Z_1 Z_18) resistor r=0.0992625
    rZ_440 (Z_3 Z_4) resistor r=13
    rZ_439 (Z_4 MM32_ELT_d) resistor r=8.44
    rZ_438 (Z_6 Z_8) resistor r=0.551675
    rZ_437 (Z_6 Z_20) resistor r=0.0973031
    rZ_436 (Z_8 Z_9) resistor r=8.66667
    rZ_435 (Z_8 Z_11) resistor r=0.704266
    rZ_434 (Z_9 MM40_ELT_d) resistor r=32.3614
    rZ_433 (Z_11 Z_12) resistor r=8.66667
    rZ_432 (Z_11 Z_14) resistor r=0.469511
    rZ_431 (Z_12 MM40_ELT_d) resistor r=16.1807
    rZ_430 (Z_12 Z_15) resistor r=32.3614
    rZ_429 (Z_14 Z_15) resistor r=26
    rZ_428 (Z_17 Z_18) resistor r=0.5311
    rZ_427 (Z_17 Z_321) resistor r=0.054866
    rZ_426 (Z_19 Z_20) resistor r=0.625471
    rZ_425 (Z_19 Z_322) resistor r=0.0614071
    rZ_424 (Z_21 Z_23) resistor r=0.440166
    rZ_423 (Z_21 Z_321) resistor r=0.0361646
    rZ_422 (Z_23 Z_24) resistor r=13
    rZ_421 (Z_24 MM31_ELT_d) resistor r=8.44
    rZ_420 (Z_26 Z_28) resistor r=0.551675
    rZ_419 (Z_26 Z_322) resistor r=0.0294371
    rZ_418 (Z_28 Z_29) resistor r=8.66667
    rZ_417 (Z_28 Z_31) resistor r=0.704266
    rZ_416 (Z_29 MM39_ELT_d) resistor r=32.3614
    rZ_415 (Z_31 Z_32) resistor r=8.66667
    rZ_414 (Z_31 Z_34) resistor r=0.469511
    rZ_413 (Z_32 MM39_ELT_d) resistor r=16.1807
    rZ_412 (Z_32 Z_35) resistor r=32.3614
    rZ_411 (Z_34 Z_35) resistor r=26
    rZ_410 (Z_37 Z_38) resistor r=0.5311
    rZ_409 (Z_37 Z_323) resistor r=0.054866
    rZ_408 (Z_38 Z_321) resistor r=0.054866
    rZ_407 (Z_39 Z_40) resistor r=0.625471
    rZ_406 (Z_39 Z_324) resistor r=0.0614071
    rZ_405 (Z_40 Z_322) resistor r=0.0614071
    rZ_404 (Z_41 Z_43) resistor r=0.440166
    rZ_403 (Z_41 Z_323) resistor r=0.0361646
    rZ_402 (Z_43 Z_44) resistor r=13
    rZ_401 (Z_44 MM30_ELT_d) resistor r=8.44
    rZ_400 (Z_46 Z_48) resistor r=0.551675
    rZ_399 (Z_46 Z_324) resistor r=0.0294371
    rZ_398 (Z_48 Z_49) resistor r=8.66667
    rZ_397 (Z_48 Z_51) resistor r=0.704266
    rZ_396 (Z_49 MM38_ELT_d) resistor r=32.3614
    rZ_395 (Z_51 Z_52) resistor r=8.66667
    rZ_394 (Z_51 Z_54) resistor r=0.469511
    rZ_393 (Z_52 MM38_ELT_d) resistor r=16.1807
    rZ_392 (Z_52 Z_55) resistor r=32.3614
    rZ_391 (Z_54 Z_55) resistor r=26
    rZ_390 (Z_57 Z_58) resistor r=0.5311
    rZ_389 (Z_57 Z_325) resistor r=0.054866
    rZ_388 (Z_58 Z_323) resistor r=0.054866
    rZ_387 (Z_59 Z_60) resistor r=0.625471
    rZ_386 (Z_59 Z_326) resistor r=0.0614071
    rZ_385 (Z_60 Z_324) resistor r=0.0614071
    rZ_384 (Z_61 Z_63) resistor r=0.440166
    rZ_383 (Z_61 Z_325) resistor r=0.0361646
    rZ_382 (Z_63 Z_64) resistor r=13
    rZ_381 (Z_64 MM29_ELT_d) resistor r=8.44
    rZ_380 (Z_66 Z_68) resistor r=0.551675
    rZ_379 (Z_66 Z_326) resistor r=0.0294371
    rZ_378 (Z_68 Z_69) resistor r=8.66667
    rZ_377 (Z_68 Z_71) resistor r=0.704266
    rZ_376 (Z_69 MM37_ELT_d) resistor r=32.3614
    rZ_375 (Z_71 Z_72) resistor r=8.66667
    rZ_374 (Z_71 Z_74) resistor r=0.469511
    rZ_373 (Z_72 MM37_ELT_d) resistor r=16.1807
    rZ_372 (Z_72 Z_75) resistor r=32.3614
    rZ_371 (Z_74 Z_75) resistor r=26
    rZ_370 (Z_77 Z_78) resistor r=0.5311
    rZ_369 (Z_77 Z_327) resistor r=0.054866
    rZ_368 (Z_78 Z_325) resistor r=0.054866
    rZ_367 (Z_79 Z_80) resistor r=0.625471
    rZ_366 (Z_79 Z_328) resistor r=0.0614071
    rZ_365 (Z_80 Z_326) resistor r=0.0614071
    rZ_364 (Z_81 Z_83) resistor r=0.440166
    rZ_363 (Z_81 Z_327) resistor r=0.0361646
    rZ_362 (Z_83 Z_84) resistor r=13
    rZ_361 (Z_84 MM28_ELT_d) resistor r=8.44
    rZ_360 (Z_86 Z_88) resistor r=0.551675
    rZ_359 (Z_86 Z_328) resistor r=0.0294371
    rZ_358 (Z_88 Z_89) resistor r=8.66667
    rZ_357 (Z_88 Z_91) resistor r=0.704266
    rZ_356 (Z_89 MM36_ELT_d) resistor r=32.3614
    rZ_355 (Z_91 Z_92) resistor r=8.66667
    rZ_354 (Z_91 Z_94) resistor r=0.469511
    rZ_353 (Z_92 MM36_ELT_d) resistor r=16.1807
    rZ_352 (Z_92 Z_95) resistor r=32.3614
    rZ_351 (Z_94 Z_95) resistor r=26
    rZ_350 (Z_97 Z_98) resistor r=0.5311
    rZ_349 (Z_97 Z_329) resistor r=0.054866
    rZ_348 (Z_98 Z_327) resistor r=0.054866
    rZ_347 (Z_99 Z_100) resistor r=0.625471
    rZ_346 (Z_99 Z_330) resistor r=0.0614071
    rZ_345 (Z_100 Z_328) resistor r=0.0614071
    rZ_344 (Z_101 Z_103) resistor r=0.440166
    rZ_343 (Z_101 Z_329) resistor r=0.0361646
    rZ_342 (Z_103 Z_104) resistor r=13
    rZ_341 (Z_104 MM27_ELT_d) resistor r=8.44
    rZ_340 (Z_106 Z_108) resistor r=0.551675
    rZ_339 (Z_106 Z_330) resistor r=0.0294371
    rZ_338 (Z_108 Z_109) resistor r=8.66667
    rZ_337 (Z_108 Z_111) resistor r=0.704266
    rZ_336 (Z_109 MM35_ELT_d) resistor r=32.3614
    rZ_335 (Z_111 Z_112) resistor r=8.66667
    rZ_334 (Z_111 Z_114) resistor r=0.469511
    rZ_333 (Z_112 MM35_ELT_d) resistor r=16.1807
    rZ_332 (Z_112 Z_115) resistor r=32.3614
    rZ_331 (Z_114 Z_115) resistor r=26
    rZ_330 (Z_117 Z_118) resistor r=0.5311
    rZ_329 (Z_117 Z_331) resistor r=0.054866
    rZ_328 (Z_118 Z_329) resistor r=0.054866
    rZ_327 (Z_119 Z_120) resistor r=0.625471
    rZ_326 (Z_119 Z_332) resistor r=0.0614071
    rZ_325 (Z_120 Z_330) resistor r=0.0614071
    rZ_324 (Z_121 Z_123) resistor r=0.440166
    rZ_323 (Z_121 Z_331) resistor r=0.0361646
    rZ_322 (Z_123 Z_124) resistor r=13
    rZ_321 (Z_124 MM26_ELT_d) resistor r=8.44
    rZ_320 (Z_126 Z_128) resistor r=0.551675
    rZ_319 (Z_126 Z_332) resistor r=0.0294371
    rZ_318 (Z_128 Z_129) resistor r=8.66667
    rZ_317 (Z_128 Z_131) resistor r=0.704266
    rZ_316 (Z_129 MM34_ELT_d) resistor r=32.3614
    rZ_315 (Z_131 Z_132) resistor r=8.66667
    rZ_314 (Z_131 Z_134) resistor r=0.469511
    rZ_313 (Z_132 MM34_ELT_d) resistor r=16.1807
    rZ_312 (Z_132 Z_135) resistor r=32.3614
    rZ_311 (Z_134 Z_135) resistor r=26
    rZ_310 (Z_137 Z_138) resistor r=0.5311
    rZ_309 (Z_137 Z_333) resistor r=0.054866
    rZ_308 (Z_138 Z_331) resistor r=0.054866
    rZ_307 (Z_139 Z_140) resistor r=0.625471
    rZ_306 (Z_139 Z_334) resistor r=0.0614071
    rZ_305 (Z_140 Z_332) resistor r=0.0614071
    rZ_304 (Z_141 Z_143) resistor r=0.440166
    rZ_303 (Z_141 Z_333) resistor r=0.0361646
    rZ_302 (Z_143 Z_144) resistor r=13
    rZ_301 (Z_144 MM25_ELT_d) resistor r=8.44
    rZ_300 (Z_146 Z_148) resistor r=0.551675
    rZ_299 (Z_146 Z_334) resistor r=0.0294371
    rZ_298 (Z_148 Z_149) resistor r=8.66667
    rZ_297 (Z_148 Z_151) resistor r=0.704266
    rZ_296 (Z_149 MM33_ELT_d) resistor r=32.3614
    rZ_295 (Z_151 Z_152) resistor r=8.66667
    rZ_294 (Z_151 Z_154) resistor r=0.469511
    rZ_293 (Z_152 MM33_ELT_d) resistor r=16.1807
    rZ_292 (Z_152 Z_155) resistor r=32.3614
    rZ_291 (Z_154 Z_155) resistor r=26
    rZ_290 (Z_157 Z_158) resistor r=0.5311
    rZ_289 (Z_157 Z_335) resistor r=0.054866
    rZ_288 (Z_158 Z_333) resistor r=0.054866
    rZ_287 (Z_159 Z_160) resistor r=0.625471
    rZ_286 (Z_159 Z_336) resistor r=0.0614071
    rZ_285 (Z_160 Z_334) resistor r=0.0614071
    rZ_284 (Z_161 Z_163) resistor r=0.440166
    rZ_283 (Z_161 Z_335) resistor r=0.0361646
    rZ_282 (Z_163 Z_164) resistor r=13
    rZ_281 (Z_164 MM19_ELT_d) resistor r=8.44
    rZ_280 (Z_166 Z_168) resistor r=0.551675
    rZ_279 (Z_166 Z_336) resistor r=0.0294371
    rZ_278 (Z_168 Z_169) resistor r=8.66667
    rZ_277 (Z_168 Z_171) resistor r=0.704266
    rZ_276 (Z_169 MM20_ELT_d) resistor r=32.3614
    rZ_275 (Z_171 Z_172) resistor r=8.66667
    rZ_274 (Z_171 Z_174) resistor r=0.469511
    rZ_273 (Z_172 MM20_ELT_d) resistor r=16.1807
    rZ_272 (Z_172 Z_175) resistor r=32.3614
    rZ_271 (Z_174 Z_175) resistor r=26
    rZ_270 (Z_177 Z_178) resistor r=0.5311
    rZ_269 (Z_177 Z_337) resistor r=0.054866
    rZ_268 (Z_178 Z_335) resistor r=0.054866
    rZ_267 (Z_179 Z_180) resistor r=0.625471
    rZ_266 (Z_179 Z_338) resistor r=0.0614071
    rZ_265 (Z_180 Z_336) resistor r=0.0614071
    rZ_264 (Z_181 Z_183) resistor r=0.440166
    rZ_263 (Z_181 Z_337) resistor r=0.0361646
    rZ_262 (Z_183 Z_184) resistor r=13
    rZ_261 (Z_184 MM18_ELT_d) resistor r=8.44
    rZ_260 (Z_186 Z_188) resistor r=0.551675
    rZ_259 (Z_186 Z_338) resistor r=0.0294371
    rZ_258 (Z_188 Z_189) resistor r=8.66667
    rZ_257 (Z_188 Z_191) resistor r=0.704266
    rZ_256 (Z_189 MM17_ELT_d) resistor r=32.3614
    rZ_255 (Z_191 Z_192) resistor r=8.66667
    rZ_254 (Z_191 Z_194) resistor r=0.469511
    rZ_253 (Z_192 MM17_ELT_d) resistor r=16.1807
    rZ_252 (Z_192 Z_195) resistor r=32.3614
    rZ_251 (Z_194 Z_195) resistor r=26
    rZ_250 (Z_197 Z_198) resistor r=0.5311
    rZ_249 (Z_197 Z_339) resistor r=0.054866
    rZ_248 (Z_198 Z_337) resistor r=0.054866
    rZ_247 (Z_199 Z_200) resistor r=0.625471
    rZ_246 (Z_199 Z_340) resistor r=0.0614071
    rZ_245 (Z_200 Z_338) resistor r=0.0614071
    rZ_244 (Z_201 Z_203) resistor r=0.440166
    rZ_243 (Z_201 Z_339) resistor r=0.0361646
    rZ_242 (Z_203 Z_204) resistor r=13
    rZ_241 (Z_204 MM16_ELT_d) resistor r=8.44
    rZ_240 (Z_206 Z_208) resistor r=0.551675
    rZ_239 (Z_206 Z_340) resistor r=0.0294371
    rZ_238 (Z_208 Z_209) resistor r=8.66667
    rZ_237 (Z_208 Z_211) resistor r=0.704266
    rZ_236 (Z_209 MM11_ELT_d) resistor r=32.3614
    rZ_235 (Z_211 Z_212) resistor r=8.66667
    rZ_234 (Z_211 Z_214) resistor r=0.469511
    rZ_233 (Z_212 MM11_ELT_d) resistor r=16.1807
    rZ_232 (Z_212 Z_215) resistor r=32.3614
    rZ_231 (Z_214 Z_215) resistor r=26
    rZ_230 (Z_217 Z_218) resistor r=0.5311
    rZ_229 (Z_217 Z_341) resistor r=0.054866
    rZ_228 (Z_218 Z_339) resistor r=0.054866
    rZ_227 (Z_219 Z_220) resistor r=0.625471
    rZ_226 (Z_219 Z_342) resistor r=0.0614071
    rZ_225 (Z_220 Z_340) resistor r=0.0614071
    rZ_224 (Z_221 Z_223) resistor r=0.440166
    rZ_223 (Z_221 Z_341) resistor r=0.0361646
    rZ_222 (Z_223 Z_224) resistor r=13
    rZ_221 (Z_224 MM10_ELT_d) resistor r=8.44
    rZ_220 (Z_226 Z_228) resistor r=0.551675
    rZ_219 (Z_226 Z_342) resistor r=0.0294371
    rZ_218 (Z_228 Z_229) resistor r=8.66667
    rZ_217 (Z_228 Z_231) resistor r=0.704266
    rZ_216 (Z_229 MM9_ELT_d) resistor r=32.3614
    rZ_215 (Z_231 Z_232) resistor r=8.66667
    rZ_214 (Z_231 Z_234) resistor r=0.469511
    rZ_213 (Z_232 MM9_ELT_d) resistor r=16.1807
    rZ_212 (Z_232 Z_235) resistor r=32.3614
    rZ_211 (Z_234 Z_235) resistor r=26
    rZ_210 (Z_237 Z_238) resistor r=0.5311
    rZ_209 (Z_237 Z_343) resistor r=0.054866
    rZ_208 (Z_238 Z_341) resistor r=0.054866
    rZ_207 (Z_239 Z_240) resistor r=0.625471
    rZ_206 (Z_239 Z_344) resistor r=0.0614071
    rZ_205 (Z_240 Z_342) resistor r=0.0614071
    rZ_204 (Z_241 Z_243) resistor r=0.440166
    rZ_203 (Z_241 Z_343) resistor r=0.0361646
    rZ_202 (Z_243 Z_244) resistor r=13
    rZ_201 (Z_244 MM5_ELT_d) resistor r=8.44
    rZ_200 (Z_246 Z_248) resistor r=0.551675
    rZ_199 (Z_246 Z_344) resistor r=0.0294371
    rZ_198 (Z_248 Z_249) resistor r=8.66667
    rZ_197 (Z_248 Z_251) resistor r=0.704266
    rZ_196 (Z_249 MM6_ELT_d) resistor r=32.3614
    rZ_195 (Z_251 Z_252) resistor r=8.66667
    rZ_194 (Z_251 Z_254) resistor r=0.469511
    rZ_193 (Z_252 MM6_ELT_d) resistor r=16.1807
    rZ_192 (Z_252 Z_255) resistor r=32.3614
    rZ_191 (Z_254 Z_255) resistor r=26
    rZ_190 (Z_257 Z_258) resistor r=0.5311
    rZ_189 (Z_257 Z_345) resistor r=0.054866
    rZ_188 (Z_258 Z_343) resistor r=0.054866
    rZ_187 (Z_259 Z_260) resistor r=0.625471
    rZ_186 (Z_259 Z_346) resistor r=0.0614071
    rZ_185 (Z_260 Z_344) resistor r=0.0614071
    rZ_184 (Z_261 Z_263) resistor r=0.440166
    rZ_183 (Z_261 Z_345) resistor r=0.0361646
    rZ_182 (Z_263 Z_264) resistor r=13
    rZ_181 (Z_264 MM4_ELT_d) resistor r=8.44
    rZ_180 (Z_266 Z_268) resistor r=0.551675
    rZ_179 (Z_266 Z_346) resistor r=0.0294371
    rZ_178 (Z_268 Z_269) resistor r=8.66667
    rZ_177 (Z_268 Z_271) resistor r=0.704266
    rZ_176 (Z_269 MM2_ELT_d) resistor r=32.3614
    rZ_175 (Z_271 Z_272) resistor r=8.66667
    rZ_174 (Z_271 Z_274) resistor r=0.469511
    rZ_173 (Z_272 MM2_ELT_d) resistor r=16.1807
    rZ_172 (Z_272 Z_275) resistor r=32.3614
    rZ_171 (Z_274 Z_275) resistor r=26
    rZ_170 (Z_277 Z_278) resistor r=0.5311
    rZ_169 (Z_277 Z_347) resistor r=0.054866
    rZ_168 (Z_278 Z_345) resistor r=0.054866
    rZ_167 (Z_279 Z_280) resistor r=0.625471
    rZ_166 (Z_279 Z_348) resistor r=0.0614071
    rZ_165 (Z_280 Z_346) resistor r=0.0614071
    rZ_164 (Z_281 Z_283) resistor r=0.440166
    rZ_163 (Z_281 Z_347) resistor r=0.0361646
    rZ_162 (Z_283 Z_284) resistor r=13
    rZ_161 (Z_284 MM1_ELT_d) resistor r=8.44
    rZ_160 (Z_286 Z_288) resistor r=0.551675
    rZ_159 (Z_286 Z_348) resistor r=0.0294371
    rZ_158 (Z_288 Z_289) resistor r=8.66667
    rZ_157 (Z_288 Z_291) resistor r=0.704266
    rZ_156 (Z_289 MM3_ELT_d) resistor r=32.3614
    rZ_155 (Z_291 Z_292) resistor r=8.66667
    rZ_154 (Z_291 Z_294) resistor r=0.469511
    rZ_153 (Z_292 MM3_ELT_d) resistor r=16.1807
    rZ_152 (Z_292 Z_295) resistor r=32.3614
    rZ_151 (Z_294 Z_295) resistor r=26
    rZ_150 (Z_297 Z_298) resistor r=0.5311
    rZ_149 (Z_297 Z_349) resistor r=0.056646
    rZ_148 (Z_298 Z_347) resistor r=0.054866
    rZ_147 (Z_299 Z_300) resistor r=0.625471
    rZ_146 (Z_299 Z_351) resistor r=0.0667723
    rZ_145 (Z_300 Z_348) resistor r=0.0614071
    rZ_144 (Z_303 Z_304) resistor r=13
    rZ_143 (Z_303 Z_350) resistor r=0.304698
    rZ_142 (Z_304 MM15_ELT_d) resistor r=8.44
    rZ_141 (Z_306 Z) resistor r=0.0588459
    rZ_140 (Z_306 Z_349) resistor r=0.0411921
    rZ_139 (Z_307 Z) resistor r=0.170187
    rZ_138 (Z_307 Z_351) resistor r=0.0359614
    rZ_137 (Z_312 Z_313) resistor r=8.66667
    rZ_136 (Z_312 Z_352) resistor r=0.342117
    rZ_135 (Z_312 Z_315) resistor r=0.64147
    rZ_134 (Z_313 MM14_ELT_d) resistor r=32.3614
    rZ_133 (Z_315 Z_316) resistor r=8.66667
    rZ_132 (Z_315 Z_318) resistor r=0.427646
    rZ_131 (Z_316 MM14_ELT_d) resistor r=16.1807
    rZ_130 (Z_316 Z_319) resistor r=32.3614
    rZ_129 (Z_318 Z_319) resistor r=26
    rZ_128 (Z_349 Z_350) resistor r=0.154729
    rZ_127 (Z_351 Z_352) resistor r=0.189429
    rVDD_678 (MM23_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_677 (MM8_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_676 (MM13_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_675 (MM40_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_674 (MM39_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_673 (MM38_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_672 (MM37_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_671 (MM36_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_670 (MM35_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_669 (MM34_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_668 (MM33_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_667 (MM20_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_666 (MM17_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_665 (MM11_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_664 (MM9_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_663 (MM6_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_662 (MM2_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_661 (MM3_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_660 (MM14_ELT_b MM24_ELT_b) resistor r=0.01
    rVDD_659 (MM24_ELT_b VDD_161) resistor r=8.66667
    rVDD_658 (MM24_ELT_b VDD_177) resistor r=8.66667
    rVDD_657 (MM24_ELT_b VDD_219) resistor r=8.66667
    rVDD_656 (MM24_ELT_b VDD_235) resistor r=8.66667
    rVDD_655 (MM24_ELT_b VDD_251) resistor r=8.66667
    rVDD_654 (MM24_ELT_b VDD_267) resistor r=8.66667
    rVDD_653 (MM24_ELT_b VDD_283) resistor r=8.66667
    rVDD_652 (MM24_ELT_b VDD_298) resistor r=13
    rVDD_651 (MM24_ELT_b VDD_316) resistor r=8.66667
    rVDD_650 (MM24_ELT_b VDD_146) resistor r=22.5067
    rVDD_649 (VDD_2 VDD_7) resistor r=0.114847
    rVDD_648 (VDD_2 VDD_301) resistor r=0.0221957
    rVDD_647 (VDD VDD_7) resistor r=0.102966
    rVDD_646 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_645 (VDD_8 VDD_24) resistor r=67.52
    rVDD_644 (VDD_9 VDD_18) resistor r=0.416691
    rVDD_643 (VDD_9 VDD_301) resistor r=0.0885198
    rVDD_642 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_641 (VDD_11 VDD_15) resistor r=0.704266
    rVDD_640 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_639 (VDD_15 VDD_18) resistor r=0.704266
    rVDD_638 (VDD_18 VDD_19) resistor r=8.66667
    rVDD_637 (VDD_19 MM23_ELT_s) resistor r=0.850556
    rVDD_636 (VDD_19 MM24_ELT_s) resistor r=0.850556
    rVDD_635 (VDD_19 VDD_450) resistor r=13.0961
    rVDD_634 (VDD_20 VDD_23) resistor r=0.0831649
    rVDD_633 (VDD_20 VDD_302) resistor r=0.0221957
    rVDD_632 (VDD_21 VDD_23) resistor r=0.0871252
    rVDD_631 (VDD_21 VDD_301) resistor r=0.0221957
    rVDD_630 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_629 (VDD_24 VDD_40) resistor r=67.52
    rVDD_628 (VDD_25 VDD_34) resistor r=0.416691
    rVDD_627 (VDD_25 VDD_302) resistor r=0.0885198
    rVDD_626 (VDD_27 VDD_35) resistor r=8.66667
    rVDD_625 (VDD_27 VDD_31) resistor r=0.704266
    rVDD_624 (VDD_31 VDD_35) resistor r=8.66667
    rVDD_623 (VDD_31 VDD_34) resistor r=0.704266
    rVDD_622 (VDD_34 VDD_35) resistor r=8.66667
    rVDD_621 (VDD_35 MM8_ELT_s) resistor r=4.04518
    rVDD_620 (VDD_35 VDD_454) resistor r=4.04518
    rVDD_619 (VDD_35 MM23_ELT_s) resistor r=4.04518
    rVDD_618 (VDD_35 VDD_452) resistor r=4.04518
    rVDD_617 (VDD_36 VDD_39) resistor r=0.051483
    rVDD_616 (VDD_36 VDD_303) resistor r=0.0221957
    rVDD_615 (VDD_37 VDD_39) resistor r=0.118807
    rVDD_614 (VDD_37 VDD_302) resistor r=0.0221957
    rVDD_613 (VDD_39 VDD_40) resistor r=8.66667
    rVDD_612 (VDD_40 VDD_56) resistor r=67.52
    rVDD_611 (VDD_41 VDD_50) resistor r=0.416691
    rVDD_610 (VDD_41 VDD_303) resistor r=0.0885198
    rVDD_609 (VDD_43 VDD_51) resistor r=8.66667
    rVDD_608 (VDD_43 VDD_47) resistor r=0.704266
    rVDD_607 (VDD_47 VDD_51) resistor r=8.66667
    rVDD_606 (VDD_47 VDD_50) resistor r=0.704266
    rVDD_605 (VDD_50 VDD_51) resistor r=8.66667
    rVDD_604 (VDD_51 MM13_ELT_s) resistor r=0.850556
    rVDD_603 (VDD_51 MM8_ELT_s) resistor r=0.850556
    rVDD_602 (VDD_51 VDD_456) resistor r=13.0961
    rVDD_601 (VDD_52 VDD_55) resistor r=0.0198012
    rVDD_600 (VDD_52 VDD_304) resistor r=0.0221957
    rVDD_599 (VDD_53 VDD_55) resistor r=0.150489
    rVDD_598 (VDD_53 VDD_303) resistor r=0.0221957
    rVDD_597 (VDD_55 VDD_56) resistor r=8.66667
    rVDD_596 (VDD_56 VDD_307) resistor r=67.52
    rVDD_595 (VDD_57 VDD_66) resistor r=0.416691
    rVDD_594 (VDD_57 VDD_304) resistor r=0.0885198
    rVDD_593 (VDD_59 VDD_67) resistor r=8.66667
    rVDD_592 (VDD_59 VDD_63) resistor r=0.704266
    rVDD_591 (VDD_63 VDD_67) resistor r=8.66667
    rVDD_590 (VDD_63 VDD_66) resistor r=0.704266
    rVDD_589 (VDD_66 VDD_67) resistor r=8.66667
    rVDD_588 (VDD_67 MM40_ELT_s) resistor r=4.04518
    rVDD_587 (VDD_67 VDD_460) resistor r=4.04518
    rVDD_586 (VDD_67 MM13_ELT_s) resistor r=4.04518
    rVDD_585 (VDD_67 VDD_458) resistor r=4.04518
    rVDD_584 (VDD_68 VDD_69) resistor r=0.17029
    rVDD_583 (VDD_68 VDD_306) resistor r=0.0221957
    rVDD_582 (VDD_69 VDD_304) resistor r=0.0221957
    rVDD_581 (VDD_70 VDD_79) resistor r=0.416691
    rVDD_580 (VDD_70 VDD_306) resistor r=0.0885198
    rVDD_579 (VDD_72 VDD_80) resistor r=8.66667
    rVDD_578 (VDD_72 VDD_76) resistor r=0.704266
    rVDD_577 (VDD_76 VDD_80) resistor r=8.66667
    rVDD_576 (VDD_76 VDD_79) resistor r=0.704266
    rVDD_575 (VDD_79 VDD_80) resistor r=8.66667
    rVDD_574 (VDD_80 MM39_ELT_s) resistor r=4.04518
    rVDD_573 (VDD_80 VDD_464) resistor r=4.04518
    rVDD_572 (VDD_80 MM40_ELT_s) resistor r=4.04518
    rVDD_571 (VDD_80 VDD_462) resistor r=4.04518
    rVDD_570 (VDD_81 VDD_82) resistor r=0.17029
    rVDD_569 (VDD_81 VDD_308) resistor r=0.0221957
    rVDD_568 (VDD_82 VDD_306) resistor r=0.0221957
    rVDD_567 (VDD_83 VDD_92) resistor r=0.416691
    rVDD_566 (VDD_83 VDD_308) resistor r=0.0885198
    rVDD_565 (VDD_85 VDD_93) resistor r=8.66667
    rVDD_564 (VDD_85 VDD_89) resistor r=0.704266
    rVDD_563 (VDD_89 VDD_93) resistor r=8.66667
    rVDD_562 (VDD_89 VDD_92) resistor r=0.704266
    rVDD_561 (VDD_92 VDD_93) resistor r=8.66667
    rVDD_560 (VDD_93 MM38_ELT_s) resistor r=0.850556
    rVDD_559 (VDD_93 MM39_ELT_s) resistor r=0.850556
    rVDD_558 (VDD_93 VDD_466) resistor r=13.0961
    rVDD_557 (VDD_94 VDD_97) resistor r=0.16237
    rVDD_556 (VDD_94 VDD_309) resistor r=0.0221957
    rVDD_555 (VDD_95 VDD_97) resistor r=0.00792047
    rVDD_554 (VDD_95 VDD_308) resistor r=0.0221957
    rVDD_553 (VDD_97 VDD_98) resistor r=8.66667
    rVDD_552 (VDD_98 VDD_307) resistor r=67.52
    rVDD_551 (VDD_98 VDD_114) resistor r=67.52
    rVDD_550 (VDD_99 VDD_108) resistor r=0.416691
    rVDD_549 (VDD_99 VDD_309) resistor r=0.0885198
    rVDD_548 (VDD_101 VDD_109) resistor r=8.66667
    rVDD_547 (VDD_101 VDD_105) resistor r=0.704266
    rVDD_546 (VDD_105 VDD_109) resistor r=8.66667
    rVDD_545 (VDD_105 VDD_108) resistor r=0.704266
    rVDD_544 (VDD_108 VDD_109) resistor r=8.66667
    rVDD_543 (VDD_109 MM37_ELT_s) resistor r=4.04518
    rVDD_542 (VDD_109 VDD_470) resistor r=4.04518
    rVDD_541 (VDD_109 MM38_ELT_s) resistor r=4.04518
    rVDD_540 (VDD_109 VDD_468) resistor r=4.04518
    rVDD_539 (VDD_110 VDD_113) resistor r=0.130688
    rVDD_538 (VDD_110 VDD_310) resistor r=0.0221957
    rVDD_537 (VDD_111 VDD_113) resistor r=0.0396023
    rVDD_536 (VDD_111 VDD_309) resistor r=0.0221957
    rVDD_535 (VDD_113 VDD_114) resistor r=8.66667
    rVDD_534 (VDD_114 VDD_130) resistor r=67.52
    rVDD_533 (VDD_115 VDD_124) resistor r=0.416691
    rVDD_532 (VDD_115 VDD_310) resistor r=0.0885198
    rVDD_531 (VDD_117 VDD_125) resistor r=8.66667
    rVDD_530 (VDD_117 VDD_121) resistor r=0.704266
    rVDD_529 (VDD_121 VDD_125) resistor r=8.66667
    rVDD_528 (VDD_121 VDD_124) resistor r=0.704266
    rVDD_527 (VDD_124 VDD_125) resistor r=8.66667
    rVDD_526 (VDD_125 MM36_ELT_s) resistor r=0.850556
    rVDD_525 (VDD_125 MM37_ELT_s) resistor r=0.850556
    rVDD_524 (VDD_125 VDD_472) resistor r=13.0961
    rVDD_523 (VDD_126 VDD_129) resistor r=0.0990059
    rVDD_522 (VDD_126 VDD_311) resistor r=0.0221957
    rVDD_521 (VDD_127 VDD_129) resistor r=0.0712842
    rVDD_520 (VDD_127 VDD_310) resistor r=0.0221957
    rVDD_519 (VDD_129 VDD_130) resistor r=8.66667
    rVDD_518 (VDD_130 VDD_146) resistor r=67.52
    rVDD_517 (VDD_131 VDD_140) resistor r=0.416691
    rVDD_516 (VDD_131 VDD_311) resistor r=0.0885198
    rVDD_515 (VDD_133 VDD_141) resistor r=8.66667
    rVDD_514 (VDD_133 VDD_137) resistor r=0.704266
    rVDD_513 (VDD_137 VDD_141) resistor r=8.66667
    rVDD_512 (VDD_137 VDD_140) resistor r=0.704266
    rVDD_511 (VDD_140 VDD_141) resistor r=8.66667
    rVDD_510 (VDD_141 MM35_ELT_s) resistor r=4.04518
    rVDD_509 (VDD_141 VDD_476) resistor r=4.04518
    rVDD_508 (VDD_141 MM36_ELT_s) resistor r=4.04518
    rVDD_507 (VDD_141 VDD_474) resistor r=4.04518
    rVDD_506 (VDD_142 VDD_145) resistor r=0.067324
    rVDD_505 (VDD_142 VDD_312) resistor r=0.0221957
    rVDD_504 (VDD_143 VDD_145) resistor r=0.102966
    rVDD_503 (VDD_143 VDD_311) resistor r=0.0221957
    rVDD_502 (VDD_145 VDD_146) resistor r=8.66667
    rVDD_501 (VDD_147 VDD_156) resistor r=0.416691
    rVDD_500 (VDD_147 VDD_312) resistor r=0.0885198
    rVDD_499 (VDD_149 VDD_157) resistor r=8.66667
    rVDD_498 (VDD_149 VDD_153) resistor r=0.704266
    rVDD_497 (VDD_153 VDD_157) resistor r=8.66667
    rVDD_496 (VDD_153 VDD_156) resistor r=0.704266
    rVDD_495 (VDD_156 VDD_157) resistor r=8.66667
    rVDD_494 (VDD_157 MM34_ELT_s) resistor r=0.850556
    rVDD_493 (VDD_157 MM35_ELT_s) resistor r=0.850556
    rVDD_492 (VDD_157 VDD_478) resistor r=13.0961
    rVDD_491 (VDD_158 VDD_161) resistor r=0.0356421
    rVDD_490 (VDD_158 VDD_313) resistor r=0.0221957
    rVDD_489 (VDD_159 VDD_161) resistor r=0.134648
    rVDD_488 (VDD_159 VDD_312) resistor r=0.0221957
    rVDD_487 (VDD_163 VDD_172) resistor r=0.416691
    rVDD_486 (VDD_163 VDD_313) resistor r=0.0885198
    rVDD_485 (VDD_165 VDD_173) resistor r=8.66667
    rVDD_484 (VDD_165 VDD_169) resistor r=0.704266
    rVDD_483 (VDD_169 VDD_173) resistor r=8.66667
    rVDD_482 (VDD_169 VDD_172) resistor r=0.704266
    rVDD_481 (VDD_172 VDD_173) resistor r=8.66667
    rVDD_480 (VDD_173 MM33_ELT_s) resistor r=4.04518
    rVDD_479 (VDD_173 VDD_482) resistor r=4.04518
    rVDD_478 (VDD_173 MM34_ELT_s) resistor r=4.04518
    rVDD_477 (VDD_173 VDD_480) resistor r=4.04518
    rVDD_476 (VDD_174 VDD_177) resistor r=0.00396023
    rVDD_475 (VDD_174 VDD_314) resistor r=0.0221957
    rVDD_474 (VDD_175 VDD_177) resistor r=0.16633
    rVDD_473 (VDD_175 VDD_313) resistor r=0.0221957
    rVDD_472 (VDD_179 VDD_188) resistor r=0.416691
    rVDD_471 (VDD_179 VDD_314) resistor r=0.0885198
    rVDD_470 (VDD_181 VDD_189) resistor r=8.66667
    rVDD_469 (VDD_181 VDD_185) resistor r=0.704266
    rVDD_468 (VDD_185 VDD_189) resistor r=8.66667
    rVDD_467 (VDD_185 VDD_188) resistor r=0.704266
    rVDD_466 (VDD_188 VDD_189) resistor r=8.66667
    rVDD_465 (VDD_189 MM20_ELT_s) resistor r=0.850556
    rVDD_464 (VDD_189 MM33_ELT_s) resistor r=0.850556
    rVDD_463 (VDD_189 VDD_484) resistor r=13.0961
    rVDD_462 (VDD_190 VDD_191) resistor r=0.17029
    rVDD_461 (VDD_190 VDD_316) resistor r=0.0221957
    rVDD_460 (VDD_191 VDD_314) resistor r=0.0221957
    rVDD_459 (VDD_192 VDD_201) resistor r=0.416691
    rVDD_458 (VDD_192 VDD_316) resistor r=0.0885198
    rVDD_457 (VDD_194 VDD_202) resistor r=8.66667
    rVDD_456 (VDD_194 VDD_198) resistor r=0.704266
    rVDD_455 (VDD_198 VDD_202) resistor r=8.66667
    rVDD_454 (VDD_198 VDD_201) resistor r=0.704266
    rVDD_453 (VDD_201 VDD_202) resistor r=8.66667
    rVDD_452 (VDD_202 MM17_ELT_s) resistor r=4.04518
    rVDD_451 (VDD_202 VDD_488) resistor r=4.04518
    rVDD_450 (VDD_202 MM20_ELT_s) resistor r=4.04518
    rVDD_449 (VDD_202 VDD_486) resistor r=4.04518
    rVDD_448 (VDD_203 VDD_204) resistor r=0.17029
    rVDD_447 (VDD_203 VDD_318) resistor r=0.0221957
    rVDD_446 (VDD_204 VDD_316) resistor r=0.0221957
    rVDD_445 (VDD_205 VDD_214) resistor r=0.416691
    rVDD_444 (VDD_205 VDD_318) resistor r=0.0885198
    rVDD_443 (VDD_207 VDD_215) resistor r=8.66667
    rVDD_442 (VDD_207 VDD_211) resistor r=0.704266
    rVDD_441 (VDD_211 VDD_215) resistor r=8.66667
    rVDD_440 (VDD_211 VDD_214) resistor r=0.704266
    rVDD_439 (VDD_214 VDD_215) resistor r=8.66667
    rVDD_438 (VDD_215 MM11_ELT_s) resistor r=0.850556
    rVDD_437 (VDD_215 MM17_ELT_s) resistor r=0.850556
    rVDD_436 (VDD_215 VDD_490) resistor r=13.0961
    rVDD_435 (VDD_216 VDD_219) resistor r=0.146529
    rVDD_434 (VDD_216 VDD_319) resistor r=0.0221957
    rVDD_433 (VDD_217 VDD_219) resistor r=0.0237614
    rVDD_432 (VDD_217 VDD_318) resistor r=0.0221957
    rVDD_431 (VDD_221 VDD_230) resistor r=0.416691
    rVDD_430 (VDD_221 VDD_319) resistor r=0.0885198
    rVDD_429 (VDD_223 VDD_231) resistor r=8.66667
    rVDD_428 (VDD_223 VDD_227) resistor r=0.704266
    rVDD_427 (VDD_227 VDD_231) resistor r=8.66667
    rVDD_426 (VDD_227 VDD_230) resistor r=0.704266
    rVDD_425 (VDD_230 VDD_231) resistor r=8.66667
    rVDD_424 (VDD_231 MM9_ELT_s) resistor r=4.04518
    rVDD_423 (VDD_231 VDD_494) resistor r=4.04518
    rVDD_422 (VDD_231 MM11_ELT_s) resistor r=4.04518
    rVDD_421 (VDD_231 VDD_492) resistor r=4.04518
    rVDD_420 (VDD_232 VDD_235) resistor r=0.114847
    rVDD_419 (VDD_232 VDD_320) resistor r=0.0221957
    rVDD_418 (VDD_233 VDD_235) resistor r=0.0554433
    rVDD_417 (VDD_233 VDD_319) resistor r=0.0221957
    rVDD_416 (VDD_237 VDD_246) resistor r=0.416691
    rVDD_415 (VDD_237 VDD_320) resistor r=0.0885198
    rVDD_414 (VDD_239 VDD_247) resistor r=8.66667
    rVDD_413 (VDD_239 VDD_243) resistor r=0.704266
    rVDD_412 (VDD_243 VDD_247) resistor r=8.66667
    rVDD_411 (VDD_243 VDD_246) resistor r=0.704266
    rVDD_410 (VDD_246 VDD_247) resistor r=8.66667
    rVDD_409 (VDD_247 MM6_ELT_s) resistor r=0.850556
    rVDD_408 (VDD_247 MM9_ELT_s) resistor r=0.850556
    rVDD_407 (VDD_247 VDD_496) resistor r=13.0961
    rVDD_406 (VDD_248 VDD_251) resistor r=0.0831649
    rVDD_405 (VDD_248 VDD_321) resistor r=0.0221957
    rVDD_404 (VDD_249 VDD_251) resistor r=0.0871252
    rVDD_403 (VDD_249 VDD_320) resistor r=0.0221957
    rVDD_402 (VDD_253 VDD_262) resistor r=0.416691
    rVDD_401 (VDD_253 VDD_321) resistor r=0.0885198
    rVDD_400 (VDD_255 VDD_263) resistor r=8.66667
    rVDD_399 (VDD_255 VDD_259) resistor r=0.704266
    rVDD_398 (VDD_259 VDD_263) resistor r=8.66667
    rVDD_397 (VDD_259 VDD_262) resistor r=0.704266
    rVDD_396 (VDD_262 VDD_263) resistor r=8.66667
    rVDD_395 (VDD_263 MM2_ELT_s) resistor r=4.04518
    rVDD_394 (VDD_263 VDD_500) resistor r=4.04518
    rVDD_393 (VDD_263 MM6_ELT_s) resistor r=4.04518
    rVDD_392 (VDD_263 VDD_498) resistor r=4.04518
    rVDD_391 (VDD_264 VDD_267) resistor r=0.051483
    rVDD_390 (VDD_264 VDD_322) resistor r=0.0221957
    rVDD_389 (VDD_265 VDD_267) resistor r=0.118807
    rVDD_388 (VDD_265 VDD_321) resistor r=0.0221957
    rVDD_387 (VDD_269 VDD_278) resistor r=0.416691
    rVDD_386 (VDD_269 VDD_322) resistor r=0.0885198
    rVDD_385 (VDD_271 VDD_279) resistor r=8.66667
    rVDD_384 (VDD_271 VDD_275) resistor r=0.704266
    rVDD_383 (VDD_275 VDD_279) resistor r=8.66667
    rVDD_382 (VDD_275 VDD_278) resistor r=0.704266
    rVDD_381 (VDD_278 VDD_279) resistor r=8.66667
    rVDD_380 (VDD_279 MM3_ELT_s) resistor r=0.850556
    rVDD_379 (VDD_279 MM2_ELT_s) resistor r=0.850556
    rVDD_378 (VDD_279 VDD_502) resistor r=13.0961
    rVDD_377 (VDD_280 VDD_283) resistor r=0.0198012
    rVDD_376 (VDD_280 VDD_323) resistor r=0.0221957
    rVDD_375 (VDD_281 VDD_283) resistor r=0.150489
    rVDD_374 (VDD_281 VDD_322) resistor r=0.0221957
    rVDD_373 (VDD_285 VDD_294) resistor r=0.416691
    rVDD_372 (VDD_285 VDD_323) resistor r=0.0885198
    rVDD_371 (VDD_287 VDD_295) resistor r=8.66667
    rVDD_370 (VDD_287 VDD_291) resistor r=0.704266
    rVDD_369 (VDD_291 VDD_295) resistor r=8.66667
    rVDD_368 (VDD_291 VDD_294) resistor r=0.704266
    rVDD_367 (VDD_294 VDD_295) resistor r=8.66667
    rVDD_366 (VDD_295 MM14_ELT_s) resistor r=4.04518
    rVDD_365 (VDD_295 VDD_506) resistor r=4.04518
    rVDD_364 (VDD_295 MM3_ELT_s) resistor r=4.04518
    rVDD_363 (VDD_295 VDD_504) resistor r=4.04518
    rVDD_362 (VDD_296 VDD_298) resistor r=0.102966
    rVDD_361 (VDD_296 VDD_323) resistor r=0.0221957
    rVDD_360 (VDD_306 VDD_307) resistor r=8.66667
    rVDD_359 (VDD_326 VDD_329) resistor r=31.2341
    rVDD_358 (VDD_326 VDD_330) resistor r=9.04595
    rVDD_357 (VDD_327 VDD_329) resistor r=31.2341
    rVDD_356 (VDD_327 VDD_333) resistor r=9.04062
    rVDD_355 (MM24_ELT_s VDD_329) resistor r=6.12113
    rVDD_354 (MM24_ELT_s VDD_331) resistor r=12.3172
    rVDD_353 (MM24_ELT_s VDD_331) resistor r=1.62887
    rVDD_352 (MM24_ELT_s VDD_334) resistor r=2.55965
    rVDD_351 (VDD_330 VDD_331) resistor r=12.3172
    rVDD_350 (VDD_332 VDD_334) resistor r=14.4784
    rVDD_349 (VDD_332 VDD_451) resistor r=10.5593
    rVDD_348 (VDD_333 VDD_334) resistor r=14.4784
    rVDD_347 (MM23_ELT_s VDD_338) resistor r=2.55965
    rVDD_346 (MM23_ELT_s VDD_340) resistor r=12.3172
    rVDD_345 (MM23_ELT_s VDD_340) resistor r=1.62887
    rVDD_344 (VDD_336 VDD_338) resistor r=14.4784
    rVDD_343 (VDD_336 VDD_455) resistor r=10.5593
    rVDD_342 (VDD_337 VDD_338) resistor r=14.4784
    rVDD_341 (VDD_337 VDD_451) resistor r=10.5593
    rVDD_340 (VDD_339 VDD_340) resistor r=12.3172
    rVDD_339 (VDD_339 VDD_453) resistor r=10.2363
    rVDD_338 (MM8_ELT_s VDD_343) resistor r=12.3172
    rVDD_337 (MM8_ELT_s VDD_343) resistor r=1.62887
    rVDD_336 (MM8_ELT_s VDD_346) resistor r=2.55965
    rVDD_335 (VDD_342 VDD_343) resistor r=12.3172
    rVDD_334 (VDD_342 VDD_453) resistor r=10.2363
    rVDD_333 (VDD_344 VDD_346) resistor r=14.4784
    rVDD_332 (VDD_344 VDD_457) resistor r=10.5593
    rVDD_331 (VDD_345 VDD_346) resistor r=14.4784
    rVDD_330 (VDD_345 VDD_455) resistor r=10.5593
    rVDD_329 (MM13_ELT_s VDD_350) resistor r=2.55965
    rVDD_328 (MM13_ELT_s VDD_352) resistor r=12.3172
    rVDD_327 (MM13_ELT_s VDD_352) resistor r=1.62887
    rVDD_326 (VDD_348 VDD_350) resistor r=14.4784
    rVDD_325 (VDD_348 VDD_461) resistor r=10.5593
    rVDD_324 (VDD_349 VDD_350) resistor r=14.4784
    rVDD_323 (VDD_349 VDD_457) resistor r=10.5593
    rVDD_322 (VDD_351 VDD_352) resistor r=12.3172
    rVDD_321 (VDD_351 VDD_459) resistor r=10.2363
    rVDD_320 (MM40_ELT_s VDD_356) resistor r=2.55965
    rVDD_319 (MM40_ELT_s VDD_358) resistor r=12.3172
    rVDD_318 (MM40_ELT_s VDD_358) resistor r=1.62887
    rVDD_317 (MM40_ELT_s VDD_459) resistor r=10.2363
    rVDD_316 (VDD_354 VDD_356) resistor r=14.4784
    rVDD_315 (VDD_354 VDD_465) resistor r=10.5593
    rVDD_314 (VDD_355 VDD_356) resistor r=14.4784
    rVDD_313 (VDD_355 VDD_461) resistor r=10.5593
    rVDD_312 (VDD_357 VDD_358) resistor r=12.3172
    rVDD_311 (VDD_357 VDD_463) resistor r=10.2363
    rVDD_310 (MM39_ELT_s VDD_361) resistor r=12.3172
    rVDD_309 (MM39_ELT_s VDD_361) resistor r=1.62887
    rVDD_308 (MM39_ELT_s VDD_364) resistor r=2.55965
    rVDD_307 (VDD_360 VDD_361) resistor r=12.3172
    rVDD_306 (VDD_360 VDD_463) resistor r=10.2363
    rVDD_305 (VDD_362 VDD_364) resistor r=14.4784
    rVDD_304 (VDD_362 VDD_467) resistor r=10.5593
    rVDD_303 (VDD_363 VDD_364) resistor r=14.4784
    rVDD_302 (VDD_363 VDD_465) resistor r=10.5593
    rVDD_301 (MM38_ELT_s VDD_368) resistor r=2.55965
    rVDD_300 (MM38_ELT_s VDD_370) resistor r=12.3172
    rVDD_299 (MM38_ELT_s VDD_370) resistor r=1.62887
    rVDD_298 (VDD_366 VDD_368) resistor r=14.4784
    rVDD_297 (VDD_366 VDD_471) resistor r=10.5593
    rVDD_296 (VDD_367 VDD_368) resistor r=14.4784
    rVDD_295 (VDD_367 VDD_467) resistor r=10.5593
    rVDD_294 (VDD_369 VDD_370) resistor r=12.3172
    rVDD_293 (VDD_369 VDD_469) resistor r=10.2363
    rVDD_292 (MM37_ELT_s VDD_373) resistor r=12.3172
    rVDD_291 (MM37_ELT_s VDD_373) resistor r=1.62887
    rVDD_290 (MM37_ELT_s VDD_376) resistor r=2.55965
    rVDD_289 (VDD_372 VDD_373) resistor r=12.3172
    rVDD_288 (VDD_372 VDD_469) resistor r=10.2363
    rVDD_287 (VDD_374 VDD_376) resistor r=14.4784
    rVDD_286 (VDD_374 VDD_473) resistor r=10.5593
    rVDD_285 (VDD_375 VDD_376) resistor r=14.4784
    rVDD_284 (VDD_375 VDD_471) resistor r=10.5593
    rVDD_283 (MM36_ELT_s VDD_380) resistor r=2.55965
    rVDD_282 (MM36_ELT_s VDD_382) resistor r=12.3172
    rVDD_281 (MM36_ELT_s VDD_382) resistor r=1.62887
    rVDD_280 (VDD_378 VDD_380) resistor r=14.4784
    rVDD_279 (VDD_378 VDD_477) resistor r=10.5593
    rVDD_278 (VDD_379 VDD_380) resistor r=14.4784
    rVDD_277 (VDD_379 VDD_473) resistor r=10.5593
    rVDD_276 (VDD_381 VDD_382) resistor r=12.3172
    rVDD_275 (VDD_381 VDD_475) resistor r=10.2363
    rVDD_274 (MM35_ELT_s VDD_385) resistor r=12.3172
    rVDD_273 (MM35_ELT_s VDD_385) resistor r=1.62887
    rVDD_272 (MM35_ELT_s VDD_388) resistor r=2.55965
    rVDD_271 (VDD_384 VDD_385) resistor r=12.3172
    rVDD_270 (VDD_384 VDD_475) resistor r=10.2363
    rVDD_269 (VDD_386 VDD_388) resistor r=14.4784
    rVDD_268 (VDD_386 VDD_479) resistor r=10.5593
    rVDD_267 (VDD_387 VDD_388) resistor r=14.4784
    rVDD_266 (VDD_387 VDD_477) resistor r=10.5593
    rVDD_265 (MM34_ELT_s VDD_392) resistor r=2.55965
    rVDD_264 (MM34_ELT_s VDD_394) resistor r=12.3172
    rVDD_263 (MM34_ELT_s VDD_394) resistor r=1.62887
    rVDD_262 (VDD_390 VDD_392) resistor r=14.4784
    rVDD_261 (VDD_390 VDD_483) resistor r=10.5593
    rVDD_260 (VDD_391 VDD_392) resistor r=14.4784
    rVDD_259 (VDD_391 VDD_479) resistor r=10.5593
    rVDD_258 (VDD_393 VDD_394) resistor r=12.3172
    rVDD_257 (VDD_393 VDD_481) resistor r=10.2363
    rVDD_256 (MM33_ELT_s VDD_397) resistor r=12.3172
    rVDD_255 (MM33_ELT_s VDD_397) resistor r=1.62887
    rVDD_254 (MM33_ELT_s VDD_400) resistor r=2.55965
    rVDD_253 (VDD_396 VDD_397) resistor r=12.3172
    rVDD_252 (VDD_396 VDD_481) resistor r=10.2363
    rVDD_251 (VDD_398 VDD_400) resistor r=14.4784
    rVDD_250 (VDD_398 VDD_485) resistor r=10.5593
    rVDD_249 (VDD_399 VDD_400) resistor r=14.4784
    rVDD_248 (VDD_399 VDD_483) resistor r=10.5593
    rVDD_247 (MM20_ELT_s VDD_404) resistor r=2.55965
    rVDD_246 (MM20_ELT_s VDD_406) resistor r=12.3172
    rVDD_245 (MM20_ELT_s VDD_406) resistor r=1.62887
    rVDD_244 (VDD_402 VDD_404) resistor r=14.4784
    rVDD_243 (VDD_402 VDD_489) resistor r=10.5593
    rVDD_242 (VDD_403 VDD_404) resistor r=14.4784
    rVDD_241 (VDD_403 VDD_485) resistor r=10.5593
    rVDD_240 (VDD_405 VDD_406) resistor r=12.3172
    rVDD_239 (VDD_405 VDD_487) resistor r=10.2363
    rVDD_238 (MM17_ELT_s VDD_409) resistor r=12.3172
    rVDD_237 (MM17_ELT_s VDD_409) resistor r=1.62887
    rVDD_236 (MM17_ELT_s VDD_412) resistor r=2.55965
    rVDD_235 (VDD_408 VDD_409) resistor r=12.3172
    rVDD_234 (VDD_408 VDD_487) resistor r=10.2363
    rVDD_233 (VDD_410 VDD_412) resistor r=14.4784
    rVDD_232 (VDD_410 VDD_491) resistor r=10.5593
    rVDD_231 (VDD_411 VDD_412) resistor r=14.4784
    rVDD_230 (VDD_411 VDD_489) resistor r=10.5593
    rVDD_229 (MM11_ELT_s VDD_416) resistor r=2.55965
    rVDD_228 (MM11_ELT_s VDD_418) resistor r=12.3172
    rVDD_227 (MM11_ELT_s VDD_418) resistor r=1.62887
    rVDD_226 (VDD_414 VDD_416) resistor r=14.4784
    rVDD_225 (VDD_414 VDD_495) resistor r=10.5593
    rVDD_224 (VDD_415 VDD_416) resistor r=14.4784
    rVDD_223 (VDD_415 VDD_491) resistor r=10.5593
    rVDD_222 (VDD_417 VDD_418) resistor r=12.3172
    rVDD_221 (VDD_417 VDD_493) resistor r=10.2363
    rVDD_220 (MM9_ELT_s VDD_421) resistor r=12.3172
    rVDD_219 (MM9_ELT_s VDD_421) resistor r=1.62887
    rVDD_218 (MM9_ELT_s VDD_424) resistor r=2.55965
    rVDD_217 (VDD_420 VDD_421) resistor r=12.3172
    rVDD_216 (VDD_420 VDD_493) resistor r=10.2363
    rVDD_215 (VDD_422 VDD_424) resistor r=14.4784
    rVDD_214 (VDD_422 VDD_497) resistor r=10.5593
    rVDD_213 (VDD_423 VDD_424) resistor r=14.4784
    rVDD_212 (VDD_423 VDD_495) resistor r=10.5593
    rVDD_211 (MM6_ELT_s VDD_428) resistor r=2.55965
    rVDD_210 (MM6_ELT_s VDD_430) resistor r=12.3172
    rVDD_209 (MM6_ELT_s VDD_430) resistor r=1.62887
    rVDD_208 (VDD_426 VDD_428) resistor r=14.4784
    rVDD_207 (VDD_426 VDD_501) resistor r=10.5593
    rVDD_206 (VDD_427 VDD_428) resistor r=14.4784
    rVDD_205 (VDD_427 VDD_497) resistor r=10.5593
    rVDD_204 (VDD_429 VDD_430) resistor r=12.3172
    rVDD_203 (VDD_429 VDD_499) resistor r=10.2363
    rVDD_202 (MM2_ELT_s VDD_433) resistor r=12.3172
    rVDD_201 (MM2_ELT_s VDD_433) resistor r=1.62887
    rVDD_200 (MM2_ELT_s VDD_436) resistor r=2.55965
    rVDD_199 (VDD_432 VDD_433) resistor r=12.3172
    rVDD_198 (VDD_432 VDD_499) resistor r=10.2363
    rVDD_197 (VDD_434 VDD_436) resistor r=14.4784
    rVDD_196 (VDD_434 VDD_503) resistor r=10.5593
    rVDD_195 (VDD_435 VDD_436) resistor r=14.4784
    rVDD_194 (VDD_435 VDD_501) resistor r=10.5593
    rVDD_193 (MM3_ELT_s VDD_440) resistor r=2.55965
    rVDD_192 (MM3_ELT_s VDD_442) resistor r=12.3172
    rVDD_191 (MM3_ELT_s VDD_442) resistor r=1.62887
    rVDD_190 (VDD_438 VDD_440) resistor r=14.4784
    rVDD_189 (VDD_438 VDD_507) resistor r=10.5593
    rVDD_188 (VDD_439 VDD_440) resistor r=14.4784
    rVDD_187 (VDD_439 VDD_503) resistor r=10.5593
    rVDD_186 (VDD_441 VDD_442) resistor r=12.3172
    rVDD_185 (VDD_441 VDD_505) resistor r=10.2363
    rVDD_184 (MM14_ELT_s VDD_445) resistor r=12.3172
    rVDD_183 (MM14_ELT_s VDD_445) resistor r=1.62887
    rVDD_182 (MM14_ELT_s VDD_448) resistor r=2.55965
    rVDD_181 (MM14_ELT_s VDD_449) resistor r=25.7298
    rVDD_180 (VDD_444 VDD_445) resistor r=12.3172
    rVDD_179 (VDD_444 VDD_505) resistor r=10.2363
    rVDD_178 (VDD_446 VDD_448) resistor r=14.4784
    rVDD_177 (VDD_446 VDD_449) resistor r=9.04062
    rVDD_176 (VDD_447 VDD_448) resistor r=14.4784
    rVDD_175 (VDD_447 VDD_507) resistor r=10.5593
    rVDD_174 (VDD_450 VDD_451) resistor r=0.730683
    rVDD_173 (VDD_452 VDD_453) resistor r=0.549089
    rVDD_172 (VDD_454 VDD_455) resistor r=0.730683
    rVDD_171 (VDD_456 VDD_457) resistor r=0.730683
    rVDD_170 (VDD_458 VDD_459) resistor r=0.549089
    rVDD_169 (VDD_460 VDD_461) resistor r=0.730683
    rVDD_168 (VDD_462 VDD_463) resistor r=0.549089
    rVDD_167 (VDD_464 VDD_465) resistor r=0.730683
    rVDD_166 (VDD_466 VDD_467) resistor r=0.730683
    rVDD_165 (VDD_468 VDD_469) resistor r=0.549089
    rVDD_164 (VDD_470 VDD_471) resistor r=0.730683
    rVDD_163 (VDD_472 VDD_473) resistor r=0.730683
    rVDD_162 (VDD_474 VDD_475) resistor r=0.549089
    rVDD_161 (VDD_476 VDD_477) resistor r=0.730683
    rVDD_160 (VDD_478 VDD_479) resistor r=0.730683
    rVDD_159 (VDD_480 VDD_481) resistor r=0.549089
    rVDD_158 (VDD_482 VDD_483) resistor r=0.730683
    rVDD_157 (VDD_484 VDD_485) resistor r=0.730683
    rVDD_156 (VDD_486 VDD_487) resistor r=0.549089
    rVDD_155 (VDD_488 VDD_489) resistor r=0.730683
    rVDD_154 (VDD_490 VDD_491) resistor r=0.730683
    rVDD_153 (VDD_492 VDD_493) resistor r=0.549089
    rVDD_152 (VDD_494 VDD_495) resistor r=0.730683
    rVDD_151 (VDD_496 VDD_497) resistor r=0.730683
    rVDD_150 (VDD_498 VDD_499) resistor r=0.549089
    rVDD_149 (VDD_500 VDD_501) resistor r=0.730683
    rVDD_148 (VDD_502 VDD_503) resistor r=0.730683
    rVDD_147 (VDD_504 VDD_505) resistor r=0.549089
    rVDD_146 (VDD_506 VDD_507) resistor r=0.730683
    rVSS_571 (MM21_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_570 (MM7_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_569 (MM12_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_568 (MM32_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_567 (MM31_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_566 (MM30_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_565 (MM29_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_564 (MM28_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_563 (MM27_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_562 (MM26_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_561 (MM25_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_560 (MM19_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_559 (MM18_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_558 (MM16_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_557 (MM10_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_556 (MM5_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_555 (MM4_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_554 (MM1_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_553 (MM15_ELT_b MM22_ELT_b) resistor r=0.01
    rVSS_552 (MM22_ELT_b VSS_92) resistor r=21.5743
    rVSS_551 (MM22_ELT_b VSS_102) resistor r=43.1485
    rVSS_550 (VSS_2 VSS_7) resistor r=0.114847
    rVSS_549 (VSS_2 VSS_187) resistor r=0.0221957
    rVSS_548 (VSS VSS_7) resistor r=0.100986
    rVSS_547 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_546 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_545 (VSS_9 VSS_11) resistor r=0.446035
    rVSS_544 (VSS_9 VSS_187) resistor r=0.0885198
    rVSS_543 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_542 (VSS_12 MM21_ELT_s) resistor r=2.27123
    rVSS_541 (VSS_12 MM22_ELT_s) resistor r=2.27123
    rVSS_540 (VSS_12 VSS_334) resistor r=8.4738
    rVSS_539 (VSS_14 VSS_17) resistor r=0.0831649
    rVSS_538 (VSS_14 VSS_188) resistor r=0.0221957
    rVSS_537 (VSS_15 VSS_17) resistor r=0.0871252
    rVSS_536 (VSS_15 VSS_187) resistor r=0.0221957
    rVSS_535 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_534 (VSS_18 VSS_28) resistor r=64.7228
    rVSS_533 (VSS_19 VSS_21) resistor r=0.446035
    rVSS_532 (VSS_19 VSS_188) resistor r=0.0885198
    rVSS_531 (VSS_21 VSS_22) resistor r=8.66667
    rVSS_530 (VSS_22 MM7_ELT_s) resistor r=4.22001
    rVSS_529 (VSS_22 VSS_338) resistor r=4.22001
    rVSS_528 (VSS_22 MM21_ELT_s) resistor r=4.22001
    rVSS_527 (VSS_22 VSS_336) resistor r=4.22001
    rVSS_526 (VSS_24 VSS_27) resistor r=0.051483
    rVSS_525 (VSS_24 VSS_189) resistor r=0.0221957
    rVSS_524 (VSS_25 VSS_27) resistor r=0.118807
    rVSS_523 (VSS_25 VSS_188) resistor r=0.0221957
    rVSS_522 (VSS_27 VSS_28) resistor r=8.66667
    rVSS_521 (VSS_28 VSS_38) resistor r=64.7228
    rVSS_520 (VSS_29 VSS_31) resistor r=0.446035
    rVSS_519 (VSS_29 VSS_189) resistor r=0.0885198
    rVSS_518 (VSS_31 VSS_32) resistor r=8.66667
    rVSS_517 (VSS_32 MM12_ELT_s) resistor r=2.27123
    rVSS_516 (VSS_32 MM7_ELT_s) resistor r=2.27123
    rVSS_515 (VSS_32 VSS_340) resistor r=8.4738
    rVSS_514 (VSS_34 VSS_37) resistor r=0.0198012
    rVSS_513 (VSS_34 VSS_190) resistor r=0.0221957
    rVSS_512 (VSS_35 VSS_37) resistor r=0.150489
    rVSS_511 (VSS_35 VSS_189) resistor r=0.0221957
    rVSS_510 (VSS_37 VSS_38) resistor r=8.66667
    rVSS_509 (VSS_38 VSS_193) resistor r=64.7228
    rVSS_508 (VSS_39 VSS_41) resistor r=0.446035
    rVSS_507 (VSS_39 VSS_190) resistor r=0.0885198
    rVSS_506 (VSS_41 VSS_42) resistor r=8.66667
    rVSS_505 (VSS_42 MM32_ELT_s) resistor r=4.22001
    rVSS_504 (VSS_42 VSS_344) resistor r=4.22001
    rVSS_503 (VSS_42 MM12_ELT_s) resistor r=4.22001
    rVSS_502 (VSS_42 VSS_342) resistor r=4.22001
    rVSS_501 (VSS_44 VSS_45) resistor r=0.17029
    rVSS_500 (VSS_44 VSS_192) resistor r=0.0221957
    rVSS_499 (VSS_45 VSS_190) resistor r=0.0221957
    rVSS_498 (VSS_46 VSS_48) resistor r=0.446035
    rVSS_497 (VSS_46 VSS_192) resistor r=0.0885198
    rVSS_496 (VSS_48 VSS_49) resistor r=8.66667
    rVSS_495 (VSS_49 MM31_ELT_s) resistor r=4.22001
    rVSS_494 (VSS_49 VSS_348) resistor r=4.22001
    rVSS_493 (VSS_49 MM32_ELT_s) resistor r=4.22001
    rVSS_492 (VSS_49 VSS_346) resistor r=4.22001
    rVSS_491 (VSS_51 VSS_52) resistor r=0.17029
    rVSS_490 (VSS_51 VSS_194) resistor r=0.0221957
    rVSS_489 (VSS_52 VSS_192) resistor r=0.0221957
    rVSS_488 (VSS_53 VSS_55) resistor r=0.446035
    rVSS_487 (VSS_53 VSS_194) resistor r=0.0885198
    rVSS_486 (VSS_55 VSS_56) resistor r=8.66667
    rVSS_485 (VSS_56 MM30_ELT_s) resistor r=2.27123
    rVSS_484 (VSS_56 MM31_ELT_s) resistor r=2.27123
    rVSS_483 (VSS_56 VSS_350) resistor r=8.4738
    rVSS_482 (VSS_58 VSS_61) resistor r=0.16237
    rVSS_481 (VSS_58 VSS_195) resistor r=0.0221957
    rVSS_480 (VSS_59 VSS_61) resistor r=0.00792047
    rVSS_479 (VSS_59 VSS_194) resistor r=0.0221957
    rVSS_478 (VSS_61 VSS_62) resistor r=8.66667
    rVSS_477 (VSS_62 VSS_193) resistor r=64.7228
    rVSS_476 (VSS_62 VSS_72) resistor r=64.7228
    rVSS_475 (VSS_63 VSS_65) resistor r=0.446035
    rVSS_474 (VSS_63 VSS_195) resistor r=0.0885198
    rVSS_473 (VSS_65 VSS_66) resistor r=8.66667
    rVSS_472 (VSS_66 MM29_ELT_s) resistor r=4.22001
    rVSS_471 (VSS_66 VSS_354) resistor r=4.22001
    rVSS_470 (VSS_66 MM30_ELT_s) resistor r=4.22001
    rVSS_469 (VSS_66 VSS_352) resistor r=4.22001
    rVSS_468 (VSS_68 VSS_71) resistor r=0.130688
    rVSS_467 (VSS_68 VSS_196) resistor r=0.0221957
    rVSS_466 (VSS_69 VSS_71) resistor r=0.0396023
    rVSS_465 (VSS_69 VSS_195) resistor r=0.0221957
    rVSS_464 (VSS_71 VSS_72) resistor r=8.66667
    rVSS_463 (VSS_72 VSS_82) resistor r=64.7228
    rVSS_462 (VSS_73 VSS_75) resistor r=0.446035
    rVSS_461 (VSS_73 VSS_196) resistor r=0.0885198
    rVSS_460 (VSS_75 VSS_76) resistor r=8.66667
    rVSS_459 (VSS_76 MM28_ELT_s) resistor r=2.27123
    rVSS_458 (VSS_76 MM29_ELT_s) resistor r=2.27123
    rVSS_457 (VSS_76 VSS_356) resistor r=8.4738
    rVSS_456 (VSS_78 VSS_81) resistor r=0.0990059
    rVSS_455 (VSS_78 VSS_197) resistor r=0.0221957
    rVSS_454 (VSS_79 VSS_81) resistor r=0.0712842
    rVSS_453 (VSS_79 VSS_196) resistor r=0.0221957
    rVSS_452 (VSS_81 VSS_82) resistor r=8.66667
    rVSS_451 (VSS_82 VSS_92) resistor r=64.7228
    rVSS_450 (VSS_83 VSS_85) resistor r=0.446035
    rVSS_449 (VSS_83 VSS_197) resistor r=0.0885198
    rVSS_448 (VSS_85 VSS_86) resistor r=8.66667
    rVSS_447 (VSS_86 MM27_ELT_s) resistor r=4.22001
    rVSS_446 (VSS_86 VSS_360) resistor r=4.22001
    rVSS_445 (VSS_86 MM28_ELT_s) resistor r=4.22001
    rVSS_444 (VSS_86 VSS_358) resistor r=4.22001
    rVSS_443 (VSS_88 VSS_91) resistor r=0.067324
    rVSS_442 (VSS_88 VSS_198) resistor r=0.0221957
    rVSS_441 (VSS_89 VSS_91) resistor r=0.102966
    rVSS_440 (VSS_89 VSS_197) resistor r=0.0221957
    rVSS_439 (VSS_91 VSS_92) resistor r=8.66667
    rVSS_438 (VSS_93 VSS_95) resistor r=0.446035
    rVSS_437 (VSS_93 VSS_198) resistor r=0.0885198
    rVSS_436 (VSS_95 VSS_96) resistor r=8.66667
    rVSS_435 (VSS_96 MM26_ELT_s) resistor r=2.27123
    rVSS_434 (VSS_96 MM27_ELT_s) resistor r=2.27123
    rVSS_433 (VSS_96 VSS_362) resistor r=8.4738
    rVSS_432 (VSS_98 VSS_101) resistor r=0.0356421
    rVSS_431 (VSS_98 VSS_199) resistor r=0.0221957
    rVSS_430 (VSS_99 VSS_101) resistor r=0.134648
    rVSS_429 (VSS_99 VSS_198) resistor r=0.0221957
    rVSS_428 (VSS_101 VSS_102) resistor r=8.66667
    rVSS_427 (VSS_102 VSS_112) resistor r=64.7228
    rVSS_426 (VSS_103 VSS_105) resistor r=0.446035
    rVSS_425 (VSS_103 VSS_199) resistor r=0.0885198
    rVSS_424 (VSS_105 VSS_106) resistor r=8.66667
    rVSS_423 (VSS_106 MM25_ELT_s) resistor r=4.22001
    rVSS_422 (VSS_106 VSS_366) resistor r=4.22001
    rVSS_421 (VSS_106 MM26_ELT_s) resistor r=4.22001
    rVSS_420 (VSS_106 VSS_364) resistor r=4.22001
    rVSS_419 (VSS_108 VSS_111) resistor r=0.00396023
    rVSS_418 (VSS_108 VSS_200) resistor r=0.0221957
    rVSS_417 (VSS_109 VSS_111) resistor r=0.16633
    rVSS_416 (VSS_109 VSS_199) resistor r=0.0221957
    rVSS_415 (VSS_111 VSS_112) resistor r=8.66667
    rVSS_414 (VSS_112 VSS_203) resistor r=64.7228
    rVSS_413 (VSS_113 VSS_115) resistor r=0.446035
    rVSS_412 (VSS_113 VSS_200) resistor r=0.0885198
    rVSS_411 (VSS_115 VSS_116) resistor r=8.66667
    rVSS_410 (VSS_116 MM19_ELT_s) resistor r=2.27123
    rVSS_409 (VSS_116 MM25_ELT_s) resistor r=2.27123
    rVSS_408 (VSS_116 VSS_368) resistor r=8.4738
    rVSS_407 (VSS_118 VSS_119) resistor r=0.17029
    rVSS_406 (VSS_118 VSS_202) resistor r=0.0221957
    rVSS_405 (VSS_119 VSS_200) resistor r=0.0221957
    rVSS_404 (VSS_120 VSS_122) resistor r=0.446035
    rVSS_403 (VSS_120 VSS_202) resistor r=0.0885198
    rVSS_402 (VSS_122 VSS_123) resistor r=8.66667
    rVSS_401 (VSS_123 MM18_ELT_s) resistor r=4.22001
    rVSS_400 (VSS_123 VSS_372) resistor r=4.22001
    rVSS_399 (VSS_123 MM19_ELT_s) resistor r=4.22001
    rVSS_398 (VSS_123 VSS_370) resistor r=4.22001
    rVSS_397 (VSS_125 VSS_126) resistor r=0.17029
    rVSS_396 (VSS_125 VSS_204) resistor r=0.0221957
    rVSS_395 (VSS_126 VSS_202) resistor r=0.0221957
    rVSS_394 (VSS_127 VSS_129) resistor r=0.446035
    rVSS_393 (VSS_127 VSS_204) resistor r=0.0885198
    rVSS_392 (VSS_129 VSS_130) resistor r=8.66667
    rVSS_391 (VSS_130 MM16_ELT_s) resistor r=2.27123
    rVSS_390 (VSS_130 MM18_ELT_s) resistor r=2.27123
    rVSS_389 (VSS_130 VSS_374) resistor r=8.4738
    rVSS_388 (VSS_132 VSS_135) resistor r=0.146529
    rVSS_387 (VSS_132 VSS_205) resistor r=0.0221957
    rVSS_386 (VSS_133 VSS_135) resistor r=0.0237614
    rVSS_385 (VSS_133 VSS_204) resistor r=0.0221957
    rVSS_384 (VSS_135 VSS_136) resistor r=8.66667
    rVSS_383 (VSS_136 VSS_203) resistor r=64.7228
    rVSS_382 (VSS_136 VSS_146) resistor r=64.7228
    rVSS_381 (VSS_137 VSS_139) resistor r=0.446035
    rVSS_380 (VSS_137 VSS_205) resistor r=0.0885198
    rVSS_379 (VSS_139 VSS_140) resistor r=8.66667
    rVSS_378 (VSS_140 MM10_ELT_s) resistor r=4.22001
    rVSS_377 (VSS_140 VSS_378) resistor r=4.22001
    rVSS_376 (VSS_140 MM16_ELT_s) resistor r=4.22001
    rVSS_375 (VSS_140 VSS_376) resistor r=4.22001
    rVSS_374 (VSS_142 VSS_145) resistor r=0.114847
    rVSS_373 (VSS_142 VSS_206) resistor r=0.0221957
    rVSS_372 (VSS_143 VSS_145) resistor r=0.0554433
    rVSS_371 (VSS_143 VSS_205) resistor r=0.0221957
    rVSS_370 (VSS_145 VSS_146) resistor r=8.66667
    rVSS_369 (VSS_146 VSS_156) resistor r=64.7228
    rVSS_368 (VSS_147 VSS_149) resistor r=0.446035
    rVSS_367 (VSS_147 VSS_206) resistor r=0.0885198
    rVSS_366 (VSS_149 VSS_150) resistor r=8.66667
    rVSS_365 (VSS_150 MM5_ELT_s) resistor r=2.27123
    rVSS_364 (VSS_150 MM10_ELT_s) resistor r=2.27123
    rVSS_363 (VSS_150 VSS_380) resistor r=8.4738
    rVSS_362 (VSS_152 VSS_155) resistor r=0.0831649
    rVSS_361 (VSS_152 VSS_207) resistor r=0.0221957
    rVSS_360 (VSS_153 VSS_155) resistor r=0.0871252
    rVSS_359 (VSS_153 VSS_206) resistor r=0.0221957
    rVSS_358 (VSS_155 VSS_156) resistor r=8.66667
    rVSS_357 (VSS_156 VSS_166) resistor r=64.7228
    rVSS_356 (VSS_157 VSS_159) resistor r=0.446035
    rVSS_355 (VSS_157 VSS_207) resistor r=0.0885198
    rVSS_354 (VSS_159 VSS_160) resistor r=8.66667
    rVSS_353 (VSS_160 MM4_ELT_s) resistor r=4.22001
    rVSS_352 (VSS_160 VSS_384) resistor r=4.22001
    rVSS_351 (VSS_160 MM5_ELT_s) resistor r=4.22001
    rVSS_350 (VSS_160 VSS_382) resistor r=4.22001
    rVSS_349 (VSS_162 VSS_165) resistor r=0.051483
    rVSS_348 (VSS_162 VSS_208) resistor r=0.0221957
    rVSS_347 (VSS_163 VSS_165) resistor r=0.118807
    rVSS_346 (VSS_163 VSS_207) resistor r=0.0221957
    rVSS_345 (VSS_165 VSS_166) resistor r=8.66667
    rVSS_344 (VSS_166 VSS_176) resistor r=64.7228
    rVSS_343 (VSS_167 VSS_169) resistor r=0.446035
    rVSS_342 (VSS_167 VSS_208) resistor r=0.0885198
    rVSS_341 (VSS_169 VSS_170) resistor r=8.66667
    rVSS_340 (VSS_170 MM1_ELT_s) resistor r=2.27123
    rVSS_339 (VSS_170 MM4_ELT_s) resistor r=2.27123
    rVSS_338 (VSS_170 VSS_386) resistor r=8.4738
    rVSS_337 (VSS_172 VSS_175) resistor r=0.0198012
    rVSS_336 (VSS_172 VSS_209) resistor r=0.0221957
    rVSS_335 (VSS_173 VSS_175) resistor r=0.150489
    rVSS_334 (VSS_173 VSS_208) resistor r=0.0221957
    rVSS_333 (VSS_175 VSS_176) resistor r=8.66667
    rVSS_332 (VSS_176 VSS_185) resistor r=43.1485
    rVSS_331 (VSS_177 VSS_179) resistor r=0.446035
    rVSS_330 (VSS_177 VSS_209) resistor r=0.0885198
    rVSS_329 (VSS_179 VSS_180) resistor r=8.66667
    rVSS_328 (VSS_180 MM15_ELT_s) resistor r=4.22001
    rVSS_327 (VSS_180 VSS_390) resistor r=4.22001
    rVSS_326 (VSS_180 MM1_ELT_s) resistor r=4.22001
    rVSS_325 (VSS_180 VSS_388) resistor r=4.22001
    rVSS_324 (VSS_182 VSS_184) resistor r=0.102966
    rVSS_323 (VSS_182 VSS_209) resistor r=0.0221957
    rVSS_322 (VSS_184 VSS_185) resistor r=13
    rVSS_321 (VSS_192 VSS_193) resistor r=8.66667
    rVSS_320 (VSS_202 VSS_203) resistor r=8.66667
    rVSS_319 (VSS_210 VSS_213) resistor r=21.1301
    rVSS_318 (VSS_210 VSS_215) resistor r=9.43134
    rVSS_317 (VSS_211 VSS_213) resistor r=21.1301
    rVSS_316 (VSS_211 VSS_217) resistor r=9.4369
    rVSS_315 (MM22_ELT_s VSS_213) resistor r=4.557
    rVSS_314 (MM22_ELT_s VSS_216) resistor r=2.67027
    rVSS_313 (MM22_ELT_s VSS_218) resistor r=12.8495
    rVSS_312 (MM22_ELT_s VSS_218) resistor r=1.69926
    rVSS_311 (VSS_214 VSS_216) resistor r=15.1041
    rVSS_310 (VSS_214 VSS_335) resistor r=11.0157
    rVSS_309 (VSS_215 VSS_216) resistor r=15.1041
    rVSS_308 (VSS_217 VSS_218) resistor r=12.8495
    rVSS_307 (MM21_ELT_s VSS_222) resistor r=2.67027
    rVSS_306 (MM21_ELT_s VSS_224) resistor r=12.8495
    rVSS_305 (MM21_ELT_s VSS_224) resistor r=1.69926
    rVSS_304 (VSS_220 VSS_222) resistor r=15.1041
    rVSS_303 (VSS_220 VSS_337) resistor r=11.0157
    rVSS_302 (VSS_221 VSS_222) resistor r=15.1041
    rVSS_301 (VSS_221 VSS_335) resistor r=11.0157
    rVSS_300 (VSS_223 VSS_224) resistor r=12.8495
    rVSS_299 (VSS_223 VSS_339) resistor r=10.6787
    rVSS_298 (MM7_ELT_s VSS_228) resistor r=2.67027
    rVSS_297 (MM7_ELT_s VSS_230) resistor r=12.8495
    rVSS_296 (MM7_ELT_s VSS_230) resistor r=1.69926
    rVSS_295 (VSS_226 VSS_228) resistor r=15.1041
    rVSS_294 (VSS_226 VSS_341) resistor r=11.0157
    rVSS_293 (VSS_227 VSS_228) resistor r=15.1041
    rVSS_292 (VSS_227 VSS_337) resistor r=11.0157
    rVSS_291 (VSS_229 VSS_230) resistor r=12.8495
    rVSS_290 (VSS_229 VSS_339) resistor r=10.6787
    rVSS_289 (MM12_ELT_s VSS_234) resistor r=2.67027
    rVSS_288 (MM12_ELT_s VSS_236) resistor r=12.8495
    rVSS_287 (MM12_ELT_s VSS_236) resistor r=1.69926
    rVSS_286 (VSS_232 VSS_234) resistor r=15.1041
    rVSS_285 (VSS_232 VSS_343) resistor r=11.0157
    rVSS_284 (VSS_233 VSS_234) resistor r=15.1041
    rVSS_283 (VSS_233 VSS_341) resistor r=11.0157
    rVSS_282 (VSS_235 VSS_236) resistor r=12.8495
    rVSS_281 (VSS_235 VSS_345) resistor r=10.6787
    rVSS_280 (MM32_ELT_s VSS_240) resistor r=2.67027
    rVSS_279 (MM32_ELT_s VSS_242) resistor r=12.8495
    rVSS_278 (MM32_ELT_s VSS_242) resistor r=1.69926
    rVSS_277 (MM32_ELT_s VSS_345) resistor r=10.6787
    rVSS_276 (VSS_238 VSS_240) resistor r=15.1041
    rVSS_275 (VSS_238 VSS_347) resistor r=11.0157
    rVSS_274 (VSS_239 VSS_240) resistor r=15.1041
    rVSS_273 (VSS_239 VSS_343) resistor r=11.0157
    rVSS_272 (VSS_241 VSS_242) resistor r=12.8495
    rVSS_271 (VSS_241 VSS_349) resistor r=10.6787
    rVSS_270 (MM31_ELT_s VSS_246) resistor r=2.67027
    rVSS_269 (MM31_ELT_s VSS_248) resistor r=12.8495
    rVSS_268 (MM31_ELT_s VSS_248) resistor r=1.69926
    rVSS_267 (VSS_244 VSS_246) resistor r=15.1041
    rVSS_266 (VSS_244 VSS_351) resistor r=11.0157
    rVSS_265 (VSS_245 VSS_246) resistor r=15.1041
    rVSS_264 (VSS_245 VSS_347) resistor r=11.0157
    rVSS_263 (VSS_247 VSS_248) resistor r=12.8495
    rVSS_262 (VSS_247 VSS_349) resistor r=10.6787
    rVSS_261 (MM30_ELT_s VSS_252) resistor r=2.67027
    rVSS_260 (MM30_ELT_s VSS_254) resistor r=12.8495
    rVSS_259 (MM30_ELT_s VSS_254) resistor r=1.69926
    rVSS_258 (VSS_250 VSS_252) resistor r=15.1041
    rVSS_257 (VSS_250 VSS_353) resistor r=11.0157
    rVSS_256 (VSS_251 VSS_252) resistor r=15.1041
    rVSS_255 (VSS_251 VSS_351) resistor r=11.0157
    rVSS_254 (VSS_253 VSS_254) resistor r=12.8495
    rVSS_253 (VSS_253 VSS_355) resistor r=10.6787
    rVSS_252 (MM29_ELT_s VSS_258) resistor r=2.67027
    rVSS_251 (MM29_ELT_s VSS_260) resistor r=12.8495
    rVSS_250 (MM29_ELT_s VSS_260) resistor r=1.69926
    rVSS_249 (VSS_256 VSS_258) resistor r=15.1041
    rVSS_248 (VSS_256 VSS_357) resistor r=11.0157
    rVSS_247 (VSS_257 VSS_258) resistor r=15.1041
    rVSS_246 (VSS_257 VSS_353) resistor r=11.0157
    rVSS_245 (VSS_259 VSS_260) resistor r=12.8495
    rVSS_244 (VSS_259 VSS_355) resistor r=10.6787
    rVSS_243 (MM28_ELT_s VSS_264) resistor r=2.67027
    rVSS_242 (MM28_ELT_s VSS_266) resistor r=12.8495
    rVSS_241 (MM28_ELT_s VSS_266) resistor r=1.69926
    rVSS_240 (VSS_262 VSS_264) resistor r=15.1041
    rVSS_239 (VSS_262 VSS_359) resistor r=11.0157
    rVSS_238 (VSS_263 VSS_264) resistor r=15.1041
    rVSS_237 (VSS_263 VSS_357) resistor r=11.0157
    rVSS_236 (VSS_265 VSS_266) resistor r=12.8495
    rVSS_235 (VSS_265 VSS_361) resistor r=10.6787
    rVSS_234 (MM27_ELT_s VSS_270) resistor r=2.67027
    rVSS_233 (MM27_ELT_s VSS_272) resistor r=12.8495
    rVSS_232 (MM27_ELT_s VSS_272) resistor r=1.69926
    rVSS_231 (VSS_268 VSS_270) resistor r=15.1041
    rVSS_230 (VSS_268 VSS_363) resistor r=11.0157
    rVSS_229 (VSS_269 VSS_270) resistor r=15.1041
    rVSS_228 (VSS_269 VSS_359) resistor r=11.0157
    rVSS_227 (VSS_271 VSS_272) resistor r=12.8495
    rVSS_226 (VSS_271 VSS_361) resistor r=10.6787
    rVSS_225 (MM26_ELT_s VSS_276) resistor r=2.67027
    rVSS_224 (MM26_ELT_s VSS_278) resistor r=12.8495
    rVSS_223 (MM26_ELT_s VSS_278) resistor r=1.69926
    rVSS_222 (VSS_274 VSS_276) resistor r=15.1041
    rVSS_221 (VSS_274 VSS_365) resistor r=11.0157
    rVSS_220 (VSS_275 VSS_276) resistor r=15.1041
    rVSS_219 (VSS_275 VSS_363) resistor r=11.0157
    rVSS_218 (VSS_277 VSS_278) resistor r=12.8495
    rVSS_217 (VSS_277 VSS_367) resistor r=10.6787
    rVSS_216 (MM25_ELT_s VSS_282) resistor r=2.67027
    rVSS_215 (MM25_ELT_s VSS_284) resistor r=12.8495
    rVSS_214 (MM25_ELT_s VSS_284) resistor r=1.69926
    rVSS_213 (VSS_280 VSS_282) resistor r=15.1041
    rVSS_212 (VSS_280 VSS_369) resistor r=11.0157
    rVSS_211 (VSS_281 VSS_282) resistor r=15.1041
    rVSS_210 (VSS_281 VSS_365) resistor r=11.0157
    rVSS_209 (VSS_283 VSS_284) resistor r=12.8495
    rVSS_208 (VSS_283 VSS_367) resistor r=10.6787
    rVSS_207 (MM19_ELT_s VSS_288) resistor r=2.67027
    rVSS_206 (MM19_ELT_s VSS_290) resistor r=12.8495
    rVSS_205 (MM19_ELT_s VSS_290) resistor r=1.69926
    rVSS_204 (VSS_286 VSS_288) resistor r=15.1041
    rVSS_203 (VSS_286 VSS_371) resistor r=11.0157
    rVSS_202 (VSS_287 VSS_288) resistor r=15.1041
    rVSS_201 (VSS_287 VSS_369) resistor r=11.0157
    rVSS_200 (VSS_289 VSS_290) resistor r=12.8495
    rVSS_199 (VSS_289 VSS_373) resistor r=10.6787
    rVSS_198 (MM18_ELT_s VSS_294) resistor r=2.67027
    rVSS_197 (MM18_ELT_s VSS_296) resistor r=12.8495
    rVSS_196 (MM18_ELT_s VSS_296) resistor r=1.69926
    rVSS_195 (VSS_292 VSS_294) resistor r=15.1041
    rVSS_194 (VSS_292 VSS_375) resistor r=11.0157
    rVSS_193 (VSS_293 VSS_294) resistor r=15.1041
    rVSS_192 (VSS_293 VSS_371) resistor r=11.0157
    rVSS_191 (VSS_295 VSS_296) resistor r=12.8495
    rVSS_190 (VSS_295 VSS_373) resistor r=10.6787
    rVSS_189 (MM16_ELT_s VSS_300) resistor r=2.67027
    rVSS_188 (MM16_ELT_s VSS_302) resistor r=12.8495
    rVSS_187 (MM16_ELT_s VSS_302) resistor r=1.69926
    rVSS_186 (VSS_298 VSS_300) resistor r=15.1041
    rVSS_185 (VSS_298 VSS_377) resistor r=11.0157
    rVSS_184 (VSS_299 VSS_300) resistor r=15.1041
    rVSS_183 (VSS_299 VSS_375) resistor r=11.0157
    rVSS_182 (VSS_301 VSS_302) resistor r=12.8495
    rVSS_181 (VSS_301 VSS_379) resistor r=10.6787
    rVSS_180 (MM10_ELT_s VSS_306) resistor r=2.67027
    rVSS_179 (MM10_ELT_s VSS_308) resistor r=12.8495
    rVSS_178 (MM10_ELT_s VSS_308) resistor r=1.69926
    rVSS_177 (VSS_304 VSS_306) resistor r=15.1041
    rVSS_176 (VSS_304 VSS_381) resistor r=11.0157
    rVSS_175 (VSS_305 VSS_306) resistor r=15.1041
    rVSS_174 (VSS_305 VSS_377) resistor r=11.0157
    rVSS_173 (VSS_307 VSS_308) resistor r=12.8495
    rVSS_172 (VSS_307 VSS_379) resistor r=10.6787
    rVSS_171 (MM5_ELT_s VSS_312) resistor r=2.67027
    rVSS_170 (MM5_ELT_s VSS_314) resistor r=12.8495
    rVSS_169 (MM5_ELT_s VSS_314) resistor r=1.69926
    rVSS_168 (VSS_310 VSS_312) resistor r=15.1041
    rVSS_167 (VSS_310 VSS_383) resistor r=11.0157
    rVSS_166 (VSS_311 VSS_312) resistor r=15.1041
    rVSS_165 (VSS_311 VSS_381) resistor r=11.0157
    rVSS_164 (VSS_313 VSS_314) resistor r=12.8495
    rVSS_163 (VSS_313 VSS_385) resistor r=10.6787
    rVSS_162 (MM4_ELT_s VSS_318) resistor r=2.67027
    rVSS_161 (MM4_ELT_s VSS_320) resistor r=12.8495
    rVSS_160 (MM4_ELT_s VSS_320) resistor r=1.69926
    rVSS_159 (VSS_316 VSS_318) resistor r=15.1041
    rVSS_158 (VSS_316 VSS_387) resistor r=11.0157
    rVSS_157 (VSS_317 VSS_318) resistor r=15.1041
    rVSS_156 (VSS_317 VSS_383) resistor r=11.0157
    rVSS_155 (VSS_319 VSS_320) resistor r=12.8495
    rVSS_154 (VSS_319 VSS_385) resistor r=10.6787
    rVSS_153 (MM1_ELT_s VSS_324) resistor r=2.67027
    rVSS_152 (MM1_ELT_s VSS_326) resistor r=12.8495
    rVSS_151 (MM1_ELT_s VSS_326) resistor r=1.69926
    rVSS_150 (VSS_322 VSS_324) resistor r=15.1041
    rVSS_149 (VSS_322 VSS_389) resistor r=11.0157
    rVSS_148 (VSS_323 VSS_324) resistor r=15.1041
    rVSS_147 (VSS_323 VSS_387) resistor r=11.0157
    rVSS_146 (VSS_325 VSS_326) resistor r=12.8495
    rVSS_145 (VSS_325 VSS_391) resistor r=10.6787
    rVSS_144 (MM15_ELT_s VSS_330) resistor r=2.67027
    rVSS_143 (MM15_ELT_s VSS_332) resistor r=12.8495
    rVSS_142 (MM15_ELT_s VSS_332) resistor r=1.69926
    rVSS_141 (MM15_ELT_s VSS_333) resistor r=18.0507
    rVSS_140 (VSS_328 VSS_330) resistor r=15.1041
    rVSS_139 (VSS_328 VSS_333) resistor r=9.43134
    rVSS_138 (VSS_329 VSS_330) resistor r=15.1041
    rVSS_137 (VSS_329 VSS_389) resistor r=11.0157
    rVSS_136 (VSS_331 VSS_332) resistor r=12.8495
    rVSS_135 (VSS_331 VSS_391) resistor r=10.6787
    rVSS_134 (VSS_334 VSS_335) resistor r=0.762262
    rVSS_133 (VSS_336 VSS_337) resistor r=0.762262
    rVSS_132 (VSS_338 VSS_339) resistor r=0.57282
    rVSS_131 (VSS_340 VSS_341) resistor r=0.762262
    rVSS_130 (VSS_342 VSS_343) resistor r=0.762262
    rVSS_129 (VSS_344 VSS_345) resistor r=0.57282
    rVSS_128 (VSS_346 VSS_347) resistor r=0.762262
    rVSS_127 (VSS_348 VSS_349) resistor r=0.57282
    rVSS_126 (VSS_350 VSS_351) resistor r=0.762262
    rVSS_125 (VSS_352 VSS_353) resistor r=0.762262
    rVSS_124 (VSS_354 VSS_355) resistor r=0.57282
    rVSS_123 (VSS_356 VSS_357) resistor r=0.762262
    rVSS_122 (VSS_358 VSS_359) resistor r=0.762262
    rVSS_121 (VSS_360 VSS_361) resistor r=0.57282
    rVSS_120 (VSS_362 VSS_363) resistor r=0.762262
    rVSS_119 (VSS_364 VSS_365) resistor r=0.762262
    rVSS_118 (VSS_366 VSS_367) resistor r=0.57282
    rVSS_117 (VSS_368 VSS_369) resistor r=0.762262
    rVSS_116 (VSS_370 VSS_371) resistor r=0.762262
    rVSS_115 (VSS_372 VSS_373) resistor r=0.57282
    rVSS_114 (VSS_374 VSS_375) resistor r=0.762262
    rVSS_113 (VSS_376 VSS_377) resistor r=0.762262
    rVSS_112 (VSS_378 VSS_379) resistor r=0.57282
    rVSS_111 (VSS_380 VSS_381) resistor r=0.762262
    rVSS_110 (VSS_382 VSS_383) resistor r=0.762262
    rVSS_109 (VSS_384 VSS_385) resistor r=0.57282
    rVSS_108 (VSS_386 VSS_387) resistor r=0.762262
    rVSS_107 (VSS_388 VSS_389) resistor r=0.762262
    rVSS_106 (VSS_390 VSS_391) resistor r=0.57282
    rnet11_1670 (MM13_ELT_d net11) resistor r=0.01
    rnet11_1669 (net11_322 net11_328) resistor r=58.3583
    rnet11_1668 (net11_322 net11_328) resistor r=4.16253
    rnet11_1667 (net11_322 net11_328) resistor r=58.3583
    rnet11_1666 (net11_322 net11_328) resistor r=4.16253
    rnet11_1665 (net11_325 net11_328) resistor r=58.3583
    rnet11_1664 (net11_325 net11_328) resistor r=6.30933
    rnet11_1663 (net11_325 net11_328) resistor r=58.3583
    rnet11_1662 (net11_325 net11_328) resistor r=6.30933
    rnet11_1661 (net11_328 net11_330) resistor r=14.9
    rnet11_1660 (net11_328 net11_353) resistor r=24.8333
    rnet11_1659 (net11_328 net11_350) resistor r=24.8333
    rnet11_1658 (net11_328 net11_361) resistor r=24.8333
    rnet11_1657 (net11_328 net11_358) resistor r=24.8333
    rnet11_1656 (net11_328 net11_382) resistor r=58.3583
    rnet11_1655 (net11_328 net11_385) resistor r=58.3583
    rnet11_1654 (net11_328 net11_353) resistor r=4.16253
    rnet11_1653 (net11_328 net11_330) resistor r=6.30933
    rnet11_1652 (net11_328 net11_361) resistor r=1.63969
    rnet11_1651 (net11_328 net11_350) resistor r=4.16253
    rnet11_1650 (net11_328 net11_382) resistor r=4.16253
    rnet11_1649 (net11_328 net11_358) resistor r=4.16253
    rnet11_1648 (net11_328 net11_385) resistor r=4.16253
    rnet11_1647 (net11_328 net11_330) resistor r=14.9
    rnet11_1646 (net11_328 net11_2538) resistor r=40.975
    rnet11_1645 (net11_328 net11_353) resistor r=24.8333
    rnet11_1644 (net11_328 net11_350) resistor r=24.8333
    rnet11_1643 (net11_328 net11_361) resistor r=24.8333
    rnet11_1642 (net11_328 net11_358) resistor r=24.8333
    rnet11_1641 (net11_328 net11_382) resistor r=58.3583
    rnet11_1640 (net11_328 MM32_ELT_g) resistor r=7.45
    rnet11_1639 (net11_328 net11_353) resistor r=4.16253
    rnet11_1638 (net11_328 net11_330) resistor r=6.30933
    rnet11_1637 (net11_328 net11_361) resistor r=1.63969
    rnet11_1636 (net11_328 net11_350) resistor r=4.16253
    rnet11_1635 (net11_328 net11_382) resistor r=4.16253
    rnet11_1634 (net11_328 net11_358) resistor r=4.16253
    rnet11_1633 (net11_328 net11_385) resistor r=4.16253
    rnet11_1632 (net11_336 net11_339) resistor r=14.9
    rnet11_1631 (net11_336 net11_339) resistor r=6.30933
    rnet11_1630 (net11_336 net11_339) resistor r=14.9
    rnet11_1629 (net11_336 net11_339) resistor r=6.30933
    rnet11_1628 (net11_339 net11_342) resistor r=202.392
    rnet11_1627 (net11_339 net11_345) resistor r=202.392
    rnet11_1626 (net11_339 net11_369) resistor r=24.8333
    rnet11_1625 (net11_339 net11_366) resistor r=24.8333
    rnet11_1624 (net11_339 net11_377) resistor r=24.8333
    rnet11_1623 (net11_339 net11_374) resistor r=24.8333
    rnet11_1622 (net11_339 net11_390) resistor r=202.392
    rnet11_1621 (net11_339 net11_393) resistor r=202.392
    rnet11_1620 (net11_339 net11_342) resistor r=6.30933
    rnet11_1619 (net11_339 net11_369) resistor r=1.63969
    rnet11_1618 (net11_339 net11_377) resistor r=4.16253
    rnet11_1617 (net11_339 net11_345) resistor r=4.16253
    rnet11_1616 (net11_339 net11_366) resistor r=4.16253
    rnet11_1615 (net11_339 net11_390) resistor r=4.16253
    rnet11_1614 (net11_339 net11_374) resistor r=4.16253
    rnet11_1613 (net11_339 net11_393) resistor r=4.16253
    rnet11_1612 (net11_339 net11_2540) resistor r=40.975
    rnet11_1611 (net11_339 net11_342) resistor r=202.392
    rnet11_1610 (net11_339 net11_345) resistor r=202.392
    rnet11_1609 (net11_339 net11_369) resistor r=24.8333
    rnet11_1608 (net11_339 net11_366) resistor r=24.8333
    rnet11_1607 (net11_339 net11_377) resistor r=24.8333
    rnet11_1606 (net11_339 net11_374) resistor r=24.8333
    rnet11_1605 (net11_339 net11_390) resistor r=202.392
    rnet11_1604 (net11_339 MM40_ELT_g) resistor r=7.45
    rnet11_1603 (net11_339 net11_342) resistor r=6.30933
    rnet11_1602 (net11_339 net11_369) resistor r=1.63969
    rnet11_1601 (net11_339 net11_377) resistor r=4.16253
    rnet11_1600 (net11_339 net11_345) resistor r=4.16253
    rnet11_1599 (net11_339 net11_366) resistor r=4.16253
    rnet11_1598 (net11_339 net11_390) resistor r=4.16253
    rnet11_1597 (net11_339 net11_374) resistor r=4.16253
    rnet11_1596 (net11_339 net11_393) resistor r=4.16253
    rnet11_1595 (net11_385 MM32_ELT_g) resistor r=50.9083
    rnet11_1594 (net11_393 MM40_ELT_g) resistor r=194.942
    rnet11_1593 (net11_398 net11_404) resistor r=58.3583
    rnet11_1592 (net11_398 net11_404) resistor r=4.16253
    rnet11_1591 (net11_398 net11_404) resistor r=58.3583
    rnet11_1590 (net11_398 net11_404) resistor r=4.16253
    rnet11_1589 (net11_401 net11_404) resistor r=58.3583
    rnet11_1588 (net11_401 net11_404) resistor r=4.16253
    rnet11_1587 (net11_401 net11_404) resistor r=58.3583
    rnet11_1586 (net11_401 net11_404) resistor r=4.16253
    rnet11_1585 (net11_404 net11_417) resistor r=24.8333
    rnet11_1584 (net11_404 net11_414) resistor r=24.8333
    rnet11_1583 (net11_404 net11_425) resistor r=24.8333
    rnet11_1582 (net11_404 net11_422) resistor r=24.8333
    rnet11_1581 (net11_404 net11_446) resistor r=58.3583
    rnet11_1580 (net11_404 net11_449) resistor r=58.3583
    rnet11_1579 (net11_404 net11_454) resistor r=14.9
    rnet11_1578 (net11_404 net11_417) resistor r=4.16253
    rnet11_1577 (net11_404 net11_425) resistor r=4.16253
    rnet11_1576 (net11_404 net11_414) resistor r=4.16253
    rnet11_1575 (net11_404 net11_446) resistor r=4.16253
    rnet11_1574 (net11_404 net11_454) resistor r=6.30933
    rnet11_1573 (net11_404 net11_449) resistor r=6.30933
    rnet11_1572 (net11_404 net11_422) resistor r=1.63969
    rnet11_1571 (net11_404 net11_417) resistor r=24.8333
    rnet11_1570 (net11_404 net11_414) resistor r=24.8333
    rnet11_1569 (net11_404 net11_425) resistor r=24.8333
    rnet11_1568 (net11_404 net11_422) resistor r=24.8333
    rnet11_1567 (net11_404 net11_446) resistor r=58.3583
    rnet11_1566 (net11_404 MM31_ELT_g) resistor r=22.35
    rnet11_1565 (net11_404 net11_454) resistor r=14.9
    rnet11_1564 (net11_404 net11_2592) resistor r=40.975
    rnet11_1563 (net11_404 net11_417) resistor r=4.16253
    rnet11_1562 (net11_404 net11_425) resistor r=4.16253
    rnet11_1561 (net11_404 net11_414) resistor r=4.16253
    rnet11_1560 (net11_404 net11_446) resistor r=4.16253
    rnet11_1559 (net11_404 net11_454) resistor r=6.30933
    rnet11_1558 (net11_404 net11_449) resistor r=6.30933
    rnet11_1557 (net11_404 net11_422) resistor r=1.63969
    rnet11_1556 (net11_406 net11_412) resistor r=202.392
    rnet11_1555 (net11_406 net11_412) resistor r=4.16253
    rnet11_1554 (net11_406 net11_412) resistor r=202.392
    rnet11_1553 (net11_406 net11_412) resistor r=4.16253
    rnet11_1552 (net11_409 net11_412) resistor r=202.392
    rnet11_1551 (net11_409 net11_412) resistor r=4.16253
    rnet11_1550 (net11_409 net11_412) resistor r=202.392
    rnet11_1549 (net11_409 net11_412) resistor r=4.16253
    rnet11_1548 (net11_412 net11_433) resistor r=24.8333
    rnet11_1547 (net11_412 net11_430) resistor r=24.8333
    rnet11_1546 (net11_412 net11_441) resistor r=24.8333
    rnet11_1545 (net11_412 net11_438) resistor r=24.8333
    rnet11_1544 (net11_412 net11_460) resistor r=14.9
    rnet11_1543 (net11_412 net11_466) resistor r=202.392
    rnet11_1542 (net11_412 net11_469) resistor r=202.392
    rnet11_1541 (net11_412 net11_433) resistor r=4.16253
    rnet11_1540 (net11_412 net11_441) resistor r=4.16253
    rnet11_1539 (net11_412 net11_466) resistor r=6.30933
    rnet11_1538 (net11_412 net11_460) resistor r=6.30933
    rnet11_1537 (net11_412 net11_430) resistor r=1.63969
    rnet11_1536 (net11_412 net11_438) resistor r=4.16253
    rnet11_1535 (net11_412 net11_469) resistor r=4.16253
    rnet11_1534 (net11_412 net11_433) resistor r=24.8333
    rnet11_1533 (net11_412 net11_430) resistor r=24.8333
    rnet11_1532 (net11_412 net11_441) resistor r=24.8333
    rnet11_1531 (net11_412 net11_438) resistor r=24.8333
    rnet11_1530 (net11_412 net11_2594) resistor r=40.975
    rnet11_1529 (net11_412 net11_460) resistor r=14.9
    rnet11_1528 (net11_412 net11_466) resistor r=202.392
    rnet11_1527 (net11_412 MM39_ELT_g) resistor r=7.45
    rnet11_1526 (net11_412 net11_433) resistor r=4.16253
    rnet11_1525 (net11_412 net11_441) resistor r=4.16253
    rnet11_1524 (net11_412 net11_466) resistor r=6.30933
    rnet11_1523 (net11_412 net11_460) resistor r=6.30933
    rnet11_1522 (net11_412 net11_430) resistor r=1.63969
    rnet11_1521 (net11_412 net11_438) resistor r=4.16253
    rnet11_1520 (net11_412 net11_469) resistor r=4.16253
    rnet11_1519 (net11_449 MM31_ELT_g) resistor r=36.0083
    rnet11_1518 (net11_469 MM39_ELT_g) resistor r=194.942
    rnet11_1517 (net11_474 net11_480) resistor r=58.3583
    rnet11_1516 (net11_474 net11_480) resistor r=4.16253
    rnet11_1515 (net11_474 net11_480) resistor r=58.3583
    rnet11_1514 (net11_474 net11_480) resistor r=4.16253
    rnet11_1513 (net11_477 net11_480) resistor r=58.3583
    rnet11_1512 (net11_477 net11_480) resistor r=6.30933
    rnet11_1511 (net11_477 net11_480) resistor r=58.3583
    rnet11_1510 (net11_477 net11_480) resistor r=6.30933
    rnet11_1509 (net11_480 net11_482) resistor r=14.9
    rnet11_1508 (net11_480 net11_505) resistor r=24.8333
    rnet11_1507 (net11_480 net11_502) resistor r=24.8333
    rnet11_1506 (net11_480 net11_513) resistor r=24.8333
    rnet11_1505 (net11_480 net11_510) resistor r=24.8333
    rnet11_1504 (net11_480 net11_534) resistor r=58.3583
    rnet11_1503 (net11_480 net11_537) resistor r=58.3583
    rnet11_1502 (net11_480 net11_505) resistor r=4.16253
    rnet11_1501 (net11_480 net11_482) resistor r=6.30933
    rnet11_1500 (net11_480 net11_513) resistor r=1.63969
    rnet11_1499 (net11_480 net11_502) resistor r=4.16253
    rnet11_1498 (net11_480 net11_534) resistor r=4.16253
    rnet11_1497 (net11_480 net11_510) resistor r=4.16253
    rnet11_1496 (net11_480 net11_537) resistor r=4.16253
    rnet11_1495 (net11_480 net11_482) resistor r=14.9
    rnet11_1494 (net11_480 net11_2606) resistor r=40.975
    rnet11_1493 (net11_480 net11_505) resistor r=24.8333
    rnet11_1492 (net11_480 net11_502) resistor r=24.8333
    rnet11_1491 (net11_480 net11_513) resistor r=24.8333
    rnet11_1490 (net11_480 net11_510) resistor r=24.8333
    rnet11_1489 (net11_480 net11_534) resistor r=58.3583
    rnet11_1488 (net11_480 MM30_ELT_g) resistor r=7.45
    rnet11_1487 (net11_480 net11_505) resistor r=4.16253
    rnet11_1486 (net11_480 net11_482) resistor r=6.30933
    rnet11_1485 (net11_480 net11_513) resistor r=1.63969
    rnet11_1484 (net11_480 net11_502) resistor r=4.16253
    rnet11_1483 (net11_480 net11_534) resistor r=4.16253
    rnet11_1482 (net11_480 net11_510) resistor r=4.16253
    rnet11_1481 (net11_480 net11_537) resistor r=4.16253
    rnet11_1480 (net11_488 net11_491) resistor r=14.9
    rnet11_1479 (net11_488 net11_491) resistor r=6.30933
    rnet11_1478 (net11_488 net11_491) resistor r=14.9
    rnet11_1477 (net11_488 net11_491) resistor r=6.30933
    rnet11_1476 (net11_491 net11_494) resistor r=202.392
    rnet11_1475 (net11_491 net11_497) resistor r=202.392
    rnet11_1474 (net11_491 net11_521) resistor r=24.8333
    rnet11_1473 (net11_491 net11_518) resistor r=24.8333
    rnet11_1472 (net11_491 net11_529) resistor r=24.8333
    rnet11_1471 (net11_491 net11_526) resistor r=24.8333
    rnet11_1470 (net11_491 net11_542) resistor r=202.392
    rnet11_1469 (net11_491 net11_545) resistor r=202.392
    rnet11_1468 (net11_491 net11_494) resistor r=6.30933
    rnet11_1467 (net11_491 net11_521) resistor r=1.63969
    rnet11_1466 (net11_491 net11_529) resistor r=4.16253
    rnet11_1465 (net11_491 net11_497) resistor r=4.16253
    rnet11_1464 (net11_491 net11_518) resistor r=4.16253
    rnet11_1463 (net11_491 net11_542) resistor r=4.16253
    rnet11_1462 (net11_491 net11_526) resistor r=4.16253
    rnet11_1461 (net11_491 net11_545) resistor r=4.16253
    rnet11_1460 (net11_491 net11_2608) resistor r=40.975
    rnet11_1459 (net11_491 net11_494) resistor r=202.392
    rnet11_1458 (net11_491 net11_497) resistor r=202.392
    rnet11_1457 (net11_491 net11_521) resistor r=24.8333
    rnet11_1456 (net11_491 net11_518) resistor r=24.8333
    rnet11_1455 (net11_491 net11_529) resistor r=24.8333
    rnet11_1454 (net11_491 net11_526) resistor r=24.8333
    rnet11_1453 (net11_491 net11_542) resistor r=202.392
    rnet11_1452 (net11_491 MM38_ELT_g) resistor r=7.45
    rnet11_1451 (net11_491 net11_494) resistor r=6.30933
    rnet11_1450 (net11_491 net11_521) resistor r=1.63969
    rnet11_1449 (net11_491 net11_529) resistor r=4.16253
    rnet11_1448 (net11_491 net11_497) resistor r=4.16253
    rnet11_1447 (net11_491 net11_518) resistor r=4.16253
    rnet11_1446 (net11_491 net11_542) resistor r=4.16253
    rnet11_1445 (net11_491 net11_526) resistor r=4.16253
    rnet11_1444 (net11_491 net11_545) resistor r=4.16253
    rnet11_1443 (net11_537 MM30_ELT_g) resistor r=50.9083
    rnet11_1442 (net11_545 MM38_ELT_g) resistor r=194.942
    rnet11_1441 (net11_550 net11_556) resistor r=58.3583
    rnet11_1440 (net11_550 net11_556) resistor r=4.16253
    rnet11_1439 (net11_550 net11_556) resistor r=58.3583
    rnet11_1438 (net11_550 net11_556) resistor r=4.16253
    rnet11_1437 (net11_553 net11_556) resistor r=58.3583
    rnet11_1436 (net11_553 net11_556) resistor r=4.16253
    rnet11_1435 (net11_553 net11_556) resistor r=58.3583
    rnet11_1434 (net11_553 net11_556) resistor r=4.16253
    rnet11_1433 (net11_556 net11_569) resistor r=24.8333
    rnet11_1432 (net11_556 net11_566) resistor r=24.8333
    rnet11_1431 (net11_556 net11_577) resistor r=24.8333
    rnet11_1430 (net11_556 net11_574) resistor r=24.8333
    rnet11_1429 (net11_556 net11_598) resistor r=58.3583
    rnet11_1428 (net11_556 net11_601) resistor r=58.3583
    rnet11_1427 (net11_556 net11_606) resistor r=14.9
    rnet11_1426 (net11_556 net11_569) resistor r=4.16253
    rnet11_1425 (net11_556 net11_577) resistor r=4.16253
    rnet11_1424 (net11_556 net11_566) resistor r=4.16253
    rnet11_1423 (net11_556 net11_598) resistor r=4.16253
    rnet11_1422 (net11_556 net11_606) resistor r=6.30933
    rnet11_1421 (net11_556 net11_601) resistor r=6.30933
    rnet11_1420 (net11_556 net11_574) resistor r=1.63969
    rnet11_1419 (net11_556 net11_569) resistor r=24.8333
    rnet11_1418 (net11_556 net11_566) resistor r=24.8333
    rnet11_1417 (net11_556 net11_577) resistor r=24.8333
    rnet11_1416 (net11_556 net11_574) resistor r=24.8333
    rnet11_1415 (net11_556 net11_598) resistor r=58.3583
    rnet11_1414 (net11_556 MM29_ELT_g) resistor r=22.35
    rnet11_1413 (net11_556 net11_606) resistor r=14.9
    rnet11_1412 (net11_556 net11_2660) resistor r=40.975
    rnet11_1411 (net11_556 net11_569) resistor r=4.16253
    rnet11_1410 (net11_556 net11_577) resistor r=4.16253
    rnet11_1409 (net11_556 net11_566) resistor r=4.16253
    rnet11_1408 (net11_556 net11_598) resistor r=4.16253
    rnet11_1407 (net11_556 net11_606) resistor r=6.30933
    rnet11_1406 (net11_556 net11_601) resistor r=6.30933
    rnet11_1405 (net11_556 net11_574) resistor r=1.63969
    rnet11_1404 (net11_558 net11_564) resistor r=202.392
    rnet11_1403 (net11_558 net11_564) resistor r=4.16253
    rnet11_1402 (net11_558 net11_564) resistor r=202.392
    rnet11_1401 (net11_558 net11_564) resistor r=4.16253
    rnet11_1400 (net11_561 net11_564) resistor r=202.392
    rnet11_1399 (net11_561 net11_564) resistor r=4.16253
    rnet11_1398 (net11_561 net11_564) resistor r=202.392
    rnet11_1397 (net11_561 net11_564) resistor r=4.16253
    rnet11_1396 (net11_564 net11_585) resistor r=24.8333
    rnet11_1395 (net11_564 net11_582) resistor r=24.8333
    rnet11_1394 (net11_564 net11_593) resistor r=24.8333
    rnet11_1393 (net11_564 net11_590) resistor r=24.8333
    rnet11_1392 (net11_564 net11_612) resistor r=14.9
    rnet11_1391 (net11_564 net11_618) resistor r=202.392
    rnet11_1390 (net11_564 net11_621) resistor r=202.392
    rnet11_1389 (net11_564 net11_585) resistor r=4.16253
    rnet11_1388 (net11_564 net11_593) resistor r=4.16253
    rnet11_1387 (net11_564 net11_618) resistor r=6.30933
    rnet11_1386 (net11_564 net11_612) resistor r=6.30933
    rnet11_1385 (net11_564 net11_582) resistor r=1.63969
    rnet11_1384 (net11_564 net11_590) resistor r=4.16253
    rnet11_1383 (net11_564 net11_621) resistor r=4.16253
    rnet11_1382 (net11_564 net11_585) resistor r=24.8333
    rnet11_1381 (net11_564 net11_582) resistor r=24.8333
    rnet11_1380 (net11_564 net11_593) resistor r=24.8333
    rnet11_1379 (net11_564 net11_590) resistor r=24.8333
    rnet11_1378 (net11_564 net11_2662) resistor r=40.975
    rnet11_1377 (net11_564 net11_612) resistor r=14.9
    rnet11_1376 (net11_564 net11_618) resistor r=202.392
    rnet11_1375 (net11_564 MM37_ELT_g) resistor r=7.45
    rnet11_1374 (net11_564 net11_585) resistor r=4.16253
    rnet11_1373 (net11_564 net11_593) resistor r=4.16253
    rnet11_1372 (net11_564 net11_618) resistor r=6.30933
    rnet11_1371 (net11_564 net11_612) resistor r=6.30933
    rnet11_1370 (net11_564 net11_582) resistor r=1.63969
    rnet11_1369 (net11_564 net11_590) resistor r=4.16253
    rnet11_1368 (net11_564 net11_621) resistor r=4.16253
    rnet11_1367 (net11_601 MM29_ELT_g) resistor r=36.0083
    rnet11_1366 (net11_621 MM37_ELT_g) resistor r=194.942
    rnet11_1365 (net11_626 net11_632) resistor r=58.3583
    rnet11_1364 (net11_626 net11_632) resistor r=4.16253
    rnet11_1363 (net11_626 net11_632) resistor r=58.3583
    rnet11_1362 (net11_626 net11_632) resistor r=4.16253
    rnet11_1361 (net11_629 net11_632) resistor r=58.3583
    rnet11_1360 (net11_629 net11_632) resistor r=6.30933
    rnet11_1359 (net11_629 net11_632) resistor r=58.3583
    rnet11_1358 (net11_629 net11_632) resistor r=6.30933
    rnet11_1357 (net11_632 net11_634) resistor r=14.9
    rnet11_1356 (net11_632 net11_657) resistor r=24.8333
    rnet11_1355 (net11_632 net11_654) resistor r=24.8333
    rnet11_1354 (net11_632 net11_665) resistor r=24.8333
    rnet11_1353 (net11_632 net11_662) resistor r=24.8333
    rnet11_1352 (net11_632 net11_686) resistor r=58.3583
    rnet11_1351 (net11_632 net11_689) resistor r=58.3583
    rnet11_1350 (net11_632 net11_657) resistor r=4.16253
    rnet11_1349 (net11_632 net11_634) resistor r=6.30933
    rnet11_1348 (net11_632 net11_665) resistor r=1.63969
    rnet11_1347 (net11_632 net11_654) resistor r=4.16253
    rnet11_1346 (net11_632 net11_686) resistor r=4.16253
    rnet11_1345 (net11_632 net11_662) resistor r=4.16253
    rnet11_1344 (net11_632 net11_689) resistor r=4.16253
    rnet11_1343 (net11_632 net11_634) resistor r=14.9
    rnet11_1342 (net11_632 net11_2676) resistor r=40.975
    rnet11_1341 (net11_632 net11_657) resistor r=24.8333
    rnet11_1340 (net11_632 net11_654) resistor r=24.8333
    rnet11_1339 (net11_632 net11_665) resistor r=24.8333
    rnet11_1338 (net11_632 net11_662) resistor r=24.8333
    rnet11_1337 (net11_632 net11_686) resistor r=58.3583
    rnet11_1336 (net11_632 MM28_ELT_g) resistor r=7.45
    rnet11_1335 (net11_632 net11_657) resistor r=4.16253
    rnet11_1334 (net11_632 net11_634) resistor r=6.30933
    rnet11_1333 (net11_632 net11_665) resistor r=1.63969
    rnet11_1332 (net11_632 net11_654) resistor r=4.16253
    rnet11_1331 (net11_632 net11_686) resistor r=4.16253
    rnet11_1330 (net11_632 net11_662) resistor r=4.16253
    rnet11_1329 (net11_632 net11_689) resistor r=4.16253
    rnet11_1328 (net11_640 net11_643) resistor r=14.9
    rnet11_1327 (net11_640 net11_643) resistor r=6.30933
    rnet11_1326 (net11_640 net11_643) resistor r=14.9
    rnet11_1325 (net11_640 net11_643) resistor r=6.30933
    rnet11_1324 (net11_643 net11_646) resistor r=202.392
    rnet11_1323 (net11_643 net11_649) resistor r=202.392
    rnet11_1322 (net11_643 net11_673) resistor r=24.8333
    rnet11_1321 (net11_643 net11_670) resistor r=24.8333
    rnet11_1320 (net11_643 net11_681) resistor r=24.8333
    rnet11_1319 (net11_643 net11_678) resistor r=24.8333
    rnet11_1318 (net11_643 net11_694) resistor r=202.392
    rnet11_1317 (net11_643 net11_697) resistor r=202.392
    rnet11_1316 (net11_643 net11_646) resistor r=6.30933
    rnet11_1315 (net11_643 net11_673) resistor r=1.63969
    rnet11_1314 (net11_643 net11_681) resistor r=4.16253
    rnet11_1313 (net11_643 net11_649) resistor r=4.16253
    rnet11_1312 (net11_643 net11_670) resistor r=4.16253
    rnet11_1311 (net11_643 net11_694) resistor r=4.16253
    rnet11_1310 (net11_643 net11_678) resistor r=4.16253
    rnet11_1309 (net11_643 net11_697) resistor r=4.16253
    rnet11_1308 (net11_643 net11_2678) resistor r=40.975
    rnet11_1307 (net11_643 net11_646) resistor r=202.392
    rnet11_1306 (net11_643 net11_649) resistor r=202.392
    rnet11_1305 (net11_643 net11_673) resistor r=24.8333
    rnet11_1304 (net11_643 net11_670) resistor r=24.8333
    rnet11_1303 (net11_643 net11_681) resistor r=24.8333
    rnet11_1302 (net11_643 net11_678) resistor r=24.8333
    rnet11_1301 (net11_643 net11_694) resistor r=202.392
    rnet11_1300 (net11_643 MM36_ELT_g) resistor r=7.45
    rnet11_1299 (net11_643 net11_646) resistor r=6.30933
    rnet11_1298 (net11_643 net11_673) resistor r=1.63969
    rnet11_1297 (net11_643 net11_681) resistor r=4.16253
    rnet11_1296 (net11_643 net11_649) resistor r=4.16253
    rnet11_1295 (net11_643 net11_670) resistor r=4.16253
    rnet11_1294 (net11_643 net11_694) resistor r=4.16253
    rnet11_1293 (net11_643 net11_678) resistor r=4.16253
    rnet11_1292 (net11_643 net11_697) resistor r=4.16253
    rnet11_1291 (net11_689 MM28_ELT_g) resistor r=50.9083
    rnet11_1290 (net11_697 MM36_ELT_g) resistor r=194.942
    rnet11_1289 (net11_702 net11_708) resistor r=58.3583
    rnet11_1288 (net11_702 net11_708) resistor r=4.16253
    rnet11_1287 (net11_702 net11_708) resistor r=58.3583
    rnet11_1286 (net11_702 net11_708) resistor r=4.16253
    rnet11_1285 (net11_705 net11_708) resistor r=58.3583
    rnet11_1284 (net11_705 net11_708) resistor r=4.16253
    rnet11_1283 (net11_705 net11_708) resistor r=58.3583
    rnet11_1282 (net11_705 net11_708) resistor r=4.16253
    rnet11_1281 (net11_708 net11_721) resistor r=24.8333
    rnet11_1280 (net11_708 net11_718) resistor r=24.8333
    rnet11_1279 (net11_708 net11_729) resistor r=24.8333
    rnet11_1278 (net11_708 net11_726) resistor r=24.8333
    rnet11_1277 (net11_708 net11_750) resistor r=58.3583
    rnet11_1276 (net11_708 net11_753) resistor r=58.3583
    rnet11_1275 (net11_708 net11_758) resistor r=14.9
    rnet11_1274 (net11_708 net11_721) resistor r=4.16253
    rnet11_1273 (net11_708 net11_729) resistor r=4.16253
    rnet11_1272 (net11_708 net11_718) resistor r=4.16253
    rnet11_1271 (net11_708 net11_750) resistor r=4.16253
    rnet11_1270 (net11_708 net11_758) resistor r=6.30933
    rnet11_1269 (net11_708 net11_753) resistor r=6.30933
    rnet11_1268 (net11_708 net11_726) resistor r=1.63969
    rnet11_1267 (net11_708 net11_721) resistor r=24.8333
    rnet11_1266 (net11_708 net11_718) resistor r=24.8333
    rnet11_1265 (net11_708 net11_729) resistor r=24.8333
    rnet11_1264 (net11_708 net11_726) resistor r=24.8333
    rnet11_1263 (net11_708 net11_750) resistor r=58.3583
    rnet11_1262 (net11_708 MM27_ELT_g) resistor r=22.35
    rnet11_1261 (net11_708 net11_758) resistor r=14.9
    rnet11_1260 (net11_708 net11_2730) resistor r=40.975
    rnet11_1259 (net11_708 net11_721) resistor r=4.16253
    rnet11_1258 (net11_708 net11_729) resistor r=4.16253
    rnet11_1257 (net11_708 net11_718) resistor r=4.16253
    rnet11_1256 (net11_708 net11_750) resistor r=4.16253
    rnet11_1255 (net11_708 net11_758) resistor r=6.30933
    rnet11_1254 (net11_708 net11_753) resistor r=6.30933
    rnet11_1253 (net11_708 net11_726) resistor r=1.63969
    rnet11_1252 (net11_710 net11_716) resistor r=202.392
    rnet11_1251 (net11_710 net11_716) resistor r=4.16253
    rnet11_1250 (net11_710 net11_716) resistor r=202.392
    rnet11_1249 (net11_710 net11_716) resistor r=4.16253
    rnet11_1248 (net11_713 net11_716) resistor r=202.392
    rnet11_1247 (net11_713 net11_716) resistor r=4.16253
    rnet11_1246 (net11_713 net11_716) resistor r=202.392
    rnet11_1245 (net11_713 net11_716) resistor r=4.16253
    rnet11_1244 (net11_716 net11_737) resistor r=24.8333
    rnet11_1243 (net11_716 net11_734) resistor r=24.8333
    rnet11_1242 (net11_716 net11_745) resistor r=24.8333
    rnet11_1241 (net11_716 net11_742) resistor r=24.8333
    rnet11_1240 (net11_716 net11_764) resistor r=14.9
    rnet11_1239 (net11_716 net11_770) resistor r=202.392
    rnet11_1238 (net11_716 net11_773) resistor r=202.392
    rnet11_1237 (net11_716 net11_737) resistor r=4.16253
    rnet11_1236 (net11_716 net11_745) resistor r=4.16253
    rnet11_1235 (net11_716 net11_770) resistor r=6.30933
    rnet11_1234 (net11_716 net11_764) resistor r=6.30933
    rnet11_1233 (net11_716 net11_734) resistor r=1.63969
    rnet11_1232 (net11_716 net11_742) resistor r=4.16253
    rnet11_1231 (net11_716 net11_773) resistor r=4.16253
    rnet11_1230 (net11_716 net11_737) resistor r=24.8333
    rnet11_1229 (net11_716 net11_734) resistor r=24.8333
    rnet11_1228 (net11_716 net11_745) resistor r=24.8333
    rnet11_1227 (net11_716 net11_742) resistor r=24.8333
    rnet11_1226 (net11_716 net11_2732) resistor r=40.975
    rnet11_1225 (net11_716 net11_764) resistor r=14.9
    rnet11_1224 (net11_716 net11_770) resistor r=202.392
    rnet11_1223 (net11_716 MM35_ELT_g) resistor r=7.45
    rnet11_1222 (net11_716 net11_737) resistor r=4.16253
    rnet11_1221 (net11_716 net11_745) resistor r=4.16253
    rnet11_1220 (net11_716 net11_770) resistor r=6.30933
    rnet11_1219 (net11_716 net11_764) resistor r=6.30933
    rnet11_1218 (net11_716 net11_734) resistor r=1.63969
    rnet11_1217 (net11_716 net11_742) resistor r=4.16253
    rnet11_1216 (net11_716 net11_773) resistor r=4.16253
    rnet11_1215 (net11_753 MM27_ELT_g) resistor r=36.0083
    rnet11_1214 (net11_773 MM35_ELT_g) resistor r=194.942
    rnet11_1213 (net11_778 net11_784) resistor r=58.3583
    rnet11_1212 (net11_778 net11_784) resistor r=4.16253
    rnet11_1211 (net11_778 net11_784) resistor r=58.3583
    rnet11_1210 (net11_778 net11_784) resistor r=4.16253
    rnet11_1209 (net11_781 net11_784) resistor r=58.3583
    rnet11_1208 (net11_781 net11_784) resistor r=6.30933
    rnet11_1207 (net11_781 net11_784) resistor r=58.3583
    rnet11_1206 (net11_781 net11_784) resistor r=6.30933
    rnet11_1205 (net11_784 net11_786) resistor r=14.9
    rnet11_1204 (net11_784 net11_809) resistor r=24.8333
    rnet11_1203 (net11_784 net11_806) resistor r=24.8333
    rnet11_1202 (net11_784 net11_817) resistor r=24.8333
    rnet11_1201 (net11_784 net11_814) resistor r=24.8333
    rnet11_1200 (net11_784 net11_838) resistor r=58.3583
    rnet11_1199 (net11_784 net11_841) resistor r=58.3583
    rnet11_1198 (net11_784 net11_809) resistor r=4.16253
    rnet11_1197 (net11_784 net11_786) resistor r=6.30933
    rnet11_1196 (net11_784 net11_817) resistor r=1.63969
    rnet11_1195 (net11_784 net11_806) resistor r=4.16253
    rnet11_1194 (net11_784 net11_838) resistor r=4.16253
    rnet11_1193 (net11_784 net11_814) resistor r=4.16253
    rnet11_1192 (net11_784 net11_841) resistor r=4.16253
    rnet11_1191 (net11_784 net11_786) resistor r=14.9
    rnet11_1190 (net11_784 net11_2746) resistor r=40.975
    rnet11_1189 (net11_784 net11_809) resistor r=24.8333
    rnet11_1188 (net11_784 net11_806) resistor r=24.8333
    rnet11_1187 (net11_784 net11_817) resistor r=24.8333
    rnet11_1186 (net11_784 net11_814) resistor r=24.8333
    rnet11_1185 (net11_784 net11_838) resistor r=58.3583
    rnet11_1184 (net11_784 MM26_ELT_g) resistor r=7.45
    rnet11_1183 (net11_784 net11_809) resistor r=4.16253
    rnet11_1182 (net11_784 net11_786) resistor r=6.30933
    rnet11_1181 (net11_784 net11_817) resistor r=1.63969
    rnet11_1180 (net11_784 net11_806) resistor r=4.16253
    rnet11_1179 (net11_784 net11_838) resistor r=4.16253
    rnet11_1178 (net11_784 net11_814) resistor r=4.16253
    rnet11_1177 (net11_784 net11_841) resistor r=4.16253
    rnet11_1176 (net11_792 net11_795) resistor r=14.9
    rnet11_1175 (net11_792 net11_795) resistor r=6.30933
    rnet11_1174 (net11_792 net11_795) resistor r=14.9
    rnet11_1173 (net11_792 net11_795) resistor r=6.30933
    rnet11_1172 (net11_795 net11_798) resistor r=202.392
    rnet11_1171 (net11_795 net11_801) resistor r=202.392
    rnet11_1170 (net11_795 net11_825) resistor r=24.8333
    rnet11_1169 (net11_795 net11_822) resistor r=24.8333
    rnet11_1168 (net11_795 net11_833) resistor r=24.8333
    rnet11_1167 (net11_795 net11_830) resistor r=24.8333
    rnet11_1166 (net11_795 net11_846) resistor r=202.392
    rnet11_1165 (net11_795 net11_849) resistor r=202.392
    rnet11_1164 (net11_795 net11_798) resistor r=6.30933
    rnet11_1163 (net11_795 net11_825) resistor r=1.63969
    rnet11_1162 (net11_795 net11_833) resistor r=4.16253
    rnet11_1161 (net11_795 net11_801) resistor r=4.16253
    rnet11_1160 (net11_795 net11_822) resistor r=4.16253
    rnet11_1159 (net11_795 net11_846) resistor r=4.16253
    rnet11_1158 (net11_795 net11_830) resistor r=4.16253
    rnet11_1157 (net11_795 net11_849) resistor r=4.16253
    rnet11_1156 (net11_795 net11_2748) resistor r=40.975
    rnet11_1155 (net11_795 net11_798) resistor r=202.392
    rnet11_1154 (net11_795 net11_801) resistor r=202.392
    rnet11_1153 (net11_795 net11_825) resistor r=24.8333
    rnet11_1152 (net11_795 net11_822) resistor r=24.8333
    rnet11_1151 (net11_795 net11_833) resistor r=24.8333
    rnet11_1150 (net11_795 net11_830) resistor r=24.8333
    rnet11_1149 (net11_795 net11_846) resistor r=202.392
    rnet11_1148 (net11_795 MM34_ELT_g) resistor r=7.45
    rnet11_1147 (net11_795 net11_798) resistor r=6.30933
    rnet11_1146 (net11_795 net11_825) resistor r=1.63969
    rnet11_1145 (net11_795 net11_833) resistor r=4.16253
    rnet11_1144 (net11_795 net11_801) resistor r=4.16253
    rnet11_1143 (net11_795 net11_822) resistor r=4.16253
    rnet11_1142 (net11_795 net11_846) resistor r=4.16253
    rnet11_1141 (net11_795 net11_830) resistor r=4.16253
    rnet11_1140 (net11_795 net11_849) resistor r=4.16253
    rnet11_1139 (net11_841 MM26_ELT_g) resistor r=50.9083
    rnet11_1138 (net11_849 MM34_ELT_g) resistor r=194.942
    rnet11_1137 (net11_854 net11_860) resistor r=58.3583
    rnet11_1136 (net11_854 net11_860) resistor r=4.16253
    rnet11_1135 (net11_854 net11_860) resistor r=58.3583
    rnet11_1134 (net11_854 net11_860) resistor r=4.16253
    rnet11_1133 (net11_857 net11_860) resistor r=58.3583
    rnet11_1132 (net11_857 net11_860) resistor r=4.16253
    rnet11_1131 (net11_857 net11_860) resistor r=58.3583
    rnet11_1130 (net11_857 net11_860) resistor r=4.16253
    rnet11_1129 (net11_860 net11_873) resistor r=24.8333
    rnet11_1128 (net11_860 net11_870) resistor r=24.8333
    rnet11_1127 (net11_860 net11_881) resistor r=24.8333
    rnet11_1126 (net11_860 net11_878) resistor r=24.8333
    rnet11_1125 (net11_860 net11_902) resistor r=58.3583
    rnet11_1124 (net11_860 net11_905) resistor r=58.3583
    rnet11_1123 (net11_860 net11_910) resistor r=14.9
    rnet11_1122 (net11_860 net11_873) resistor r=4.16253
    rnet11_1121 (net11_860 net11_881) resistor r=4.16253
    rnet11_1120 (net11_860 net11_870) resistor r=4.16253
    rnet11_1119 (net11_860 net11_902) resistor r=4.16253
    rnet11_1118 (net11_860 net11_910) resistor r=6.30933
    rnet11_1117 (net11_860 net11_905) resistor r=6.30933
    rnet11_1116 (net11_860 net11_878) resistor r=1.63969
    rnet11_1115 (net11_860 net11_873) resistor r=24.8333
    rnet11_1114 (net11_860 net11_870) resistor r=24.8333
    rnet11_1113 (net11_860 net11_881) resistor r=24.8333
    rnet11_1112 (net11_860 net11_878) resistor r=24.8333
    rnet11_1111 (net11_860 net11_902) resistor r=58.3583
    rnet11_1110 (net11_860 MM25_ELT_g) resistor r=22.35
    rnet11_1109 (net11_860 net11_910) resistor r=14.9
    rnet11_1108 (net11_860 net11_2800) resistor r=40.975
    rnet11_1107 (net11_860 net11_873) resistor r=4.16253
    rnet11_1106 (net11_860 net11_881) resistor r=4.16253
    rnet11_1105 (net11_860 net11_870) resistor r=4.16253
    rnet11_1104 (net11_860 net11_902) resistor r=4.16253
    rnet11_1103 (net11_860 net11_910) resistor r=6.30933
    rnet11_1102 (net11_860 net11_905) resistor r=6.30933
    rnet11_1101 (net11_860 net11_878) resistor r=1.63969
    rnet11_1100 (net11_862 net11_868) resistor r=202.392
    rnet11_1099 (net11_862 net11_868) resistor r=4.16253
    rnet11_1098 (net11_862 net11_868) resistor r=202.392
    rnet11_1097 (net11_862 net11_868) resistor r=4.16253
    rnet11_1096 (net11_865 net11_868) resistor r=202.392
    rnet11_1095 (net11_865 net11_868) resistor r=4.16253
    rnet11_1094 (net11_865 net11_868) resistor r=202.392
    rnet11_1093 (net11_865 net11_868) resistor r=4.16253
    rnet11_1092 (net11_868 net11_889) resistor r=24.8333
    rnet11_1091 (net11_868 net11_886) resistor r=24.8333
    rnet11_1090 (net11_868 net11_897) resistor r=24.8333
    rnet11_1089 (net11_868 net11_894) resistor r=24.8333
    rnet11_1088 (net11_868 net11_916) resistor r=14.9
    rnet11_1087 (net11_868 net11_922) resistor r=202.392
    rnet11_1086 (net11_868 net11_925) resistor r=202.392
    rnet11_1085 (net11_868 net11_889) resistor r=4.16253
    rnet11_1084 (net11_868 net11_897) resistor r=4.16253
    rnet11_1083 (net11_868 net11_922) resistor r=6.30933
    rnet11_1082 (net11_868 net11_916) resistor r=6.30933
    rnet11_1081 (net11_868 net11_886) resistor r=1.63969
    rnet11_1080 (net11_868 net11_894) resistor r=4.16253
    rnet11_1079 (net11_868 net11_925) resistor r=4.16253
    rnet11_1078 (net11_868 net11_889) resistor r=24.8333
    rnet11_1077 (net11_868 net11_886) resistor r=24.8333
    rnet11_1076 (net11_868 net11_897) resistor r=24.8333
    rnet11_1075 (net11_868 net11_894) resistor r=24.8333
    rnet11_1074 (net11_868 net11_2802) resistor r=40.975
    rnet11_1073 (net11_868 net11_916) resistor r=14.9
    rnet11_1072 (net11_868 net11_922) resistor r=202.392
    rnet11_1071 (net11_868 MM33_ELT_g) resistor r=7.45
    rnet11_1070 (net11_868 net11_889) resistor r=4.16253
    rnet11_1069 (net11_868 net11_897) resistor r=4.16253
    rnet11_1068 (net11_868 net11_922) resistor r=6.30933
    rnet11_1067 (net11_868 net11_916) resistor r=6.30933
    rnet11_1066 (net11_868 net11_886) resistor r=1.63969
    rnet11_1065 (net11_868 net11_894) resistor r=4.16253
    rnet11_1064 (net11_868 net11_925) resistor r=4.16253
    rnet11_1063 (net11_905 MM25_ELT_g) resistor r=36.0083
    rnet11_1062 (net11_925 MM33_ELT_g) resistor r=194.942
    rnet11_1061 (net11_930 net11_936) resistor r=58.3583
    rnet11_1060 (net11_930 net11_936) resistor r=4.16253
    rnet11_1059 (net11_930 net11_936) resistor r=58.3583
    rnet11_1058 (net11_930 net11_936) resistor r=4.16253
    rnet11_1057 (net11_933 net11_936) resistor r=58.3583
    rnet11_1056 (net11_933 net11_936) resistor r=6.30933
    rnet11_1055 (net11_933 net11_936) resistor r=58.3583
    rnet11_1054 (net11_933 net11_936) resistor r=6.30933
    rnet11_1053 (net11_936 net11_938) resistor r=14.9
    rnet11_1052 (net11_936 net11_961) resistor r=24.8333
    rnet11_1051 (net11_936 net11_958) resistor r=24.8333
    rnet11_1050 (net11_936 net11_969) resistor r=24.8333
    rnet11_1049 (net11_936 net11_966) resistor r=24.8333
    rnet11_1048 (net11_936 net11_990) resistor r=58.3583
    rnet11_1047 (net11_936 net11_993) resistor r=58.3583
    rnet11_1046 (net11_936 net11_961) resistor r=4.16253
    rnet11_1045 (net11_936 net11_938) resistor r=6.30933
    rnet11_1044 (net11_936 net11_969) resistor r=1.63969
    rnet11_1043 (net11_936 net11_958) resistor r=4.16253
    rnet11_1042 (net11_936 net11_990) resistor r=4.16253
    rnet11_1041 (net11_936 net11_966) resistor r=4.16253
    rnet11_1040 (net11_936 net11_993) resistor r=4.16253
    rnet11_1039 (net11_936 net11_938) resistor r=14.9
    rnet11_1038 (net11_936 net11_2816) resistor r=40.975
    rnet11_1037 (net11_936 net11_961) resistor r=24.8333
    rnet11_1036 (net11_936 net11_958) resistor r=24.8333
    rnet11_1035 (net11_936 net11_969) resistor r=24.8333
    rnet11_1034 (net11_936 net11_966) resistor r=24.8333
    rnet11_1033 (net11_936 net11_990) resistor r=58.3583
    rnet11_1032 (net11_936 MM19_ELT_g) resistor r=7.45
    rnet11_1031 (net11_936 net11_961) resistor r=4.16253
    rnet11_1030 (net11_936 net11_938) resistor r=6.30933
    rnet11_1029 (net11_936 net11_969) resistor r=1.63969
    rnet11_1028 (net11_936 net11_958) resistor r=4.16253
    rnet11_1027 (net11_936 net11_990) resistor r=4.16253
    rnet11_1026 (net11_936 net11_966) resistor r=4.16253
    rnet11_1025 (net11_936 net11_993) resistor r=4.16253
    rnet11_1024 (net11_944 net11_947) resistor r=14.9
    rnet11_1023 (net11_944 net11_947) resistor r=6.30933
    rnet11_1022 (net11_944 net11_947) resistor r=14.9
    rnet11_1021 (net11_944 net11_947) resistor r=6.30933
    rnet11_1020 (net11_947 net11_950) resistor r=202.392
    rnet11_1019 (net11_947 net11_953) resistor r=202.392
    rnet11_1018 (net11_947 net11_977) resistor r=24.8333
    rnet11_1017 (net11_947 net11_974) resistor r=24.8333
    rnet11_1016 (net11_947 net11_985) resistor r=24.8333
    rnet11_1015 (net11_947 net11_982) resistor r=24.8333
    rnet11_1014 (net11_947 net11_998) resistor r=202.392
    rnet11_1013 (net11_947 net11_1001) resistor r=202.392
    rnet11_1012 (net11_947 net11_950) resistor r=6.30933
    rnet11_1011 (net11_947 net11_977) resistor r=1.63969
    rnet11_1010 (net11_947 net11_985) resistor r=4.16253
    rnet11_1009 (net11_947 net11_953) resistor r=4.16253
    rnet11_1008 (net11_947 net11_974) resistor r=4.16253
    rnet11_1007 (net11_947 net11_998) resistor r=4.16253
    rnet11_1006 (net11_947 net11_982) resistor r=4.16253
    rnet11_1005 (net11_947 net11_1001) resistor r=4.16253
    rnet11_1004 (net11_947 net11_2818) resistor r=40.975
    rnet11_1003 (net11_947 net11_950) resistor r=202.392
    rnet11_1002 (net11_947 net11_953) resistor r=202.392
    rnet11_1001 (net11_947 net11_977) resistor r=24.8333
    rnet11_1000 (net11_947 net11_974) resistor r=24.8333
    rnet11_999 (net11_947 net11_985) resistor r=24.8333
    rnet11_998 (net11_947 net11_982) resistor r=24.8333
    rnet11_997 (net11_947 net11_998) resistor r=202.392
    rnet11_996 (net11_947 MM20_ELT_g) resistor r=7.45
    rnet11_995 (net11_947 net11_950) resistor r=6.30933
    rnet11_994 (net11_947 net11_977) resistor r=1.63969
    rnet11_993 (net11_947 net11_985) resistor r=4.16253
    rnet11_992 (net11_947 net11_953) resistor r=4.16253
    rnet11_991 (net11_947 net11_974) resistor r=4.16253
    rnet11_990 (net11_947 net11_998) resistor r=4.16253
    rnet11_989 (net11_947 net11_982) resistor r=4.16253
    rnet11_988 (net11_947 net11_1001) resistor r=4.16253
    rnet11_987 (net11_993 MM19_ELT_g) resistor r=50.9083
    rnet11_986 (net11_1001 MM20_ELT_g) resistor r=194.942
    rnet11_985 (net11_1006 net11_1012) resistor r=58.3583
    rnet11_984 (net11_1006 net11_1012) resistor r=4.16253
    rnet11_983 (net11_1006 net11_1012) resistor r=58.3583
    rnet11_982 (net11_1006 net11_1012) resistor r=4.16253
    rnet11_981 (net11_1009 net11_1012) resistor r=58.3583
    rnet11_980 (net11_1009 net11_1012) resistor r=4.16253
    rnet11_979 (net11_1009 net11_1012) resistor r=58.3583
    rnet11_978 (net11_1009 net11_1012) resistor r=4.16253
    rnet11_977 (net11_1012 net11_1025) resistor r=24.8333
    rnet11_976 (net11_1012 net11_1022) resistor r=24.8333
    rnet11_975 (net11_1012 net11_1033) resistor r=24.8333
    rnet11_974 (net11_1012 net11_1030) resistor r=24.8333
    rnet11_973 (net11_1012 net11_1054) resistor r=58.3583
    rnet11_972 (net11_1012 net11_1057) resistor r=58.3583
    rnet11_971 (net11_1012 net11_1062) resistor r=14.9
    rnet11_970 (net11_1012 net11_1025) resistor r=4.16253
    rnet11_969 (net11_1012 net11_1033) resistor r=4.16253
    rnet11_968 (net11_1012 net11_1022) resistor r=4.16253
    rnet11_967 (net11_1012 net11_1054) resistor r=4.16253
    rnet11_966 (net11_1012 net11_1062) resistor r=6.30933
    rnet11_965 (net11_1012 net11_1057) resistor r=6.30933
    rnet11_964 (net11_1012 net11_1030) resistor r=1.63969
    rnet11_963 (net11_1012 net11_1025) resistor r=24.8333
    rnet11_962 (net11_1012 net11_1022) resistor r=24.8333
    rnet11_961 (net11_1012 net11_1033) resistor r=24.8333
    rnet11_960 (net11_1012 net11_1030) resistor r=24.8333
    rnet11_959 (net11_1012 net11_1054) resistor r=58.3583
    rnet11_958 (net11_1012 MM18_ELT_g) resistor r=22.35
    rnet11_957 (net11_1012 net11_1062) resistor r=14.9
    rnet11_956 (net11_1012 net11_2870) resistor r=40.975
    rnet11_955 (net11_1012 net11_1025) resistor r=4.16253
    rnet11_954 (net11_1012 net11_1033) resistor r=4.16253
    rnet11_953 (net11_1012 net11_1022) resistor r=4.16253
    rnet11_952 (net11_1012 net11_1054) resistor r=4.16253
    rnet11_951 (net11_1012 net11_1062) resistor r=6.30933
    rnet11_950 (net11_1012 net11_1057) resistor r=6.30933
    rnet11_949 (net11_1012 net11_1030) resistor r=1.63969
    rnet11_948 (net11_1014 net11_1020) resistor r=202.392
    rnet11_947 (net11_1014 net11_1020) resistor r=4.16253
    rnet11_946 (net11_1014 net11_1020) resistor r=202.392
    rnet11_945 (net11_1014 net11_1020) resistor r=4.16253
    rnet11_944 (net11_1017 net11_1020) resistor r=202.392
    rnet11_943 (net11_1017 net11_1020) resistor r=4.16253
    rnet11_942 (net11_1017 net11_1020) resistor r=202.392
    rnet11_941 (net11_1017 net11_1020) resistor r=4.16253
    rnet11_940 (net11_1020 net11_1041) resistor r=24.8333
    rnet11_939 (net11_1020 net11_1038) resistor r=24.8333
    rnet11_938 (net11_1020 net11_1049) resistor r=24.8333
    rnet11_937 (net11_1020 net11_1046) resistor r=24.8333
    rnet11_936 (net11_1020 net11_1068) resistor r=14.9
    rnet11_935 (net11_1020 net11_1074) resistor r=202.392
    rnet11_934 (net11_1020 net11_1077) resistor r=202.392
    rnet11_933 (net11_1020 net11_1041) resistor r=4.16253
    rnet11_932 (net11_1020 net11_1049) resistor r=4.16253
    rnet11_931 (net11_1020 net11_1074) resistor r=6.30933
    rnet11_930 (net11_1020 net11_1068) resistor r=6.30933
    rnet11_929 (net11_1020 net11_1038) resistor r=1.63969
    rnet11_928 (net11_1020 net11_1046) resistor r=4.16253
    rnet11_927 (net11_1020 net11_1077) resistor r=4.16253
    rnet11_926 (net11_1020 net11_1041) resistor r=24.8333
    rnet11_925 (net11_1020 net11_1038) resistor r=24.8333
    rnet11_924 (net11_1020 net11_1049) resistor r=24.8333
    rnet11_923 (net11_1020 net11_1046) resistor r=24.8333
    rnet11_922 (net11_1020 net11_2872) resistor r=40.975
    rnet11_921 (net11_1020 net11_1068) resistor r=14.9
    rnet11_920 (net11_1020 net11_1074) resistor r=202.392
    rnet11_919 (net11_1020 MM17_ELT_g) resistor r=7.45
    rnet11_918 (net11_1020 net11_1041) resistor r=4.16253
    rnet11_917 (net11_1020 net11_1049) resistor r=4.16253
    rnet11_916 (net11_1020 net11_1074) resistor r=6.30933
    rnet11_915 (net11_1020 net11_1068) resistor r=6.30933
    rnet11_914 (net11_1020 net11_1038) resistor r=1.63969
    rnet11_913 (net11_1020 net11_1046) resistor r=4.16253
    rnet11_912 (net11_1020 net11_1077) resistor r=4.16253
    rnet11_911 (net11_1057 MM18_ELT_g) resistor r=36.0083
    rnet11_910 (net11_1077 MM17_ELT_g) resistor r=194.942
    rnet11_909 (net11_1082 net11_1088) resistor r=58.3583
