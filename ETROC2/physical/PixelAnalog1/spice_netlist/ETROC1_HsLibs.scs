    rnet11_908 (net11_1082 net11_1088) resistor r=4.16253
    rnet11_907 (net11_1082 net11_1088) resistor r=58.3583
    rnet11_906 (net11_1082 net11_1088) resistor r=4.16253
    rnet11_905 (net11_1085 net11_1088) resistor r=58.3583
    rnet11_904 (net11_1085 net11_1088) resistor r=6.30933
    rnet11_903 (net11_1085 net11_1088) resistor r=58.3583
    rnet11_902 (net11_1085 net11_1088) resistor r=6.30933
    rnet11_901 (net11_1088 net11_1090) resistor r=14.9
    rnet11_900 (net11_1088 net11_1113) resistor r=24.8333
    rnet11_899 (net11_1088 net11_1110) resistor r=24.8333
    rnet11_898 (net11_1088 net11_1121) resistor r=24.8333
    rnet11_897 (net11_1088 net11_1118) resistor r=24.8333
    rnet11_896 (net11_1088 net11_1142) resistor r=58.3583
    rnet11_895 (net11_1088 net11_1145) resistor r=58.3583
    rnet11_894 (net11_1088 net11_1113) resistor r=4.16253
    rnet11_893 (net11_1088 net11_1090) resistor r=6.30933
    rnet11_892 (net11_1088 net11_1121) resistor r=1.63969
    rnet11_891 (net11_1088 net11_1110) resistor r=4.16253
    rnet11_890 (net11_1088 net11_1142) resistor r=4.16253
    rnet11_889 (net11_1088 net11_1118) resistor r=4.16253
    rnet11_888 (net11_1088 net11_1145) resistor r=4.16253
    rnet11_887 (net11_1088 net11_1090) resistor r=14.9
    rnet11_886 (net11_1088 net11_2884) resistor r=40.975
    rnet11_885 (net11_1088 net11_1113) resistor r=24.8333
    rnet11_884 (net11_1088 net11_1110) resistor r=24.8333
    rnet11_883 (net11_1088 net11_1121) resistor r=24.8333
    rnet11_882 (net11_1088 net11_1118) resistor r=24.8333
    rnet11_881 (net11_1088 net11_1142) resistor r=58.3583
    rnet11_880 (net11_1088 MM16_ELT_g) resistor r=7.45
    rnet11_879 (net11_1088 net11_1113) resistor r=4.16253
    rnet11_878 (net11_1088 net11_1090) resistor r=6.30933
    rnet11_877 (net11_1088 net11_1121) resistor r=1.63969
    rnet11_876 (net11_1088 net11_1110) resistor r=4.16253
    rnet11_875 (net11_1088 net11_1142) resistor r=4.16253
    rnet11_874 (net11_1088 net11_1118) resistor r=4.16253
    rnet11_873 (net11_1088 net11_1145) resistor r=4.16253
    rnet11_872 (net11_1096 net11_1099) resistor r=14.9
    rnet11_871 (net11_1096 net11_1099) resistor r=6.30933
    rnet11_870 (net11_1096 net11_1099) resistor r=14.9
    rnet11_869 (net11_1096 net11_1099) resistor r=6.30933
    rnet11_868 (net11_1099 net11_1102) resistor r=202.392
    rnet11_867 (net11_1099 net11_1105) resistor r=202.392
    rnet11_866 (net11_1099 net11_1129) resistor r=24.8333
    rnet11_865 (net11_1099 net11_1126) resistor r=24.8333
    rnet11_864 (net11_1099 net11_1137) resistor r=24.8333
    rnet11_863 (net11_1099 net11_1134) resistor r=24.8333
    rnet11_862 (net11_1099 net11_1150) resistor r=202.392
    rnet11_861 (net11_1099 net11_1153) resistor r=202.392
    rnet11_860 (net11_1099 net11_1102) resistor r=6.30933
    rnet11_859 (net11_1099 net11_1129) resistor r=1.63969
    rnet11_858 (net11_1099 net11_1137) resistor r=4.16253
    rnet11_857 (net11_1099 net11_1105) resistor r=4.16253
    rnet11_856 (net11_1099 net11_1126) resistor r=4.16253
    rnet11_855 (net11_1099 net11_1150) resistor r=4.16253
    rnet11_854 (net11_1099 net11_1134) resistor r=4.16253
    rnet11_853 (net11_1099 net11_1153) resistor r=4.16253
    rnet11_852 (net11_1099 net11_2886) resistor r=40.975
    rnet11_851 (net11_1099 net11_1102) resistor r=202.392
    rnet11_850 (net11_1099 net11_1105) resistor r=202.392
    rnet11_849 (net11_1099 net11_1129) resistor r=24.8333
    rnet11_848 (net11_1099 net11_1126) resistor r=24.8333
    rnet11_847 (net11_1099 net11_1137) resistor r=24.8333
    rnet11_846 (net11_1099 net11_1134) resistor r=24.8333
    rnet11_845 (net11_1099 net11_1150) resistor r=202.392
    rnet11_844 (net11_1099 MM11_ELT_g) resistor r=7.45
    rnet11_843 (net11_1099 net11_1102) resistor r=6.30933
    rnet11_842 (net11_1099 net11_1129) resistor r=1.63969
    rnet11_841 (net11_1099 net11_1137) resistor r=4.16253
    rnet11_840 (net11_1099 net11_1105) resistor r=4.16253
    rnet11_839 (net11_1099 net11_1126) resistor r=4.16253
    rnet11_838 (net11_1099 net11_1150) resistor r=4.16253
    rnet11_837 (net11_1099 net11_1134) resistor r=4.16253
    rnet11_836 (net11_1099 net11_1153) resistor r=4.16253
    rnet11_835 (net11_1145 MM16_ELT_g) resistor r=50.9083
    rnet11_834 (net11_1153 MM11_ELT_g) resistor r=194.942
    rnet11_833 (net11_1158 net11_1164) resistor r=58.3583
    rnet11_832 (net11_1158 net11_1164) resistor r=4.16253
    rnet11_831 (net11_1158 net11_1164) resistor r=58.3583
    rnet11_830 (net11_1158 net11_1164) resistor r=4.16253
    rnet11_829 (net11_1161 net11_1164) resistor r=58.3583
    rnet11_828 (net11_1161 net11_1164) resistor r=4.16253
    rnet11_827 (net11_1161 net11_1164) resistor r=58.3583
    rnet11_826 (net11_1161 net11_1164) resistor r=4.16253
    rnet11_825 (net11_1164 net11_1177) resistor r=24.8333
    rnet11_824 (net11_1164 net11_1174) resistor r=24.8333
    rnet11_823 (net11_1164 net11_1185) resistor r=24.8333
    rnet11_822 (net11_1164 net11_1182) resistor r=24.8333
    rnet11_821 (net11_1164 net11_1206) resistor r=58.3583
    rnet11_820 (net11_1164 net11_1209) resistor r=58.3583
    rnet11_819 (net11_1164 net11_1214) resistor r=14.9
    rnet11_818 (net11_1164 net11_1177) resistor r=4.16253
    rnet11_817 (net11_1164 net11_1185) resistor r=4.16253
    rnet11_816 (net11_1164 net11_1174) resistor r=4.16253
    rnet11_815 (net11_1164 net11_1206) resistor r=4.16253
    rnet11_814 (net11_1164 net11_1214) resistor r=6.30933
    rnet11_813 (net11_1164 net11_1209) resistor r=6.30933
    rnet11_812 (net11_1164 net11_1182) resistor r=1.63969
    rnet11_811 (net11_1164 net11_1177) resistor r=24.8333
    rnet11_810 (net11_1164 net11_1174) resistor r=24.8333
    rnet11_809 (net11_1164 net11_1185) resistor r=24.8333
    rnet11_808 (net11_1164 net11_1182) resistor r=24.8333
    rnet11_807 (net11_1164 net11_1206) resistor r=58.3583
    rnet11_806 (net11_1164 MM10_ELT_g) resistor r=22.35
    rnet11_805 (net11_1164 net11_1214) resistor r=14.9
    rnet11_804 (net11_1164 net11_2938) resistor r=40.975
    rnet11_803 (net11_1164 net11_1177) resistor r=4.16253
    rnet11_802 (net11_1164 net11_1185) resistor r=4.16253
    rnet11_801 (net11_1164 net11_1174) resistor r=4.16253
    rnet11_800 (net11_1164 net11_1206) resistor r=4.16253
    rnet11_799 (net11_1164 net11_1214) resistor r=6.30933
    rnet11_798 (net11_1164 net11_1209) resistor r=6.30933
    rnet11_797 (net11_1164 net11_1182) resistor r=1.63969
    rnet11_796 (net11_1166 net11_1172) resistor r=202.392
    rnet11_795 (net11_1166 net11_1172) resistor r=4.16253
    rnet11_794 (net11_1166 net11_1172) resistor r=202.392
    rnet11_793 (net11_1166 net11_1172) resistor r=4.16253
    rnet11_792 (net11_1169 net11_1172) resistor r=202.392
    rnet11_791 (net11_1169 net11_1172) resistor r=4.16253
    rnet11_790 (net11_1169 net11_1172) resistor r=202.392
    rnet11_789 (net11_1169 net11_1172) resistor r=4.16253
    rnet11_788 (net11_1172 net11_1193) resistor r=24.8333
    rnet11_787 (net11_1172 net11_1190) resistor r=24.8333
    rnet11_786 (net11_1172 net11_1201) resistor r=24.8333
    rnet11_785 (net11_1172 net11_1198) resistor r=24.8333
    rnet11_784 (net11_1172 net11_1220) resistor r=14.9
    rnet11_783 (net11_1172 net11_1226) resistor r=202.392
    rnet11_782 (net11_1172 net11_1229) resistor r=202.392
    rnet11_781 (net11_1172 net11_1193) resistor r=4.16253
    rnet11_780 (net11_1172 net11_1201) resistor r=4.16253
    rnet11_779 (net11_1172 net11_1226) resistor r=6.30933
    rnet11_778 (net11_1172 net11_1220) resistor r=6.30933
    rnet11_777 (net11_1172 net11_1190) resistor r=1.63969
    rnet11_776 (net11_1172 net11_1198) resistor r=4.16253
    rnet11_775 (net11_1172 net11_1229) resistor r=4.16253
    rnet11_774 (net11_1172 net11_1193) resistor r=24.8333
    rnet11_773 (net11_1172 net11_1190) resistor r=24.8333
    rnet11_772 (net11_1172 net11_1201) resistor r=24.8333
    rnet11_771 (net11_1172 net11_1198) resistor r=24.8333
    rnet11_770 (net11_1172 net11_2940) resistor r=40.975
    rnet11_769 (net11_1172 net11_1220) resistor r=14.9
    rnet11_768 (net11_1172 net11_1226) resistor r=202.392
    rnet11_767 (net11_1172 MM9_ELT_g) resistor r=7.45
    rnet11_766 (net11_1172 net11_1193) resistor r=4.16253
    rnet11_765 (net11_1172 net11_1201) resistor r=4.16253
    rnet11_764 (net11_1172 net11_1226) resistor r=6.30933
    rnet11_763 (net11_1172 net11_1220) resistor r=6.30933
    rnet11_762 (net11_1172 net11_1190) resistor r=1.63969
    rnet11_761 (net11_1172 net11_1198) resistor r=4.16253
    rnet11_760 (net11_1172 net11_1229) resistor r=4.16253
    rnet11_759 (net11_1209 MM10_ELT_g) resistor r=36.0083
    rnet11_758 (net11_1229 MM9_ELT_g) resistor r=194.942
    rnet11_757 (net11_1234 net11_1240) resistor r=58.3583
    rnet11_756 (net11_1234 net11_1240) resistor r=4.16253
    rnet11_755 (net11_1234 net11_1240) resistor r=58.3583
    rnet11_754 (net11_1234 net11_1240) resistor r=4.16253
    rnet11_753 (net11_1237 net11_1240) resistor r=58.3583
    rnet11_752 (net11_1237 net11_1240) resistor r=6.30933
    rnet11_751 (net11_1237 net11_1240) resistor r=58.3583
    rnet11_750 (net11_1237 net11_1240) resistor r=6.30933
    rnet11_749 (net11_1240 net11_1242) resistor r=14.9
    rnet11_748 (net11_1240 net11_1265) resistor r=24.8333
    rnet11_747 (net11_1240 net11_1262) resistor r=24.8333
    rnet11_746 (net11_1240 net11_1273) resistor r=24.8333
    rnet11_745 (net11_1240 net11_1270) resistor r=24.8333
    rnet11_744 (net11_1240 net11_1294) resistor r=58.3583
    rnet11_743 (net11_1240 net11_1297) resistor r=58.3583
    rnet11_742 (net11_1240 net11_1265) resistor r=4.16253
    rnet11_741 (net11_1240 net11_1242) resistor r=6.30933
    rnet11_740 (net11_1240 net11_1273) resistor r=1.63969
    rnet11_739 (net11_1240 net11_1262) resistor r=4.16253
    rnet11_738 (net11_1240 net11_1294) resistor r=4.16253
    rnet11_737 (net11_1240 net11_1270) resistor r=4.16253
    rnet11_736 (net11_1240 net11_1297) resistor r=4.16253
    rnet11_735 (net11_1240 net11_1242) resistor r=14.9
    rnet11_734 (net11_1240 net11_2954) resistor r=40.975
    rnet11_733 (net11_1240 net11_1265) resistor r=24.8333
    rnet11_732 (net11_1240 net11_1262) resistor r=24.8333
    rnet11_731 (net11_1240 net11_1273) resistor r=24.8333
    rnet11_730 (net11_1240 net11_1270) resistor r=24.8333
    rnet11_729 (net11_1240 net11_1294) resistor r=58.3583
    rnet11_728 (net11_1240 MM5_ELT_g) resistor r=7.45
    rnet11_727 (net11_1240 net11_1265) resistor r=4.16253
    rnet11_726 (net11_1240 net11_1242) resistor r=6.30933
    rnet11_725 (net11_1240 net11_1273) resistor r=1.63969
    rnet11_724 (net11_1240 net11_1262) resistor r=4.16253
    rnet11_723 (net11_1240 net11_1294) resistor r=4.16253
    rnet11_722 (net11_1240 net11_1270) resistor r=4.16253
    rnet11_721 (net11_1240 net11_1297) resistor r=4.16253
    rnet11_720 (net11_1248 net11_1251) resistor r=14.9
    rnet11_719 (net11_1248 net11_1251) resistor r=6.30933
    rnet11_718 (net11_1248 net11_1251) resistor r=14.9
    rnet11_717 (net11_1248 net11_1251) resistor r=6.30933
    rnet11_716 (net11_1251 net11_1254) resistor r=202.392
    rnet11_715 (net11_1251 net11_1257) resistor r=202.392
    rnet11_714 (net11_1251 net11_1281) resistor r=24.8333
    rnet11_713 (net11_1251 net11_1278) resistor r=24.8333
    rnet11_712 (net11_1251 net11_1289) resistor r=24.8333
    rnet11_711 (net11_1251 net11_1286) resistor r=24.8333
    rnet11_710 (net11_1251 net11_1302) resistor r=202.392
    rnet11_709 (net11_1251 net11_1305) resistor r=202.392
    rnet11_708 (net11_1251 net11_1254) resistor r=6.30933
    rnet11_707 (net11_1251 net11_1281) resistor r=1.63969
    rnet11_706 (net11_1251 net11_1289) resistor r=4.16253
    rnet11_705 (net11_1251 net11_1257) resistor r=4.16253
    rnet11_704 (net11_1251 net11_1278) resistor r=4.16253
    rnet11_703 (net11_1251 net11_1302) resistor r=4.16253
    rnet11_702 (net11_1251 net11_1286) resistor r=4.16253
    rnet11_701 (net11_1251 net11_1305) resistor r=4.16253
    rnet11_700 (net11_1251 net11_2956) resistor r=40.975
    rnet11_699 (net11_1251 net11_1254) resistor r=202.392
    rnet11_698 (net11_1251 net11_1257) resistor r=202.392
    rnet11_697 (net11_1251 net11_1281) resistor r=24.8333
    rnet11_696 (net11_1251 net11_1278) resistor r=24.8333
    rnet11_695 (net11_1251 net11_1289) resistor r=24.8333
    rnet11_694 (net11_1251 net11_1286) resistor r=24.8333
    rnet11_693 (net11_1251 net11_1302) resistor r=202.392
    rnet11_692 (net11_1251 MM6_ELT_g) resistor r=7.45
    rnet11_691 (net11_1251 net11_1254) resistor r=6.30933
    rnet11_690 (net11_1251 net11_1281) resistor r=1.63969
    rnet11_689 (net11_1251 net11_1289) resistor r=4.16253
    rnet11_688 (net11_1251 net11_1257) resistor r=4.16253
    rnet11_687 (net11_1251 net11_1278) resistor r=4.16253
    rnet11_686 (net11_1251 net11_1302) resistor r=4.16253
    rnet11_685 (net11_1251 net11_1286) resistor r=4.16253
    rnet11_684 (net11_1251 net11_1305) resistor r=4.16253
    rnet11_683 (net11_1297 MM5_ELT_g) resistor r=50.9083
    rnet11_682 (net11_1305 MM6_ELT_g) resistor r=194.942
    rnet11_681 (net11_1310 net11_1316) resistor r=58.3583
    rnet11_680 (net11_1310 net11_1316) resistor r=4.16253
    rnet11_679 (net11_1310 net11_1316) resistor r=58.3583
    rnet11_678 (net11_1310 net11_1316) resistor r=4.16253
    rnet11_677 (net11_1313 net11_1316) resistor r=58.3583
    rnet11_676 (net11_1313 net11_1316) resistor r=4.16253
    rnet11_675 (net11_1313 net11_1316) resistor r=58.3583
    rnet11_674 (net11_1313 net11_1316) resistor r=4.16253
    rnet11_673 (net11_1316 net11_1329) resistor r=24.8333
    rnet11_672 (net11_1316 net11_1326) resistor r=24.8333
    rnet11_671 (net11_1316 net11_1337) resistor r=24.8333
    rnet11_670 (net11_1316 net11_1334) resistor r=24.8333
    rnet11_669 (net11_1316 net11_1358) resistor r=58.3583
    rnet11_668 (net11_1316 net11_1361) resistor r=58.3583
    rnet11_667 (net11_1316 net11_1366) resistor r=14.9
    rnet11_666 (net11_1316 net11_1329) resistor r=4.16253
    rnet11_665 (net11_1316 net11_1337) resistor r=4.16253
    rnet11_664 (net11_1316 net11_1326) resistor r=4.16253
    rnet11_663 (net11_1316 net11_1358) resistor r=4.16253
    rnet11_662 (net11_1316 net11_1366) resistor r=6.30933
    rnet11_661 (net11_1316 net11_1361) resistor r=6.30933
    rnet11_660 (net11_1316 net11_1334) resistor r=1.63969
    rnet11_659 (net11_1316 net11_1329) resistor r=24.8333
    rnet11_658 (net11_1316 net11_1326) resistor r=24.8333
    rnet11_657 (net11_1316 net11_1337) resistor r=24.8333
    rnet11_656 (net11_1316 net11_1334) resistor r=24.8333
    rnet11_655 (net11_1316 net11_1358) resistor r=58.3583
    rnet11_654 (net11_1316 MM4_ELT_g) resistor r=22.35
    rnet11_653 (net11_1316 net11_1366) resistor r=14.9
    rnet11_652 (net11_1316 net11_3008) resistor r=40.975
    rnet11_651 (net11_1316 net11_1329) resistor r=4.16253
    rnet11_650 (net11_1316 net11_1337) resistor r=4.16253
    rnet11_649 (net11_1316 net11_1326) resistor r=4.16253
    rnet11_648 (net11_1316 net11_1358) resistor r=4.16253
    rnet11_647 (net11_1316 net11_1366) resistor r=6.30933
    rnet11_646 (net11_1316 net11_1361) resistor r=6.30933
    rnet11_645 (net11_1316 net11_1334) resistor r=1.63969
    rnet11_644 (net11_1318 net11_1324) resistor r=202.392
    rnet11_643 (net11_1318 net11_1324) resistor r=4.16253
    rnet11_642 (net11_1318 net11_1324) resistor r=202.392
    rnet11_641 (net11_1318 net11_1324) resistor r=4.16253
    rnet11_640 (net11_1321 net11_1324) resistor r=202.392
    rnet11_639 (net11_1321 net11_1324) resistor r=4.16253
    rnet11_638 (net11_1321 net11_1324) resistor r=202.392
    rnet11_637 (net11_1321 net11_1324) resistor r=4.16253
    rnet11_636 (net11_1324 net11_1345) resistor r=24.8333
    rnet11_635 (net11_1324 net11_1342) resistor r=24.8333
    rnet11_634 (net11_1324 net11_1353) resistor r=24.8333
    rnet11_633 (net11_1324 net11_1350) resistor r=24.8333
    rnet11_632 (net11_1324 net11_1372) resistor r=14.9
    rnet11_631 (net11_1324 net11_1378) resistor r=202.392
    rnet11_630 (net11_1324 net11_1381) resistor r=202.392
    rnet11_629 (net11_1324 net11_1345) resistor r=4.16253
    rnet11_628 (net11_1324 net11_1353) resistor r=4.16253
    rnet11_627 (net11_1324 net11_1378) resistor r=6.30933
    rnet11_626 (net11_1324 net11_1372) resistor r=6.30933
    rnet11_625 (net11_1324 net11_1342) resistor r=1.63969
    rnet11_624 (net11_1324 net11_1350) resistor r=4.16253
    rnet11_623 (net11_1324 net11_1381) resistor r=4.16253
    rnet11_622 (net11_1324 net11_1345) resistor r=24.8333
    rnet11_621 (net11_1324 net11_1342) resistor r=24.8333
    rnet11_620 (net11_1324 net11_1353) resistor r=24.8333
    rnet11_619 (net11_1324 net11_1350) resistor r=24.8333
    rnet11_618 (net11_1324 net11_3010) resistor r=40.975
    rnet11_617 (net11_1324 net11_1372) resistor r=14.9
    rnet11_616 (net11_1324 net11_1378) resistor r=202.392
    rnet11_615 (net11_1324 MM2_ELT_g) resistor r=7.45
    rnet11_614 (net11_1324 net11_1345) resistor r=4.16253
    rnet11_613 (net11_1324 net11_1353) resistor r=4.16253
    rnet11_612 (net11_1324 net11_1378) resistor r=6.30933
    rnet11_611 (net11_1324 net11_1372) resistor r=6.30933
    rnet11_610 (net11_1324 net11_1342) resistor r=1.63969
    rnet11_609 (net11_1324 net11_1350) resistor r=4.16253
    rnet11_608 (net11_1324 net11_1381) resistor r=4.16253
    rnet11_607 (net11_1361 MM4_ELT_g) resistor r=36.0083
    rnet11_606 (net11_1381 MM2_ELT_g) resistor r=194.942
    rnet11_605 (net11_1386 net11_1392) resistor r=58.3583
    rnet11_604 (net11_1386 net11_1392) resistor r=4.16253
    rnet11_603 (net11_1386 net11_1392) resistor r=58.3583
    rnet11_602 (net11_1386 net11_1392) resistor r=4.16253
    rnet11_601 (net11_1389 net11_1392) resistor r=58.3583
    rnet11_600 (net11_1389 net11_1392) resistor r=6.30933
    rnet11_599 (net11_1389 net11_1392) resistor r=58.3583
    rnet11_598 (net11_1389 net11_1392) resistor r=6.30933
    rnet11_597 (net11_1392 net11_1394) resistor r=14.9
    rnet11_596 (net11_1392 net11_1417) resistor r=24.8333
    rnet11_595 (net11_1392 net11_1414) resistor r=24.8333
    rnet11_594 (net11_1392 net11_1425) resistor r=24.8333
    rnet11_593 (net11_1392 net11_1422) resistor r=24.8333
    rnet11_592 (net11_1392 net11_1446) resistor r=58.3583
    rnet11_591 (net11_1392 net11_1449) resistor r=58.3583
    rnet11_590 (net11_1392 net11_1417) resistor r=4.16253
    rnet11_589 (net11_1392 net11_1394) resistor r=6.30933
    rnet11_588 (net11_1392 net11_1425) resistor r=1.63969
    rnet11_587 (net11_1392 net11_1414) resistor r=4.16253
    rnet11_586 (net11_1392 net11_1446) resistor r=4.16253
    rnet11_585 (net11_1392 net11_1422) resistor r=4.16253
    rnet11_584 (net11_1392 net11_1449) resistor r=4.16253
    rnet11_583 (net11_1392 net11_1394) resistor r=14.9
    rnet11_582 (net11_1392 net11_3024) resistor r=40.975
    rnet11_581 (net11_1392 net11_1417) resistor r=24.8333
    rnet11_580 (net11_1392 net11_1414) resistor r=24.8333
    rnet11_579 (net11_1392 net11_1425) resistor r=24.8333
    rnet11_578 (net11_1392 net11_1422) resistor r=24.8333
    rnet11_577 (net11_1392 net11_1446) resistor r=58.3583
    rnet11_576 (net11_1392 MM1_ELT_g) resistor r=7.45
    rnet11_575 (net11_1392 net11_1417) resistor r=4.16253
    rnet11_574 (net11_1392 net11_1394) resistor r=6.30933
    rnet11_573 (net11_1392 net11_1425) resistor r=1.63969
    rnet11_572 (net11_1392 net11_1414) resistor r=4.16253
    rnet11_571 (net11_1392 net11_1446) resistor r=4.16253
    rnet11_570 (net11_1392 net11_1422) resistor r=4.16253
    rnet11_569 (net11_1392 net11_1449) resistor r=4.16253
    rnet11_568 (net11_1400 net11_1403) resistor r=14.9
    rnet11_567 (net11_1400 net11_1403) resistor r=6.30933
    rnet11_566 (net11_1400 net11_1403) resistor r=14.9
    rnet11_565 (net11_1400 net11_1403) resistor r=6.30933
    rnet11_564 (net11_1403 net11_1406) resistor r=202.392
    rnet11_563 (net11_1403 net11_1409) resistor r=202.392
    rnet11_562 (net11_1403 net11_1433) resistor r=24.8333
    rnet11_561 (net11_1403 net11_1430) resistor r=24.8333
    rnet11_560 (net11_1403 net11_1441) resistor r=24.8333
    rnet11_559 (net11_1403 net11_1438) resistor r=24.8333
    rnet11_558 (net11_1403 net11_1454) resistor r=202.392
    rnet11_557 (net11_1403 net11_1457) resistor r=202.392
    rnet11_556 (net11_1403 net11_1406) resistor r=6.30933
    rnet11_555 (net11_1403 net11_1433) resistor r=1.63969
    rnet11_554 (net11_1403 net11_1441) resistor r=4.16253
    rnet11_553 (net11_1403 net11_1409) resistor r=4.16253
    rnet11_552 (net11_1403 net11_1430) resistor r=4.16253
    rnet11_551 (net11_1403 net11_1454) resistor r=4.16253
    rnet11_550 (net11_1403 net11_1438) resistor r=4.16253
    rnet11_549 (net11_1403 net11_1457) resistor r=4.16253
    rnet11_548 (net11_1403 net11_3026) resistor r=40.975
    rnet11_547 (net11_1403 net11_1406) resistor r=202.392
    rnet11_546 (net11_1403 net11_1409) resistor r=202.392
    rnet11_545 (net11_1403 net11_1433) resistor r=24.8333
    rnet11_544 (net11_1403 net11_1430) resistor r=24.8333
    rnet11_543 (net11_1403 net11_1441) resistor r=24.8333
    rnet11_542 (net11_1403 net11_1438) resistor r=24.8333
    rnet11_541 (net11_1403 net11_1454) resistor r=202.392
    rnet11_540 (net11_1403 MM3_ELT_g) resistor r=7.45
    rnet11_539 (net11_1403 net11_1406) resistor r=6.30933
    rnet11_538 (net11_1403 net11_1433) resistor r=1.63969
    rnet11_537 (net11_1403 net11_1441) resistor r=4.16253
    rnet11_536 (net11_1403 net11_1409) resistor r=4.16253
    rnet11_535 (net11_1403 net11_1430) resistor r=4.16253
    rnet11_534 (net11_1403 net11_1454) resistor r=4.16253
    rnet11_533 (net11_1403 net11_1438) resistor r=4.16253
    rnet11_532 (net11_1403 net11_1457) resistor r=4.16253
    rnet11_531 (net11_1449 MM1_ELT_g) resistor r=50.9083
    rnet11_530 (net11_1457 MM3_ELT_g) resistor r=194.942
    rnet11_529 (net11_1462 net11_1468) resistor r=58.3583
    rnet11_528 (net11_1462 net11_1468) resistor r=4.16253
    rnet11_527 (net11_1462 net11_1468) resistor r=58.3583
    rnet11_526 (net11_1462 net11_1468) resistor r=4.16253
    rnet11_525 (net11_1465 net11_1468) resistor r=58.3583
    rnet11_524 (net11_1465 net11_1468) resistor r=4.16253
    rnet11_523 (net11_1465 net11_1468) resistor r=58.3583
    rnet11_522 (net11_1465 net11_1468) resistor r=4.16253
    rnet11_521 (net11_1468 net11_1481) resistor r=24.8333
    rnet11_520 (net11_1468 net11_1478) resistor r=24.8333
    rnet11_519 (net11_1468 net11_1489) resistor r=24.8333
    rnet11_518 (net11_1468 net11_1486) resistor r=24.8333
    rnet11_517 (net11_1468 net11_1510) resistor r=58.3583
    rnet11_516 (net11_1468 net11_1513) resistor r=58.3583
    rnet11_515 (net11_1468 net11_1518) resistor r=14.9
    rnet11_514 (net11_1468 net11_1481) resistor r=4.16253
    rnet11_513 (net11_1468 net11_1489) resistor r=4.16253
    rnet11_512 (net11_1468 net11_1478) resistor r=4.16253
    rnet11_511 (net11_1468 net11_1510) resistor r=4.16253
    rnet11_510 (net11_1468 net11_1518) resistor r=6.30933
    rnet11_509 (net11_1468 net11_1513) resistor r=6.30933
    rnet11_508 (net11_1468 net11_1486) resistor r=1.63969
    rnet11_507 (net11_1468 net11_1481) resistor r=24.8333
    rnet11_506 (net11_1468 net11_1478) resistor r=24.8333
    rnet11_505 (net11_1468 net11_1489) resistor r=24.8333
    rnet11_504 (net11_1468 net11_1486) resistor r=24.8333
    rnet11_503 (net11_1468 net11_1510) resistor r=58.3583
    rnet11_502 (net11_1468 MM15_ELT_g) resistor r=22.35
    rnet11_501 (net11_1468 net11_1518) resistor r=14.9
    rnet11_500 (net11_1468 net11_3078) resistor r=40.975
    rnet11_499 (net11_1468 net11_1481) resistor r=4.16253
    rnet11_498 (net11_1468 net11_1489) resistor r=4.16253
    rnet11_497 (net11_1468 net11_1478) resistor r=4.16253
    rnet11_496 (net11_1468 net11_1510) resistor r=4.16253
    rnet11_495 (net11_1468 net11_1518) resistor r=6.30933
    rnet11_494 (net11_1468 net11_1513) resistor r=6.30933
    rnet11_493 (net11_1468 net11_1486) resistor r=1.63969
    rnet11_492 (net11_1470 net11_1476) resistor r=202.392
    rnet11_491 (net11_1470 net11_1476) resistor r=4.16253
    rnet11_490 (net11_1470 net11_1476) resistor r=202.392
    rnet11_489 (net11_1470 net11_1476) resistor r=4.16253
    rnet11_488 (net11_1473 net11_1476) resistor r=202.392
    rnet11_487 (net11_1473 net11_1476) resistor r=4.16253
    rnet11_486 (net11_1473 net11_1476) resistor r=202.392
    rnet11_485 (net11_1473 net11_1476) resistor r=4.16253
    rnet11_484 (net11_1476 net11_1497) resistor r=24.8333
    rnet11_483 (net11_1476 net11_1494) resistor r=24.8333
    rnet11_482 (net11_1476 net11_1505) resistor r=24.8333
    rnet11_481 (net11_1476 net11_1502) resistor r=24.8333
    rnet11_480 (net11_1476 net11_1524) resistor r=14.9
    rnet11_479 (net11_1476 net11_1530) resistor r=202.392
    rnet11_478 (net11_1476 net11_1533) resistor r=202.392
    rnet11_477 (net11_1476 net11_1497) resistor r=4.16253
    rnet11_476 (net11_1476 net11_1505) resistor r=4.16253
    rnet11_475 (net11_1476 net11_1530) resistor r=6.30933
    rnet11_474 (net11_1476 net11_1524) resistor r=6.30933
    rnet11_473 (net11_1476 net11_1494) resistor r=1.63969
    rnet11_472 (net11_1476 net11_1502) resistor r=4.16253
    rnet11_471 (net11_1476 net11_1533) resistor r=4.16253
    rnet11_470 (net11_1476 net11_1497) resistor r=24.8333
    rnet11_469 (net11_1476 net11_1494) resistor r=24.8333
    rnet11_468 (net11_1476 net11_1505) resistor r=24.8333
    rnet11_467 (net11_1476 net11_1502) resistor r=24.8333
    rnet11_466 (net11_1476 net11_3080) resistor r=40.975
    rnet11_465 (net11_1476 net11_1524) resistor r=14.9
    rnet11_464 (net11_1476 net11_1530) resistor r=202.392
    rnet11_463 (net11_1476 MM14_ELT_g) resistor r=7.45
    rnet11_462 (net11_1476 net11_1497) resistor r=4.16253
    rnet11_461 (net11_1476 net11_1505) resistor r=4.16253
    rnet11_460 (net11_1476 net11_1530) resistor r=6.30933
    rnet11_459 (net11_1476 net11_1524) resistor r=6.30933
    rnet11_458 (net11_1476 net11_1494) resistor r=1.63969
    rnet11_457 (net11_1476 net11_1502) resistor r=4.16253
    rnet11_456 (net11_1476 net11_1533) resistor r=4.16253
    rnet11_455 (net11_1513 MM15_ELT_g) resistor r=36.0083
    rnet11_454 (net11_1533 MM14_ELT_g) resistor r=194.942
    rnet11_453 (net11_2081 net11_2083) resistor r=0.400918
    rnet11_452 (net11_2081 net11_2098) resistor r=0.0992625
    rnet11_451 (net11_2083 net11_2084) resistor r=13
    rnet11_450 (net11_2084 MM22_ELT_d) resistor r=8.44
    rnet11_449 (net11_2086 net11_2088) resistor r=0.502484
    rnet11_448 (net11_2086 net11_2100) resistor r=0.0973031
    rnet11_447 (net11_2088 net11_2089) resistor r=8.66667
    rnet11_446 (net11_2088 net11_2091) resistor r=0.64147
    rnet11_445 (net11_2089 MM24_ELT_d) resistor r=32.3614
    rnet11_444 (net11_2091 net11_2092) resistor r=8.66667
    rnet11_443 (net11_2091 net11_2094) resistor r=0.427646
    rnet11_442 (net11_2092 MM24_ELT_d) resistor r=16.1807
    rnet11_441 (net11_2092 net11_2095) resistor r=32.3614
    rnet11_440 (net11_2094 net11_2095) resistor r=26
    rnet11_439 (net11_2097 net11_2098) resistor r=0.463169
    rnet11_438 (net11_2097 net11_2206) resistor r=0.0157428
    rnet11_437 (net11_2099 net11_2100) resistor r=0.545469
    rnet11_436 (net11_2099 net11_2208) resistor r=0.0223006
    rnet11_435 (net11_2101 net11_2102) resistor r=0.078177
    rnet11_434 (net11_2101 net11_2206) resistor r=0.076567
    rnet11_433 (net11_2102 net11_2207) resistor r=0.0825742
    rnet11_432 (net11_2103 net11_2104) resistor r=0.078177
    rnet11_431 (net11_2103 net11_2207) resistor r=0.0825742
    rnet11_430 (net11_2104 net11_2208) resistor r=0.0688372
    rnet11_429 (net11_2105 net11_2107) resistor r=0.440166
    rnet11_428 (net11_2105 net11_2206) resistor r=0.076567
    rnet11_427 (net11_2107 net11_2108) resistor r=13
    rnet11_426 (net11_2108 MM21_ELT_d) resistor r=8.44
    rnet11_425 (net11_2110 net11_2112) resistor r=0.551675
    rnet11_424 (net11_2110 net11_2208) resistor r=0.0688372
    rnet11_423 (net11_2112 net11_2113) resistor r=8.66667
    rnet11_422 (net11_2112 net11_2115) resistor r=0.704266
    rnet11_421 (net11_2113 MM23_ELT_d) resistor r=32.3614
    rnet11_420 (net11_2115 net11_2116) resistor r=8.66667
    rnet11_419 (net11_2115 net11_2118) resistor r=0.469511
    rnet11_418 (net11_2116 MM23_ELT_d) resistor r=16.1807
    rnet11_417 (net11_2116 net11_2119) resistor r=32.3614
    rnet11_416 (net11_2118 net11_2119) resistor r=26
    rnet11_415 (net11_2121 net11_2122) resistor r=0.568077
    rnet11_414 (net11_2121 net11_2212) resistor r=0.042592
    rnet11_413 (net11_2122 net11_2207) resistor r=0.0106461
    rnet11_412 (net11_2123 net11_2125) resistor r=0.440166
    rnet11_411 (net11_2123 net11_2141) resistor r=0.286547
    rnet11_410 (net11_2125 net11_2126) resistor r=13
    rnet11_409 (net11_2126 MM7_ELT_d) resistor r=8.44
    rnet11_408 (net11_2128 net11_2130) resistor r=0.551675
    rnet11_407 (net11_2128 net11_2140) resistor r=0.0973031
    rnet11_406 (net11_2130 net11_2131) resistor r=8.66667
    rnet11_405 (net11_2130 net11_2133) resistor r=0.704266
    rnet11_404 (net11_2131 MM8_ELT_d) resistor r=32.3614
    rnet11_403 (net11_2133 net11_2134) resistor r=8.66667
    rnet11_402 (net11_2133 net11_2136) resistor r=0.469511
    rnet11_401 (net11_2134 MM8_ELT_d) resistor r=16.1807
    rnet11_400 (net11_2134 net11_2137) resistor r=32.3614
    rnet11_399 (net11_2136 net11_2137) resistor r=26
    rnet11_398 (net11_2139 net11_2140) resistor r=0.132734
    rnet11_397 (net11_2139 net11_2213) resistor r=0.0910082
    rnet11_396 (net11_2141 net11_2142) resistor r=0.078177
    rnet11_395 (net11_2141 net11_2146) resistor r=0.0764802
    rnet11_394 (net11_2142 net11_2212) resistor r=0.0427972
    rnet11_393 (net11_2143 net11_2144) resistor r=0.078177
    rnet11_392 (net11_2143 net11_2212) resistor r=0.0427972
    rnet11_391 (net11_2144 net11_2213) resistor r=0.00499399
    rnet11_390 (net11_2145 net11_2146) resistor r=0.178105
    rnet11_389 (net11_2145 net11_2190) resistor r=0.0992625
    rnet11_388 (net11_2147 net11_2149) resistor r=0.773837
    rnet11_387 (net11_2147 net11_2212) resistor r=0.042592
    rnet11_386 (net11_2149 net11_2150) resistor r=6.66667
    rnet11_385 (net11_2149 net11_2152) resistor r=0.536766
    rnet11_384 (net11_2150 net11_3090) resistor r=31.1545
    rnet11_383 (net11_2150 net11_3105) resistor r=66.3727
    rnet11_382 (net11_2152 net11_2153) resistor r=6.66667
    rnet11_381 (net11_2152 net11_2155) resistor r=0.536766
    rnet11_380 (net11_2153 net11_3104) resistor r=6.77273
    rnet11_379 (net11_2153 net11_3112) resistor r=20.3182
    rnet11_378 (net11_2155 net11_2156) resistor r=6.66667
    rnet11_377 (net11_2155 net11_2158) resistor r=0.536766
    rnet11_376 (net11_2156 net11_3111) resistor r=52.8273
    rnet11_375 (net11_2156 net11_3126) resistor r=44.7
    rnet11_374 (net11_2158 net11_2159) resistor r=6.66667
    rnet11_373 (net11_2158 net11_2161) resistor r=0.536766
    rnet11_372 (net11_2159 net11_3251) resistor r=3.725
    rnet11_371 (net11_2159 net11_2678) resistor r=3.725
    rnet11_370 (net11_2159 net11_2670) resistor r=3.725
    rnet11_369 (net11_2159 net11_2676) resistor r=3.725
    rnet11_368 (net11_2161 net11_2162) resistor r=6.66667
    rnet11_367 (net11_2161 net11_2164) resistor r=0.536766
    rnet11_366 (net11_2162 net11_3251) resistor r=74.5
    rnet11_365 (net11_2162 net11_3144) resistor r=23.0273
    rnet11_364 (net11_2164 net11_2165) resistor r=6.66667
    rnet11_363 (net11_2164 net11_2167) resistor r=0.536766
    rnet11_362 (net11_2165 net11_3150) resistor r=14.9
    rnet11_361 (net11_2165 net11_2168) resistor r=81.2727
    rnet11_360 (net11_2167 net11_2168) resistor r=6.66667
    rnet11_359 (net11_2167 net11_2170) resistor r=0.536766
    rnet11_358 (net11_2168 net11_3164) resistor r=1.35455
    rnet11_357 (net11_2170 net11_2171) resistor r=6.66667
    rnet11_356 (net11_2170 net11_2173) resistor r=0.536766
    rnet11_355 (net11_2171 net11_3170) resistor r=36.5727
    rnet11_354 (net11_2171 net11_3185) resistor r=60.9545
    rnet11_353 (net11_2173 net11_2174) resistor r=6.66667
    rnet11_352 (net11_2173 net11_2176) resistor r=0.536766
    rnet11_351 (net11_2174 net11_3184) resistor r=12.1909
    rnet11_350 (net11_2174 net11_3192) resistor r=14.9
    rnet11_349 (net11_2176 net11_2177) resistor r=6.66667
    rnet11_348 (net11_2176 net11_2179) resistor r=0.536766
    rnet11_347 (net11_2177 net11_3191) resistor r=58.2455
    rnet11_346 (net11_2177 net11_3206) resistor r=39.2818
    rnet11_345 (net11_2179 net11_2180) resistor r=6.66667
    rnet11_344 (net11_2179 net11_2182) resistor r=0.536766
    rnet11_343 (net11_2180 net11_3258) resistor r=3.725
    rnet11_342 (net11_2180 net11_2956) resistor r=3.725
    rnet11_341 (net11_2180 net11_2948) resistor r=3.725
    rnet11_340 (net11_2180 net11_2954) resistor r=3.725
    rnet11_339 (net11_2182 net11_2183) resistor r=6.66667
    rnet11_338 (net11_2182 net11_2185) resistor r=0.536766
    rnet11_337 (net11_2183 net11_3258) resistor r=79.9182
    rnet11_336 (net11_2183 net11_3224) resistor r=17.6091
    rnet11_335 (net11_2185 net11_2186) resistor r=6.66667
    rnet11_334 (net11_2186 net11_3230) resistor r=20.3182
    rnet11_333 (net11_2186 net11_3244) resistor r=77.2091
    rnet11_332 (net11_2188 net11_2189) resistor r=0.196216
    rnet11_331 (net11_2188 net11_2195) resistor r=0.0973031
    rnet11_330 (net11_2189 net11_2213) resistor r=0.0910082
    rnet11_329 (net11_2190 net11_2192) resistor r=0.440166
    rnet11_328 (net11_2192 net11_2193) resistor r=13
    rnet11_327 (net11_2193 MM12_ELT_d) resistor r=8.44
    rnet11_326 (net11_2195 net11_2197) resistor r=0.551675
    rnet11_325 (net11_2197 net11_2198) resistor r=8.66667
    rnet11_324 (net11_2197 net11_2200) resistor r=0.704266
    rnet11_323 (net11_2198 net11) resistor r=32.3614
    rnet11_322 (net11_2200 net11_2201) resistor r=8.66667
    rnet11_321 (net11_2200 net11_2203) resistor r=0.469511
    rnet11_320 (net11_2201 net11) resistor r=16.1807
    rnet11_319 (net11_2201 net11_2204) resistor r=32.3614
    rnet11_318 (net11_2203 net11_2204) resistor r=26
    rnet11_317 (net11_2538 net11_3091) resistor r=10.0997
    rnet11_316 (net11_2540 net11_3091) resistor r=10.0997
    rnet11_315 (net11_2592 net11_3106) resistor r=3.725
    rnet11_314 (net11_2594 net11_3106) resistor r=3.725
    rnet11_313 (net11_2606 net11_3113) resistor r=3.725
    rnet11_312 (net11_2608 net11_3113) resistor r=3.725
    rnet11_311 (net11_2660 net11_3127) resistor r=3.725
    rnet11_310 (net11_2662 net11_3127) resistor r=3.725
    rnet11_309 (net11_2670 net11_2671) resistor r=27.0909
    rnet11_308 (net11_2671 net11_3127) resistor r=3.725
    rnet11_307 (net11_2730 net11_3145) resistor r=3.725
    rnet11_306 (net11_2732 net11_3145) resistor r=3.725
    rnet11_305 (net11_2740 net11_2741) resistor r=27.0909
    rnet11_304 (net11_2740 net11_3151) resistor r=3.725
    rnet11_303 (net11_2741 net11_3145) resistor r=3.725
    rnet11_302 (net11_2746 net11_3151) resistor r=3.725
    rnet11_301 (net11_2748 net11_3151) resistor r=3.725
    rnet11_300 (net11_2800 net11_3165) resistor r=3.725
    rnet11_299 (net11_2802 net11_3165) resistor r=3.725
    rnet11_298 (net11_2810 net11_2811) resistor r=27.0909
    rnet11_297 (net11_2810 net11_3171) resistor r=3.725
    rnet11_296 (net11_2811 net11_3165) resistor r=3.725
    rnet11_295 (net11_2816 net11_3171) resistor r=3.725
    rnet11_294 (net11_2818 net11_3171) resistor r=3.725
    rnet11_293 (net11_2870 net11_3186) resistor r=3.725
    rnet11_292 (net11_2872 net11_3186) resistor r=3.725
    rnet11_291 (net11_2884 net11_3193) resistor r=3.725
    rnet11_290 (net11_2886 net11_3193) resistor r=3.725
    rnet11_289 (net11_2938 net11_3207) resistor r=3.725
    rnet11_288 (net11_2940 net11_3207) resistor r=3.725
    rnet11_287 (net11_2948 net11_2949) resistor r=27.0909
    rnet11_286 (net11_2949 net11_3207) resistor r=3.725
    rnet11_285 (net11_3008 net11_3225) resistor r=3.725
    rnet11_284 (net11_3010 net11_3225) resistor r=3.725
    rnet11_283 (net11_3018 net11_3019) resistor r=27.0909
    rnet11_282 (net11_3018 net11_3231) resistor r=3.725
    rnet11_281 (net11_3019 net11_3225) resistor r=3.725
    rnet11_280 (net11_3024 net11_3231) resistor r=3.725
    rnet11_279 (net11_3026 net11_3231) resistor r=3.725
    rnet11_278 (net11_3078 net11_3245) resistor r=10.0997
    rnet11_277 (net11_3080 net11_3245) resistor r=10.0997
    rnet11_276 (net11_3090 net11_3091) resistor r=0.877078
    rnet11_275 (net11_3104 net11_3106) resistor r=3.725
    rnet11_274 (net11_3105 net11_3106) resistor r=3.725
    rnet11_273 (net11_3111 net11_3113) resistor r=3.725
    rnet11_272 (net11_3112 net11_3113) resistor r=3.725
    rnet11_271 (net11_3126 net11_3127) resistor r=3.725
    rnet11_270 (net11_3144 net11_3145) resistor r=3.725
    rnet11_269 (net11_3150 net11_3151) resistor r=3.725
    rnet11_268 (net11_3164 net11_3165) resistor r=3.725
    rnet11_267 (net11_3170 net11_3171) resistor r=3.725
    rnet11_266 (net11_3184 net11_3186) resistor r=3.725
    rnet11_265 (net11_3185 net11_3186) resistor r=3.725
    rnet11_264 (net11_3191 net11_3193) resistor r=3.725
    rnet11_263 (net11_3192 net11_3193) resistor r=3.725
    rnet11_262 (net11_3206 net11_3207) resistor r=3.725
    rnet11_261 (net11_3224 net11_3225) resistor r=3.725
    rnet11_260 (net11_3230 net11_3231) resistor r=3.725
    rnet11_259 (net11_3244 net11_3245) resistor r=0.877078
    rI_378 (I_82 I_88) resistor r=58.3583
    rI_377 (I_82 I_88) resistor r=4.16253
    rI_376 (I_82 I_88) resistor r=58.3583
    rI_375 (I_82 I_88) resistor r=4.16253
    rI_374 (I_85 I_88) resistor r=58.3583
    rI_373 (I_85 I_88) resistor r=4.16253
    rI_372 (I_85 I_88) resistor r=58.3583
    rI_371 (I_85 I_88) resistor r=4.16253
    rI_370 (I_88 I_101) resistor r=24.8333
    rI_369 (I_88 I_98) resistor r=24.8333
    rI_368 (I_88 I_109) resistor r=24.8333
    rI_367 (I_88 I_106) resistor r=24.8333
    rI_366 (I_88 I_130) resistor r=58.3583
    rI_365 (I_88 I_133) resistor r=58.3583
    rI_364 (I_88 I_138) resistor r=14.9
    rI_363 (I_88 I_101) resistor r=4.16253
    rI_362 (I_88 I_109) resistor r=4.16253
    rI_361 (I_88 I_98) resistor r=4.16253
    rI_360 (I_88 I_130) resistor r=4.16253
    rI_359 (I_88 I_138) resistor r=6.30933
    rI_358 (I_88 I_133) resistor r=6.30933
    rI_357 (I_88 I_106) resistor r=1.63969
    rI_356 (I_88 I_101) resistor r=24.8333
    rI_355 (I_88 I_98) resistor r=24.8333
    rI_354 (I_88 I_109) resistor r=24.8333
    rI_353 (I_88 I_106) resistor r=24.8333
    rI_352 (I_88 I_130) resistor r=58.3583
    rI_351 (I_88 MM22_ELT_g) resistor r=22.35
    rI_350 (I_88 I_138) resistor r=14.9
    rI_349 (I_88 I_631) resistor r=40.975
    rI_348 (I_88 I_101) resistor r=4.16253
    rI_347 (I_88 I_109) resistor r=4.16253
    rI_346 (I_88 I_98) resistor r=4.16253
    rI_345 (I_88 I_130) resistor r=4.16253
    rI_344 (I_88 I_138) resistor r=6.30933
    rI_343 (I_88 I_133) resistor r=6.30933
    rI_342 (I_88 I_106) resistor r=1.63969
    rI_341 (I_90 I_96) resistor r=202.392
    rI_340 (I_90 I_96) resistor r=4.16253
    rI_339 (I_90 I_96) resistor r=202.392
    rI_338 (I_90 I_96) resistor r=4.16253
    rI_337 (I_93 I_96) resistor r=202.392
    rI_336 (I_93 I_96) resistor r=4.16253
    rI_335 (I_93 I_96) resistor r=202.392
    rI_334 (I_93 I_96) resistor r=4.16253
    rI_333 (I_96 I_117) resistor r=24.8333
    rI_332 (I_96 I_114) resistor r=24.8333
    rI_331 (I_96 I_125) resistor r=24.8333
    rI_330 (I_96 I_122) resistor r=24.8333
    rI_329 (I_96 I_144) resistor r=14.9
    rI_328 (I_96 I_150) resistor r=202.392
    rI_327 (I_96 I_153) resistor r=202.392
    rI_326 (I_96 I_117) resistor r=4.16253
    rI_325 (I_96 I_125) resistor r=4.16253
    rI_324 (I_96 I_150) resistor r=6.30933
    rI_323 (I_96 I_144) resistor r=6.30933
    rI_322 (I_96 I_114) resistor r=1.63969
    rI_321 (I_96 I_122) resistor r=4.16253
    rI_320 (I_96 I_153) resistor r=4.16253
    rI_319 (I_96 I_117) resistor r=24.8333
    rI_318 (I_96 I_114) resistor r=24.8333
    rI_317 (I_96 I_125) resistor r=24.8333
    rI_316 (I_96 I_122) resistor r=24.8333
    rI_315 (I_96 I_633) resistor r=40.975
    rI_314 (I_96 I_144) resistor r=14.9
    rI_313 (I_96 I_150) resistor r=202.392
    rI_312 (I_96 MM24_ELT_g) resistor r=7.45
    rI_311 (I_96 I_117) resistor r=4.16253
    rI_310 (I_96 I_125) resistor r=4.16253
    rI_309 (I_96 I_150) resistor r=6.30933
    rI_308 (I_96 I_144) resistor r=6.30933
    rI_307 (I_96 I_114) resistor r=1.63969
    rI_306 (I_96 I_122) resistor r=4.16253
    rI_305 (I_96 I_153) resistor r=4.16253
    rI_304 (I_133 MM22_ELT_g) resistor r=36.0083
    rI_303 (I_153 MM24_ELT_g) resistor r=194.942
    rI_302 (I_158 I_164) resistor r=58.3583
    rI_301 (I_158 I_164) resistor r=4.16253
    rI_300 (I_158 I_164) resistor r=58.3583
    rI_299 (I_158 I_164) resistor r=4.16253
    rI_298 (I_161 I_164) resistor r=58.3583
    rI_297 (I_161 I_164) resistor r=6.30933
    rI_296 (I_161 I_164) resistor r=58.3583
    rI_295 (I_161 I_164) resistor r=6.30933
    rI_294 (I_164 I_166) resistor r=14.9
    rI_293 (I_164 I_189) resistor r=24.8333
    rI_292 (I_164 I_186) resistor r=24.8333
    rI_291 (I_164 I_197) resistor r=24.8333
    rI_290 (I_164 I_194) resistor r=24.8333
    rI_289 (I_164 I_218) resistor r=58.3583
    rI_288 (I_164 I_221) resistor r=58.3583
    rI_287 (I_164 I_189) resistor r=4.16253
    rI_286 (I_164 I_166) resistor r=6.30933
    rI_285 (I_164 I_197) resistor r=1.63969
    rI_284 (I_164 I_186) resistor r=4.16253
    rI_283 (I_164 I_218) resistor r=4.16253
    rI_282 (I_164 I_194) resistor r=4.16253
    rI_281 (I_164 I_221) resistor r=4.16253
    rI_280 (I_164 I_166) resistor r=14.9
    rI_279 (I_164 I_647) resistor r=40.975
    rI_278 (I_164 I_189) resistor r=24.8333
    rI_277 (I_164 I_186) resistor r=24.8333
    rI_276 (I_164 I_197) resistor r=24.8333
    rI_275 (I_164 I_194) resistor r=24.8333
    rI_274 (I_164 I_218) resistor r=58.3583
    rI_273 (I_164 MM21_ELT_g) resistor r=7.45
    rI_272 (I_164 I_189) resistor r=4.16253
    rI_271 (I_164 I_166) resistor r=6.30933
    rI_270 (I_164 I_197) resistor r=1.63969
    rI_269 (I_164 I_186) resistor r=4.16253
    rI_268 (I_164 I_218) resistor r=4.16253
    rI_267 (I_164 I_194) resistor r=4.16253
    rI_266 (I_164 I_221) resistor r=4.16253
    rI_265 (I_172 I_175) resistor r=14.9
    rI_264 (I_172 I_175) resistor r=6.30933
    rI_263 (I_172 I_175) resistor r=14.9
    rI_262 (I_172 I_175) resistor r=6.30933
    rI_261 (I_175 I_178) resistor r=202.392
    rI_260 (I_175 I_181) resistor r=202.392
    rI_259 (I_175 I_205) resistor r=24.8333
    rI_258 (I_175 I_202) resistor r=24.8333
    rI_257 (I_175 I_213) resistor r=24.8333
    rI_256 (I_175 I_210) resistor r=24.8333
    rI_255 (I_175 I_226) resistor r=202.392
    rI_254 (I_175 I_229) resistor r=202.392
    rI_253 (I_175 I_178) resistor r=6.30933
    rI_252 (I_175 I_205) resistor r=1.63969
    rI_251 (I_175 I_213) resistor r=4.16253
    rI_250 (I_175 I_181) resistor r=4.16253
    rI_249 (I_175 I_202) resistor r=4.16253
    rI_248 (I_175 I_226) resistor r=4.16253
    rI_247 (I_175 I_210) resistor r=4.16253
    rI_246 (I_175 I_229) resistor r=4.16253
    rI_245 (I_175 I_649) resistor r=40.975
    rI_244 (I_175 I_178) resistor r=202.392
    rI_243 (I_175 I_181) resistor r=202.392
    rI_242 (I_175 I_205) resistor r=24.8333
    rI_241 (I_175 I_202) resistor r=24.8333
    rI_240 (I_175 I_213) resistor r=24.8333
    rI_239 (I_175 I_210) resistor r=24.8333
    rI_238 (I_175 I_226) resistor r=202.392
    rI_237 (I_175 MM23_ELT_g) resistor r=7.45
    rI_236 (I_175 I_178) resistor r=6.30933
    rI_235 (I_175 I_205) resistor r=1.63969
    rI_234 (I_175 I_213) resistor r=4.16253
    rI_233 (I_175 I_181) resistor r=4.16253
    rI_232 (I_175 I_202) resistor r=4.16253
    rI_231 (I_175 I_226) resistor r=4.16253
    rI_230 (I_175 I_210) resistor r=4.16253
    rI_229 (I_175 I_229) resistor r=4.16253
    rI_228 (I_221 MM21_ELT_g) resistor r=50.9083
    rI_227 (I_229 MM23_ELT_g) resistor r=194.942
    rI_226 (I_234 I_240) resistor r=58.3583
    rI_225 (I_234 I_240) resistor r=4.16253
    rI_224 (I_234 I_240) resistor r=58.3583
    rI_223 (I_234 I_240) resistor r=4.16253
    rI_222 (I_237 I_240) resistor r=58.3583
    rI_221 (I_237 I_240) resistor r=4.16253
    rI_220 (I_237 I_240) resistor r=58.3583
    rI_219 (I_237 I_240) resistor r=4.16253
    rI_218 (I_240 I_253) resistor r=24.8333
    rI_217 (I_240 I_250) resistor r=24.8333
    rI_216 (I_240 I_261) resistor r=24.8333
    rI_215 (I_240 I_258) resistor r=24.8333
    rI_214 (I_240 I_282) resistor r=58.3583
    rI_213 (I_240 I_285) resistor r=58.3583
    rI_212 (I_240 I_290) resistor r=14.9
    rI_211 (I_240 I_253) resistor r=4.16253
    rI_210 (I_240 I_261) resistor r=4.16253
    rI_209 (I_240 I_250) resistor r=4.16253
    rI_208 (I_240 I_282) resistor r=4.16253
    rI_207 (I_240 I_290) resistor r=6.30933
    rI_206 (I_240 I_285) resistor r=6.30933
    rI_205 (I_240 I_258) resistor r=1.63969
    rI_204 (I_240 I_253) resistor r=24.8333
    rI_203 (I_240 I_250) resistor r=24.8333
    rI_202 (I_240 I_261) resistor r=24.8333
    rI_201 (I_240 I_258) resistor r=24.8333
    rI_200 (I_240 I_282) resistor r=58.3583
    rI_199 (I_240 MM7_ELT_g) resistor r=22.35
    rI_198 (I_240 I_290) resistor r=14.9
    rI_197 (I_240 I_703) resistor r=40.975
    rI_196 (I_240 I_253) resistor r=4.16253
    rI_195 (I_240 I_261) resistor r=4.16253
    rI_194 (I_240 I_250) resistor r=4.16253
    rI_193 (I_240 I_282) resistor r=4.16253
    rI_192 (I_240 I_290) resistor r=6.30933
    rI_191 (I_240 I_285) resistor r=6.30933
    rI_190 (I_240 I_258) resistor r=1.63969
    rI_189 (I_242 I_248) resistor r=202.392
    rI_188 (I_242 I_248) resistor r=4.16253
    rI_187 (I_242 I_248) resistor r=202.392
    rI_186 (I_242 I_248) resistor r=4.16253
    rI_185 (I_245 I_248) resistor r=202.392
    rI_184 (I_245 I_248) resistor r=4.16253
    rI_183 (I_245 I_248) resistor r=202.392
    rI_182 (I_245 I_248) resistor r=4.16253
    rI_181 (I_248 I_269) resistor r=24.8333
    rI_180 (I_248 I_266) resistor r=24.8333
    rI_179 (I_248 I_277) resistor r=24.8333
    rI_178 (I_248 I_274) resistor r=24.8333
    rI_177 (I_248 I_296) resistor r=14.9
    rI_176 (I_248 I_302) resistor r=202.392
    rI_175 (I_248 I_305) resistor r=202.392
    rI_174 (I_248 I_269) resistor r=4.16253
    rI_173 (I_248 I_277) resistor r=4.16253
    rI_172 (I_248 I_302) resistor r=6.30933
    rI_171 (I_248 I_296) resistor r=6.30933
    rI_170 (I_248 I_266) resistor r=1.63969
    rI_169 (I_248 I_274) resistor r=4.16253
    rI_168 (I_248 I_305) resistor r=4.16253
    rI_167 (I_248 I_269) resistor r=24.8333
    rI_166 (I_248 I_266) resistor r=24.8333
    rI_165 (I_248 I_277) resistor r=24.8333
    rI_164 (I_248 I_274) resistor r=24.8333
    rI_163 (I_248 I_705) resistor r=40.975
    rI_162 (I_248 I_296) resistor r=14.9
    rI_161 (I_248 I_302) resistor r=202.392
    rI_160 (I_248 MM8_ELT_g) resistor r=7.45
    rI_159 (I_248 I_269) resistor r=4.16253
    rI_158 (I_248 I_277) resistor r=4.16253
    rI_157 (I_248 I_302) resistor r=6.30933
    rI_156 (I_248 I_296) resistor r=6.30933
    rI_155 (I_248 I_266) resistor r=1.63969
    rI_154 (I_248 I_274) resistor r=4.16253
    rI_153 (I_248 I_305) resistor r=4.16253
    rI_152 (I_285 MM7_ELT_g) resistor r=36.0083
    rI_151 (I_305 MM8_ELT_g) resistor r=194.942
    rI_150 (I_310 I_316) resistor r=58.3583
    rI_149 (I_310 I_316) resistor r=4.16253
    rI_148 (I_310 I_316) resistor r=58.3583
    rI_147 (I_310 I_316) resistor r=4.16253
    rI_146 (I_313 I_316) resistor r=58.3583
    rI_145 (I_313 I_316) resistor r=6.30933
    rI_144 (I_313 I_316) resistor r=58.3583
    rI_143 (I_313 I_316) resistor r=6.30933
    rI_142 (I_316 I_318) resistor r=14.9
    rI_141 (I_316 I_341) resistor r=24.8333
    rI_140 (I_316 I_338) resistor r=24.8333
    rI_139 (I_316 I_349) resistor r=24.8333
    rI_138 (I_316 I_346) resistor r=24.8333
    rI_137 (I_316 I_370) resistor r=58.3583
    rI_136 (I_316 I_373) resistor r=58.3583
    rI_135 (I_316 I_341) resistor r=4.16253
    rI_134 (I_316 I_318) resistor r=6.30933
    rI_133 (I_316 I_349) resistor r=1.63969
    rI_132 (I_316 I_338) resistor r=4.16253
    rI_131 (I_316 I_370) resistor r=4.16253
    rI_130 (I_316 I_346) resistor r=4.16253
    rI_129 (I_316 I_373) resistor r=4.16253
    rI_128 (I_316 I_318) resistor r=14.9
    rI_127 (I_316 I_719) resistor r=40.975
    rI_126 (I_316 I_341) resistor r=24.8333
    rI_125 (I_316 I_338) resistor r=24.8333
    rI_124 (I_316 I_349) resistor r=24.8333
    rI_123 (I_316 I_346) resistor r=24.8333
    rI_122 (I_316 I_370) resistor r=58.3583
    rI_121 (I_316 MM12_ELT_g) resistor r=7.45
    rI_120 (I_316 I_341) resistor r=4.16253
    rI_119 (I_316 I_318) resistor r=6.30933
    rI_118 (I_316 I_349) resistor r=1.63969
    rI_117 (I_316 I_338) resistor r=4.16253
    rI_116 (I_316 I_370) resistor r=4.16253
    rI_115 (I_316 I_346) resistor r=4.16253
    rI_114 (I_316 I_373) resistor r=4.16253
    rI_113 (I_324 I_327) resistor r=14.9
    rI_112 (I_324 I_327) resistor r=6.30933
    rI_111 (I_324 I_327) resistor r=14.9
    rI_110 (I_324 I_327) resistor r=6.30933
    rI_109 (I_327 I_330) resistor r=202.392
    rI_108 (I_327 I_333) resistor r=202.392
    rI_107 (I_327 I_357) resistor r=24.8333
    rI_106 (I_327 I_354) resistor r=24.8333
    rI_105 (I_327 I_365) resistor r=24.8333
    rI_104 (I_327 I_362) resistor r=24.8333
    rI_103 (I_327 I_378) resistor r=202.392
    rI_102 (I_327 I_381) resistor r=202.392
    rI_101 (I_327 I_330) resistor r=6.30933
    rI_100 (I_327 I_357) resistor r=1.63969
    rI_99 (I_327 I_365) resistor r=4.16253
    rI_98 (I_327 I_333) resistor r=4.16253
    rI_97 (I_327 I_354) resistor r=4.16253
    rI_96 (I_327 I_378) resistor r=4.16253
    rI_95 (I_327 I_362) resistor r=4.16253
    rI_94 (I_327 I_381) resistor r=4.16253
    rI_93 (I_327 I_721) resistor r=40.975
    rI_92 (I_327 I_330) resistor r=202.392
    rI_91 (I_327 I_333) resistor r=202.392
    rI_90 (I_327 I_357) resistor r=24.8333
    rI_89 (I_327 I_354) resistor r=24.8333
    rI_88 (I_327 I_365) resistor r=24.8333
    rI_87 (I_327 I_362) resistor r=24.8333
    rI_86 (I_327 I_378) resistor r=202.392
    rI_85 (I_327 MM13_ELT_g) resistor r=7.45
    rI_84 (I_327 I_330) resistor r=6.30933
    rI_83 (I_327 I_357) resistor r=1.63969
    rI_82 (I_327 I_365) resistor r=4.16253
    rI_81 (I_327 I_333) resistor r=4.16253
    rI_80 (I_327 I_354) resistor r=4.16253
    rI_79 (I_327 I_378) resistor r=4.16253
    rI_78 (I_327 I_362) resistor r=4.16253
    rI_77 (I_327 I_381) resistor r=4.16253
    rI_76 (I_373 MM12_ELT_g) resistor r=50.9083
    rI_75 (I_381 MM13_ELT_g) resistor r=194.942
    rI_74 (I_523 I) resistor r=6.66667
    rI_73 (I_523 I_755) resistor r=14.2227
    rI_72 (I_631 I_756) resistor r=3.725
    rI_71 (I_633 I_756) resistor r=3.725
    rI_70 (I_641 I_642) resistor r=27.0909
    rI_69 (I_641 I_761) resistor r=3.725
    rI_68 (I_642 I_756) resistor r=3.725
    rI_67 (I_647 I_761) resistor r=3.725
    rI_66 (I_649 I_761) resistor r=3.725
    rI_65 (I_661 I_662) resistor r=97.5273
    rI_64 (I_661 I_774) resistor r=3.725
    rI_63 (I_662 I_761) resistor r=3.725
    rI_62 (I_703 I_774) resistor r=3.725
    rI_61 (I_705 I_774) resistor r=3.725
    rI_60 (I_713 I_714) resistor r=27.0909
    rI_59 (I_713 I_779) resistor r=0.877078
    rI_58 (I_714 I_774) resistor r=3.725
    rI_57 (I_719 I_779) resistor r=10.0997
    rI_56 (I_721 I_779) resistor r=10.0997
    rI_55 (I_755 I_756) resistor r=3.725
ends CKBD16_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: CKBD1_LVT_ELT
// View name: calibre
subckt CKBD1_LVT_ELT I Z VDD VSS
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 \
        ps=4.76e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.31325e-13 pd=3.66e-06 \
        ps=9.4e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciZ_6 (Z_3 VSS) capacitor c=4.4736e-17
    ciZ_5 (Z_4 VSS) capacitor c=1.11612e-16
    ciZ_4 (Z_8 VSS) capacitor c=1.73883e-16
    ciZ_3 (Z_9 VSS) capacitor c=3.31535e-16
    ciZ_2 (Z VSS) capacitor c=7.84123e-17
    ciZ_1 (Z_23 VSS) capacitor c=2.47064e-17
    ciZ_0 (Z_27 VSS) capacitor c=1.7952e-17
    ciVDD_15 (VDD_4 VSS) capacitor c=1.30817e-16
    ciVDD_14 (VDD_13 VSS) capacitor c=4.7227e-17
    ciVDD_13 (VDD_14 VSS) capacitor c=2.63453e-17
    ciVDD_12 (VDD_20 VSS) capacitor c=1.97544e-16
    ciVDD_11 (VDD_31 VSS) capacitor c=6.80668e-17
    ciVDD_10 (VDD_39 VSS) capacitor c=3.58509e-18
    ciVDD_9 (VDD_46 VSS) capacitor c=1.11099e-18
    ciVDD_8 (VDD_47 VSS) capacitor c=3.18371e-18
    ciVDD_7 (VDD_48 VSS) capacitor c=2.31893e-18
    ciVDD_6 (VDD_51 VSS) capacitor c=1.6944e-17
    ciVDD_5 (VDD_55 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_56 VSS) capacitor c=5.8958e-18
    ciVDD_3 (VDD_57 VSS) capacitor c=3.57629e-18
    ciVDD_2 (VDD_60 VSS) capacitor c=1.62337e-17
    ciVDD_1 (VDD_61 VSS) capacitor c=2.16736e-16
    ciVDD_0 (VDD_62 VSS) capacitor c=2.43577e-16
    ciVSS_13 (VSS_4 VSS) capacitor c=5.35016e-17
    ciVSS_12 (VSS_10 VSS) capacitor c=4.54808e-17
    ciVSS_11 (VSS_11 VSS) capacitor c=2.63453e-17
    ciVSS_10 (VSS_17 VSS) capacitor c=8.23724e-17
    ciVSS_9 (VSS_25 VSS) capacitor c=6.58046e-17
    ciVSS_8 (VSS_33 VSS) capacitor c=3.58509e-18
    ciVSS_7 (VSS_39 VSS) capacitor c=2.56295e-18
    ciVSS_6 (VSS_40 VSS) capacitor c=1.95946e-18
    ciVSS_5 (VSS_43 VSS) capacitor c=2.55032e-18
    ciVSS_4 (VSS_48 VSS) capacitor c=5.8958e-18
    ciVSS_3 (VSS_49 VSS) capacitor c=2.31485e-18
    ciVSS_2 (VSS_52 VSS) capacitor c=1.96647e-18
    ciVSS_1 (VSS_53 VSS) capacitor c=6.9763e-17
    ciVSS_0 (VSS_54 VSS) capacitor c=7.75232e-17
    cinet11_23 (net11_22 VSS) capacitor c=4.28147e-18
    cinet11_22 (net11_28 VSS) capacitor c=1.94583e-16
    cinet11_21 (net11_39 VSS) capacitor c=5.87485e-16
    cinet11_20 (net11_45 VSS) capacitor c=4.43454e-18
    cinet11_19 (net11_50 VSS) capacitor c=2.23559e-17
    cinet11_18 (net11_58 VSS) capacitor c=1.51948e-17
    cinet11_17 (net11_66 VSS) capacitor c=2.02795e-17
    cinet11_16 (net11_74 VSS) capacitor c=1.2255e-17
    cinet11_15 (net11_82 VSS) capacitor c=2.11871e-18
    cinet11_14 (net11_85 VSS) capacitor c=3.9912e-18
    cinet11_13 (net11_90 VSS) capacitor c=4.02575e-18
    cinet11_12 (net11_93 VSS) capacitor c=2.22299e-18
    cinet11_11 (net11_133 VSS) capacitor c=4.07331e-17
    cinet11_10 (net11_134 VSS) capacitor c=1.13565e-16
    cinet11_9 (net11_138 VSS) capacitor c=1.61983e-16
    cinet11_8 (net11_139 VSS) capacitor c=3.41341e-16
    cinet11_7 (net11_148 VSS) capacitor c=2.48581e-17
    cinet11_6 (net11_150 VSS) capacitor c=2.89183e-17
    cinet11_5 (net11_153 VSS) capacitor c=6.32515e-17
    cinet11_4 (net11_158 VSS) capacitor c=2.87195e-17
    cinet11_3 (net11_162 VSS) capacitor c=2.20678e-17
    cinet11_2 (net11_164 VSS) capacitor c=1.73687e-17
    cinet11_1 (net11_223 VSS) capacitor c=2.80395e-17
    cinet11_0 (net11_224 VSS) capacitor c=1.55167e-17
    ciI_14 (I_22 VSS) capacitor c=3.00043e-18
    ciI_13 (I_28 VSS) capacitor c=2.07783e-16
    ciI_12 (I_39 VSS) capacitor c=6.29002e-16
    ciI_11 (I_45 VSS) capacitor c=3.44142e-18
    ciI_10 (I_50 VSS) capacitor c=2.23559e-17
    ciI_9 (I_58 VSS) capacitor c=2.02821e-17
    ciI_8 (I_66 VSS) capacitor c=1.21265e-17
    ciI_7 (I_74 VSS) capacitor c=1.51948e-17
    ciI_6 (I_82 VSS) capacitor c=3.24866e-18
    ciI_5 (I_85 VSS) capacitor c=4.86502e-18
    ciI_4 (I_90 VSS) capacitor c=5.13868e-18
    ciI_3 (I_93 VSS) capacitor c=3.65682e-18
    ciI_2 (I VSS) capacitor c=4.32267e-17
    ciI_1 (I_196 VSS) capacitor c=3.13771e-17
    ciI_0 (I_197 VSS) capacitor c=1.36036e-17
    rZ_26 (Z_1 Z_3) resistor r=0.303823
    rZ_25 (Z_1 Z_21) resistor r=0.0101022
    rZ_24 (Z_3 Z_4) resistor r=13
    rZ_23 (Z_4 MM15_ELT_d) resistor r=8.44
    rZ_22 (Z_6 Z_8) resistor r=0.341135
    rZ_21 (Z_6 Z_25) resistor r=0.0101022
    rZ_20 (Z_8 Z_9) resistor r=8.66667
    rZ_19 (Z_8 Z_11) resistor r=0.639628
    rZ_18 (Z_9 MM14_ELT_d) resistor r=32.3614
    rZ_17 (Z_11 Z_12) resistor r=8.66667
    rZ_16 (Z_11 Z_14) resistor r=0.426419
    rZ_15 (Z_12 MM14_ELT_d) resistor r=16.1807
    rZ_14 (Z_12 Z_15) resistor r=32.3614
    rZ_13 (Z_14 Z_15) resistor r=26
    rZ_12 (Z_17 Z) resistor r=0.15618
    rZ_11 (Z_17 Z_23) resistor r=0.0101022
    rZ_10 (Z_18 Z) resistor r=0.619252
    rZ_9 (Z_18 Z_27) resistor r=0.0101022
    rZ_8 (Z_21 Z_23) resistor r=0.126896
    rZ_7 (Z_25 Z_27) resistor r=0.126896
    rVDD_69 (MM14_ELT_b MM13_ELT_b) resistor r=0.01
    rVDD_68 (MM13_ELT_b VDD_31) resistor r=13
    rVDD_67 (MM13_ELT_b VDD_39) resistor r=8.66667
    rVDD_66 (MM13_ELT_b VDD_17) resistor r=56.2667
    rVDD_65 (VDD_2 VDD_11) resistor r=0.490382
    rVDD_64 (VDD_2 VDD_37) resistor r=0.119145
    rVDD_63 (VDD_4 VDD_12) resistor r=8.66667
    rVDD_62 (VDD_4 VDD_8) resistor r=0.639628
    rVDD_61 (VDD_8 VDD_12) resistor r=8.66667
    rVDD_60 (VDD_8 VDD_11) resistor r=0.639628
    rVDD_59 (VDD_11 VDD_12) resistor r=8.66667
    rVDD_58 (VDD_12 MM13_ELT_s) resistor r=1.847
    rVDD_57 (VDD_12 VDD_61) resistor r=20.317
    rVDD_56 (VDD_13 VDD_16) resistor r=0.221265
    rVDD_55 (VDD_13 VDD_39) resistor r=0.0221449
    rVDD_54 (VDD_14 VDD_16) resistor r=0.0335849
    rVDD_53 (VDD_14 VDD_37) resistor r=0.0177803
    rVDD_52 (VDD_16 VDD_17) resistor r=8.66667
    rVDD_51 (VDD_18 VDD_27) resistor r=0.490382
    rVDD_50 (VDD_18 VDD_39) resistor r=0.0882593
    rVDD_49 (VDD_20 VDD_28) resistor r=8.66667
    rVDD_48 (VDD_20 VDD_24) resistor r=0.639628
    rVDD_47 (VDD_24 VDD_28) resistor r=8.66667
    rVDD_46 (VDD_24 VDD_27) resistor r=0.639628
    rVDD_45 (VDD_27 VDD_28) resistor r=8.66667
    rVDD_44 (VDD_28 MM14_ELT_s) resistor r=1.847
    rVDD_43 (VDD_28 VDD_62) resistor r=20.317
    rVDD_42 (VDD_29 VDD_31) resistor r=0.138291
    rVDD_41 (VDD_29 VDD_39) resistor r=0.0221449
    rVDD_40 (VDD VDD_37) resistor r=0.0513652
    rVDD_39 (MM13_ELT_s VDD_46) resistor r=2.55965
    rVDD_38 (MM13_ELT_s VDD_48) resistor r=12.3172
    rVDD_37 (MM13_ELT_s VDD_48) resistor r=1.62887
    rVDD_36 (MM13_ELT_s VDD_51) resistor r=6.12113
    rVDD_35 (VDD_44 VDD_46) resistor r=14.4784
    rVDD_34 (VDD_44 VDD_50) resistor r=9.04062
    rVDD_33 (VDD_45 VDD_46) resistor r=14.4784
    rVDD_32 (VDD_45 VDD_61) resistor r=9.48555
    rVDD_31 (VDD_47 VDD_48) resistor r=12.3172
    rVDD_30 (VDD_47 VDD_49) resistor r=9.04595
    rVDD_29 (VDD_49 VDD_51) resistor r=31.2341
    rVDD_28 (VDD_50 VDD_51) resistor r=31.2341
    rVDD_27 (MM14_ELT_s VDD_55) resistor r=2.55965
    rVDD_26 (MM14_ELT_s VDD_57) resistor r=11.6604
    rVDD_25 (MM14_ELT_s VDD_57) resistor r=1.30988
    rVDD_24 (MM14_ELT_s VDD_60) resistor r=6.12113
    rVDD_23 (VDD_53 VDD_55) resistor r=14.4784
    rVDD_22 (VDD_53 VDD_59) resistor r=9.04062
    rVDD_21 (VDD_54 VDD_55) resistor r=14.4784
    rVDD_20 (VDD_54 VDD_62) resistor r=9.48555
    rVDD_19 (VDD_56 VDD_57) resistor r=11.6604
    rVDD_18 (VDD_56 VDD_58) resistor r=9.04595
    rVDD_17 (VDD_58 VDD_60) resistor r=31.2341
    rVDD_16 (VDD_59 VDD_60) resistor r=31.2341
    rVSS_63 (MM15_ELT_b MM12_ELT_b) resistor r=0.01
    rVSS_62 (MM12_ELT_b VSS_25) resistor r=13
    rVSS_61 (MM12_ELT_b VSS_33) resistor r=8.66667
    rVSS_60 (MM12_ELT_b VSS_14) resistor r=53.9357
    rVSS_59 (VSS_2 VSS_4) resistor r=0.399768
    rVSS_58 (VSS_2 VSS_31) resistor r=0.119145
    rVSS_57 (VSS_4 VSS_8) resistor r=8.66667
    rVSS_56 (VSS_4 VSS_7) resistor r=0.426419
    rVSS_55 (VSS_7 VSS_8) resistor r=26
    rVSS_54 (VSS_8 MM12_ELT_s) resistor r=2.90692
    rVSS_53 (VSS_8 VSS_53) resistor r=12.1406
    rVSS_52 (VSS_10 VSS_13) resistor r=0.221265
    rVSS_51 (VSS_10 VSS_33) resistor r=0.0221449
    rVSS_50 (VSS_11 VSS_13) resistor r=0.0335849
    rVSS_49 (VSS_11 VSS_31) resistor r=0.0177803
    rVSS_48 (VSS_13 VSS_14) resistor r=8.66667
    rVSS_47 (VSS_15 VSS_17) resistor r=0.399768
    rVSS_46 (VSS_15 VSS_33) resistor r=0.0882593
    rVSS_45 (VSS_17 VSS_21) resistor r=8.66667
    rVSS_44 (VSS_17 VSS_20) resistor r=0.432805
    rVSS_43 (VSS_20 VSS_21) resistor r=26
    rVSS_42 (VSS_21 MM15_ELT_s) resistor r=2.90692
    rVSS_41 (VSS_21 VSS_54) resistor r=12.1406
    rVSS_40 (VSS_23 VSS_25) resistor r=0.138291
    rVSS_39 (VSS_23 VSS_33) resistor r=0.0221449
    rVSS_38 (VSS VSS_31) resistor r=0.0493896
    rVSS_37 (MM12_ELT_s VSS_38) resistor r=2.67027
    rVSS_36 (MM12_ELT_s VSS_40) resistor r=12.8495
    rVSS_35 (MM12_ELT_s VSS_40) resistor r=1.69926
    rVSS_34 (MM12_ELT_s VSS_43) resistor r=4.557
    rVSS_33 (VSS_36 VSS_38) resistor r=15.1041
    rVSS_32 (VSS_36 VSS_41) resistor r=9.43134
    rVSS_31 (VSS_37 VSS_38) resistor r=15.1041
    rVSS_30 (VSS_37 VSS_53) resistor r=9.89549
    rVSS_29 (VSS_39 VSS_40) resistor r=12.8495
    rVSS_28 (VSS_39 VSS_42) resistor r=9.4369
    rVSS_27 (VSS_41 VSS_43) resistor r=21.1301
    rVSS_26 (VSS_42 VSS_43) resistor r=21.1301
    rVSS_25 (MM15_ELT_s VSS_47) resistor r=2.67027
    rVSS_24 (MM15_ELT_s VSS_49) resistor r=12.1643
    rVSS_23 (MM15_ELT_s VSS_49) resistor r=1.36649
    rVSS_22 (MM15_ELT_s VSS_52) resistor r=4.557
    rVSS_21 (VSS_45 VSS_47) resistor r=15.1041
    rVSS_20 (VSS_45 VSS_50) resistor r=9.43134
    rVSS_19 (VSS_46 VSS_47) resistor r=15.1041
    rVSS_18 (VSS_46 VSS_54) resistor r=9.89549
    rVSS_17 (VSS_48 VSS_49) resistor r=12.1643
    rVSS_16 (VSS_48 VSS_51) resistor r=9.4369
    rVSS_15 (VSS_50 VSS_52) resistor r=21.1301
    rVSS_14 (VSS_51 VSS_52) resistor r=21.1301
    rnet11_129 (MM13_ELT_d net11) resistor r=0.01
    rnet11_128 (net11_22 net11_28) resistor r=58.3583
    rnet11_127 (net11_22 net11_28) resistor r=4.16253
    rnet11_126 (net11_22 net11_28) resistor r=58.3583
    rnet11_125 (net11_22 net11_28) resistor r=4.16253
    rnet11_124 (net11_25 net11_28) resistor r=58.3583
    rnet11_123 (net11_25 net11_28) resistor r=5.53947
    rnet11_122 (net11_25 net11_28) resistor r=58.3583
    rnet11_121 (net11_25 net11_28) resistor r=5.53947
    rnet11_120 (net11_28 net11_30) resistor r=11.175
    rnet11_119 (net11_28 net11_53) resistor r=24.8333
    rnet11_118 (net11_28 net11_50) resistor r=24.8333
    rnet11_117 (net11_28 net11_69) resistor r=22.35
    rnet11_116 (net11_28 net11_66) resistor r=22.35
    rnet11_115 (net11_28 net11_82) resistor r=58.3583
    rnet11_114 (net11_28 net11_85) resistor r=58.3583
    rnet11_113 (net11_28 net11_53) resistor r=4.16253
    rnet11_112 (net11_28 net11_30) resistor r=5.53947
    rnet11_111 (net11_28 net11_69) resistor r=2.32428
    rnet11_110 (net11_28 net11_50) resistor r=4.16253
    rnet11_109 (net11_28 net11_82) resistor r=4.16253
    rnet11_108 (net11_28 net11_66) resistor r=4.16253
    rnet11_107 (net11_28 net11_85) resistor r=4.16253
    rnet11_106 (net11_28 net11_30) resistor r=11.175
    rnet11_105 (net11_28 net11_189) resistor r=30.7313
    rnet11_104 (net11_28 net11_53) resistor r=24.8333
    rnet11_103 (net11_28 net11_50) resistor r=24.8333
    rnet11_102 (net11_28 net11_69) resistor r=22.35
    rnet11_101 (net11_28 net11_66) resistor r=22.35
    rnet11_100 (net11_28 net11_82) resistor r=58.3583
    rnet11_99 (net11_28 MM15_ELT_g) resistor r=7.45
    rnet11_98 (net11_28 net11_53) resistor r=4.16253
    rnet11_97 (net11_28 net11_30) resistor r=5.53947
    rnet11_96 (net11_28 net11_69) resistor r=2.32428
    rnet11_95 (net11_28 net11_50) resistor r=4.16253
    rnet11_94 (net11_28 net11_82) resistor r=4.16253
    rnet11_93 (net11_28 net11_66) resistor r=4.16253
    rnet11_92 (net11_28 net11_85) resistor r=4.16253
    rnet11_91 (net11_36 net11_39) resistor r=11.175
    rnet11_90 (net11_36 net11_39) resistor r=5.53947
    rnet11_89 (net11_36 net11_39) resistor r=11.175
    rnet11_88 (net11_36 net11_39) resistor r=5.53947
    rnet11_87 (net11_39 net11_42) resistor r=202.392
    rnet11_86 (net11_39 net11_45) resistor r=202.392
    rnet11_85 (net11_39 net11_61) resistor r=24.8333
    rnet11_84 (net11_39 net11_58) resistor r=24.8333
    rnet11_83 (net11_39 net11_77) resistor r=22.35
    rnet11_82 (net11_39 net11_74) resistor r=22.35
    rnet11_81 (net11_39 net11_90) resistor r=202.392
    rnet11_80 (net11_39 net11_93) resistor r=202.392
    rnet11_79 (net11_39 net11_42) resistor r=5.53947
    rnet11_78 (net11_39 net11_77) resistor r=2.32428
    rnet11_77 (net11_39 net11_61) resistor r=4.16253
    rnet11_76 (net11_39 net11_45) resistor r=4.16253
    rnet11_75 (net11_39 net11_74) resistor r=4.16253
    rnet11_74 (net11_39 net11_90) resistor r=4.16253
    rnet11_73 (net11_39 net11_58) resistor r=4.16253
    rnet11_72 (net11_39 net11_93) resistor r=4.16253
    rnet11_71 (net11_39 net11_191) resistor r=30.7313
    rnet11_70 (net11_39 net11_42) resistor r=202.392
    rnet11_69 (net11_39 net11_45) resistor r=202.392
    rnet11_68 (net11_39 net11_61) resistor r=24.8333
    rnet11_67 (net11_39 net11_58) resistor r=24.8333
    rnet11_66 (net11_39 net11_77) resistor r=22.35
    rnet11_65 (net11_39 net11_74) resistor r=22.35
    rnet11_64 (net11_39 net11_90) resistor r=202.392
    rnet11_63 (net11_39 MM14_ELT_g) resistor r=7.45
    rnet11_62 (net11_39 net11_42) resistor r=5.53947
    rnet11_61 (net11_39 net11_77) resistor r=2.32428
    rnet11_60 (net11_39 net11_61) resistor r=4.16253
    rnet11_59 (net11_39 net11_45) resistor r=4.16253
    rnet11_58 (net11_39 net11_74) resistor r=4.16253
    rnet11_57 (net11_39 net11_90) resistor r=4.16253
    rnet11_56 (net11_39 net11_58) resistor r=4.16253
    rnet11_55 (net11_39 net11_93) resistor r=4.16253
    rnet11_54 (net11_85 MM15_ELT_g) resistor r=50.9083
    rnet11_53 (net11_93 MM14_ELT_g) resistor r=194.942
    rnet11_52 (net11_131 net11_133) resistor r=0.303823
    rnet11_51 (net11_131 net11_156) resistor r=0.0101022
    rnet11_50 (net11_133 net11_134) resistor r=13
    rnet11_49 (net11_134 MM12_ELT_d) resistor r=8.44
    rnet11_48 (net11_136 net11_138) resistor r=0.341135
    rnet11_47 (net11_136 net11_160) resistor r=0.0101022
    rnet11_46 (net11_138 net11_139) resistor r=8.66667
    rnet11_45 (net11_138 net11_141) resistor r=0.639628
    rnet11_44 (net11_139 net11) resistor r=32.3614
    rnet11_43 (net11_141 net11_142) resistor r=8.66667
    rnet11_42 (net11_141 net11_144) resistor r=0.426419
    rnet11_41 (net11_142 net11) resistor r=16.1807
    rnet11_40 (net11_142 net11_145) resistor r=32.3614
    rnet11_39 (net11_144 net11_145) resistor r=26
    rnet11_38 (net11_147 net11_148) resistor r=0.212834
    rnet11_37 (net11_147 net11_158) resistor r=0.0101022
    rnet11_36 (net11_148 net11_164) resistor r=0.119095
    rnet11_35 (net11_149 net11_150) resistor r=0.257381
    rnet11_34 (net11_149 net11_164) resistor r=0.119095
    rnet11_33 (net11_150 net11_162) resistor r=0.0101022
    rnet11_32 (net11_151 net11_153) resistor r=0.266961
    rnet11_31 (net11_151 net11_164) resistor r=0.0120267
    rnet11_30 (net11_153 net11_154) resistor r=10
    rnet11_29 (net11_154 net11_223) resistor r=12.1909
    rnet11_28 (net11_156 net11_158) resistor r=0.131777
    rnet11_27 (net11_160 net11_162) resistor r=0.131777
    rnet11_26 (net11_189 net11_224) resistor r=3.725
    rnet11_25 (net11_191 net11_224) resistor r=3.725
    rnet11_24 (net11_223 net11_224) resistor r=3.725
    rI_96 (I_22 I_28) resistor r=58.3583
    rI_95 (I_22 I_28) resistor r=4.16253
    rI_94 (I_22 I_28) resistor r=58.3583
    rI_93 (I_22 I_28) resistor r=4.16253
    rI_92 (I_25 I_28) resistor r=58.3583
    rI_91 (I_25 I_28) resistor r=6.30933
    rI_90 (I_25 I_28) resistor r=58.3583
    rI_89 (I_25 I_28) resistor r=6.30933
    rI_88 (I_28 I_30) resistor r=14.9
    rI_87 (I_28 I_53) resistor r=24.8333
    rI_86 (I_28 I_50) resistor r=24.8333
    rI_85 (I_28 I_61) resistor r=24.8333
    rI_84 (I_28 I_58) resistor r=24.8333
    rI_83 (I_28 I_82) resistor r=58.3583
    rI_82 (I_28 I_85) resistor r=58.3583
    rI_81 (I_28 I_53) resistor r=4.16253
    rI_80 (I_28 I_30) resistor r=6.30933
    rI_79 (I_28 I_61) resistor r=1.63969
    rI_78 (I_28 I_50) resistor r=4.16253
    rI_77 (I_28 I_82) resistor r=4.16253
    rI_76 (I_28 I_58) resistor r=4.16253
    rI_75 (I_28 I_85) resistor r=4.16253
    rI_74 (I_28 I_30) resistor r=14.9
    rI_73 (I_28 I_162) resistor r=40.975
    rI_72 (I_28 I_53) resistor r=24.8333
    rI_71 (I_28 I_50) resistor r=24.8333
    rI_70 (I_28 I_61) resistor r=24.8333
    rI_69 (I_28 I_58) resistor r=24.8333
    rI_68 (I_28 I_82) resistor r=58.3583
    rI_67 (I_28 MM12_ELT_g) resistor r=7.45
    rI_66 (I_28 I_53) resistor r=4.16253
    rI_65 (I_28 I_30) resistor r=6.30933
    rI_64 (I_28 I_61) resistor r=1.63969
    rI_63 (I_28 I_50) resistor r=4.16253
    rI_62 (I_28 I_82) resistor r=4.16253
    rI_61 (I_28 I_58) resistor r=4.16253
    rI_60 (I_28 I_85) resistor r=4.16253
    rI_59 (I_36 I_39) resistor r=14.9
    rI_58 (I_36 I_39) resistor r=6.30933
    rI_57 (I_36 I_39) resistor r=14.9
    rI_56 (I_36 I_39) resistor r=6.30933
    rI_55 (I_39 I_42) resistor r=202.392
    rI_54 (I_39 I_45) resistor r=202.392
    rI_53 (I_39 I_69) resistor r=24.8333
    rI_52 (I_39 I_66) resistor r=24.8333
    rI_51 (I_39 I_77) resistor r=24.8333
    rI_50 (I_39 I_74) resistor r=24.8333
    rI_49 (I_39 I_90) resistor r=202.392
    rI_48 (I_39 I_93) resistor r=202.392
    rI_47 (I_39 I_42) resistor r=6.30933
    rI_46 (I_39 I_69) resistor r=1.63969
    rI_45 (I_39 I_77) resistor r=4.16253
    rI_44 (I_39 I_45) resistor r=4.16253
    rI_43 (I_39 I_66) resistor r=4.16253
    rI_42 (I_39 I_90) resistor r=4.16253
    rI_41 (I_39 I_74) resistor r=4.16253
    rI_40 (I_39 I_93) resistor r=4.16253
    rI_39 (I_39 I_164) resistor r=40.975
    rI_38 (I_39 I_42) resistor r=202.392
    rI_37 (I_39 I_45) resistor r=202.392
    rI_36 (I_39 I_69) resistor r=24.8333
    rI_35 (I_39 I_66) resistor r=24.8333
    rI_34 (I_39 I_77) resistor r=24.8333
    rI_33 (I_39 I_74) resistor r=24.8333
    rI_32 (I_39 I_90) resistor r=202.392
    rI_31 (I_39 MM13_ELT_g) resistor r=7.45
    rI_30 (I_39 I_42) resistor r=6.30933
    rI_29 (I_39 I_69) resistor r=1.63969
    rI_28 (I_39 I_77) resistor r=4.16253
    rI_27 (I_39 I_45) resistor r=4.16253
    rI_26 (I_39 I_66) resistor r=4.16253
    rI_25 (I_39 I_90) resistor r=4.16253
    rI_24 (I_39 I_74) resistor r=4.16253
    rI_23 (I_39 I_93) resistor r=4.16253
    rI_22 (I_85 MM12_ELT_g) resistor r=50.9083
    rI_21 (I_93 MM13_ELT_g) resistor r=194.942
    rI_20 (I_132 I_133) resistor r=10
    rI_19 (I_132 I) resistor r=0.087528
    rI_18 (I_133 I_196) resistor r=13.5455
    rI_17 (I_162 I_197) resistor r=3.725
    rI_16 (I_164 I_197) resistor r=3.725
    rI_15 (I_196 I_197) resistor r=3.725
ends CKBD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: CKBD4_LVT_ELT
// View name: calibre
subckt CKBD4_LVT_ELT I Z VDD VSS
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.37125e-13 pd=1.34e-06 \
        ps=3.265e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.37125e-13 pd=1.34e-06 \
        ps=3.265e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.37125e-13 pd=1.34e-06 \
        ps=3.265e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.37125e-13 pd=1.34e-06 \
        ps=3.265e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.37125e-13 pd=1.34e-06 \
        ps=3.265e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.37125e-13 pd=1.34e-06 \
        ps=3.265e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.74925e-13 pd=3.66e-06 \
        ps=5.97167e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.74925e-13 pd=3.66e-06 \
        ps=5.97167e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.74925e-13 pd=3.66e-06 \
        ps=5.97167e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.74925e-13 pd=3.66e-06 \
        ps=5.97167e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.74925e-13 pd=3.66e-06 \
        ps=5.97167e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.74925e-13 pd=3.66e-06 \
        ps=5.97167e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    ciZ_30 (Z_3 VSS) capacitor c=6.77659e-17
    ciZ_29 (Z_4 VSS) capacitor c=1.17382e-16
    ciZ_28 (Z_8 VSS) capacitor c=2.37118e-16
    ciZ_27 (Z_9 VSS) capacitor c=3.53834e-16
    ciZ_26 (Z_17 VSS) capacitor c=7.15493e-17
    ciZ_25 (Z_18 VSS) capacitor c=1.81918e-17
    ciZ_24 (Z_19 VSS) capacitor c=6.98722e-17
    ciZ_23 (Z_20 VSS) capacitor c=1.71849e-17
    ciZ_22 (Z_23 VSS) capacitor c=6.60866e-17
    ciZ_21 (Z_24 VSS) capacitor c=1.1736e-16
    ciZ_20 (Z_28 VSS) capacitor c=2.35468e-16
    ciZ_19 (Z_29 VSS) capacitor c=3.53761e-16
    ciZ_18 (Z_37 VSS) capacitor c=8.77943e-17
    ciZ_17 (Z_39 VSS) capacitor c=8.63041e-17
    ciZ_16 (Z_43 VSS) capacitor c=6.60866e-17
    ciZ_15 (Z_44 VSS) capacitor c=1.1736e-16
    ciZ_14 (Z_48 VSS) capacitor c=2.35468e-16
    ciZ_13 (Z_49 VSS) capacitor c=3.53761e-16
    ciZ_12 (Z_57 VSS) capacitor c=6.61783e-17
    ciZ_11 (Z_59 VSS) capacitor c=6.26086e-17
    ciZ_10 (Z_63 VSS) capacitor c=4.75256e-17
    ciZ_9 (Z_64 VSS) capacitor c=1.1105e-16
    ciZ_8 (Z VSS) capacitor c=5.10482e-17
    ciZ_7 (Z_72 VSS) capacitor c=1.73839e-16
    ciZ_6 (Z_73 VSS) capacitor c=3.2943e-16
    ciZ_5 (Z_81 VSS) capacitor c=1.21398e-17
    ciZ_4 (Z_82 VSS) capacitor c=1.18284e-17
    ciZ_3 (Z_83 VSS) capacitor c=1.21398e-17
    ciZ_2 (Z_84 VSS) capacitor c=1.18284e-17
    ciZ_1 (Z_85 VSS) capacitor c=2.94128e-17
    ciZ_0 (Z_87 VSS) capacitor c=3.52929e-17
    ciVDD_41 (VDD_2 VSS) capacitor c=6.33959e-17
    ciVDD_40 (VDD_11 VSS) capacitor c=2.45926e-16
    ciVDD_39 (VDD_19 VSS) capacitor c=2.35046e-17
    ciVDD_38 (VDD_20 VSS) capacitor c=2.99239e-17
    ciVDD_37 (VDD_27 VSS) capacitor c=2.36325e-16
    ciVDD_36 (VDD_35 VSS) capacitor c=1.64325e-17
    ciVDD_35 (VDD_36 VSS) capacitor c=2.99239e-17
    ciVDD_34 (VDD_43 VSS) capacitor c=2.41628e-16
    ciVDD_33 (VDD_51 VSS) capacitor c=1.91089e-17
    ciVDD_32 (VDD_52 VSS) capacitor c=2.99239e-17
    ciVDD_31 (VDD_59 VSS) capacitor c=2.41628e-16
    ciVDD_30 (VDD_67 VSS) capacitor c=2.40827e-17
    ciVDD_29 (VDD_68 VSS) capacitor c=2.99239e-17
    ciVDD_28 (VDD_72 VSS) capacitor c=2.4725e-16
    ciVDD_27 (VDD_80 VSS) capacitor c=1.91089e-17
    ciVDD_26 (VDD_83 VSS) capacitor c=6.72865e-17
    ciVDD_25 (VDD_86 VSS) capacitor c=3.58509e-18
    ciVDD_24 (VDD_87 VSS) capacitor c=3.58509e-18
    ciVDD_23 (VDD_88 VSS) capacitor c=3.58509e-18
    ciVDD_22 (VDD_89 VSS) capacitor c=3.58509e-18
    ciVDD_21 (VDD_91 VSS) capacitor c=3.58509e-18
    ciVDD_20 (VDD_98 VSS) capacitor c=1.32762e-17
    ciVDD_19 (VDD_100 VSS) capacitor c=4.26933e-18
    ciVDD_18 (VDD_103 VSS) capacitor c=1.11099e-18
    ciVDD_17 (VDD_107 VSS) capacitor c=1.11099e-18
    ciVDD_16 (VDD_109 VSS) capacitor c=4.64503e-18
    ciVDD_15 (VDD_113 VSS) capacitor c=1.11099e-18
    ciVDD_14 (VDD_115 VSS) capacitor c=4.39776e-18
    ciVDD_13 (VDD_118 VSS) capacitor c=3.41486e-18
    ciVDD_12 (VDD_121 VSS) capacitor c=1.11099e-18
    ciVDD_11 (VDD_125 VSS) capacitor c=1.11099e-18
    ciVDD_10 (VDD_127 VSS) capacitor c=3.41486e-18
    ciVDD_9 (MM14_ELT_s VSS) capacitor c=1.75793e-17
    ciVDD_8 (VDD_130 VSS) capacitor c=2.62825e-18
    ciVDD_7 (VDD_133 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_136 VSS) capacitor c=3.75299e-16
    ciVDD_5 (VDD_140 VSS) capacitor c=3.73768e-16
    ciVDD_4 (VDD_142 VSS) capacitor c=1.79226e-18
    ciVDD_3 (VDD_144 VSS) capacitor c=3.76541e-16
    ciVDD_2 (VDD_146 VSS) capacitor c=3.76541e-16
    ciVDD_1 (VDD_148 VSS) capacitor c=1.79226e-18
    ciVDD_0 (VDD_150 VSS) capacitor c=3.76541e-16
    ciVSS_29 (VSS_2 VSS) capacitor c=6.18944e-17
    ciVSS_28 (VSS_11 VSS) capacitor c=7.4056e-17
    ciVSS_27 (VSS_12 VSS) capacitor c=1.23595e-16
    ciVSS_26 (VSS_14 VSS) capacitor c=2.86956e-17
    ciVSS_25 (VSS_21 VSS) capacitor c=6.62264e-17
    ciVSS_24 (VSS_22 VSS) capacitor c=1.15631e-16
    ciVSS_23 (VSS_24 VSS) capacitor c=2.86956e-17
    ciVSS_22 (VSS_31 VSS) capacitor c=7.16887e-17
    ciVSS_21 (VSS_32 VSS) capacitor c=1.20772e-16
    ciVSS_20 (VSS_34 VSS) capacitor c=2.86956e-17
    ciVSS_19 (VSS_41 VSS) capacitor c=7.16887e-17
    ciVSS_18 (VSS_42 VSS) capacitor c=1.25763e-16
    ciVSS_17 (VSS_44 VSS) capacitor c=2.86956e-17
    ciVSS_16 (VSS_48 VSS) capacitor c=7.60881e-17
    ciVSS_15 (VSS_49 VSS) capacitor c=1.21868e-16
    ciVSS_14 (VSS_53 VSS) capacitor c=6.52483e-17
    ciVSS_13 (VSS_56 VSS) capacitor c=3.58509e-18
    ciVSS_12 (VSS_57 VSS) capacitor c=3.58509e-18
    ciVSS_11 (VSS_58 VSS) capacitor c=3.58509e-18
    ciVSS_10 (VSS_59 VSS) capacitor c=3.58509e-18
    ciVSS_9 (VSS_61 VSS) capacitor c=3.58509e-18
    ciVSS_8 (VSS_71 VSS) capacitor c=3.14446e-18
    ciVSS_7 (VSS_77 VSS) capacitor c=3.54201e-18
    ciVSS_6 (VSS_83 VSS) capacitor c=3.29332e-18
    ciVSS_5 (VSS_89 VSS) capacitor c=2.31042e-18
    ciVSS_4 (VSS_95 VSS) capacitor c=2.31042e-18
    ciVSS_3 (MM15_ELT_s VSS) capacitor c=3.51765e-18
    ciVSS_2 (VSS_101 VSS) capacitor c=1.50446e-18
    ciVSS_1 (VSS_112 VSS) capacitor c=1.80133e-18
    ciVSS_0 (VSS_118 VSS) capacitor c=1.80133e-18
    cinet11_74 (net11_82 VSS) capacitor c=3.00043e-18
    cinet11_73 (net11_88 VSS) capacitor c=2.47633e-16
    cinet11_72 (net11_99 VSS) capacitor c=7.70883e-16
    cinet11_71 (net11_105 VSS) capacitor c=3.00043e-18
    cinet11_70 (net11_110 VSS) capacitor c=2.2416e-17
    cinet11_69 (net11_118 VSS) capacitor c=1.99976e-17
    cinet11_68 (net11_126 VSS) capacitor c=1.34072e-17
    cinet11_67 (net11_134 VSS) capacitor c=1.51948e-17
    cinet11_66 (net11_142 VSS) capacitor c=3.00043e-18
    cinet11_65 (net11_145 VSS) capacitor c=3.24288e-18
    cinet11_64 (net11_150 VSS) capacitor c=2.75982e-18
    cinet11_63 (net11_153 VSS) capacitor c=3.00043e-18
    cinet11_62 (net11_158 VSS) capacitor c=3.00043e-18
    cinet11_61 (net11_161 VSS) capacitor c=3.24288e-18
    cinet11_60 (net11_164 VSS) capacitor c=2.40662e-16
    cinet11_59 (net11_166 VSS) capacitor c=2.75982e-18
    cinet11_58 (net11_169 VSS) capacitor c=3.00043e-18
    cinet11_57 (net11_172 VSS) capacitor c=7.64189e-16
    cinet11_56 (net11_174 VSS) capacitor c=2.2416e-17
    cinet11_55 (net11_182 VSS) capacitor c=2.10003e-17
    cinet11_54 (net11_190 VSS) capacitor c=1.45586e-17
    cinet11_53 (net11_198 VSS) capacitor c=1.51948e-17
    cinet11_52 (net11_206 VSS) capacitor c=3.00043e-18
    cinet11_51 (net11_229 VSS) capacitor c=3.00043e-18
    cinet11_50 (net11_234 VSS) capacitor c=3.00043e-18
    cinet11_49 (net11_240 VSS) capacitor c=2.40752e-16
    cinet11_48 (net11_251 VSS) capacitor c=7.64278e-16
    cinet11_47 (net11_257 VSS) capacitor c=3.00043e-18
    cinet11_46 (net11_262 VSS) capacitor c=2.2416e-17
    cinet11_45 (net11_270 VSS) capacitor c=2.10003e-17
    cinet11_44 (net11_278 VSS) capacitor c=1.45586e-17
    cinet11_43 (net11_286 VSS) capacitor c=1.51948e-17
    cinet11_42 (net11_294 VSS) capacitor c=3.00043e-18
    cinet11_41 (net11_297 VSS) capacitor c=3.24095e-18
    cinet11_40 (net11_302 VSS) capacitor c=2.75982e-18
    cinet11_39 (net11_305 VSS) capacitor c=3.00043e-18
    cinet11_38 (net11_310 VSS) capacitor c=4.24886e-18
    cinet11_37 (net11_313 VSS) capacitor c=3.1195e-18
    cinet11_36 (net11_316 VSS) capacitor c=1.86446e-16
    cinet11_35 (net11_318 VSS) capacitor c=2.89979e-18
    cinet11_34 (net11_321 VSS) capacitor c=4.28147e-18
    cinet11_33 (net11_324 VSS) capacitor c=5.73739e-16
    cinet11_32 (net11_326 VSS) capacitor c=2.23559e-17
    cinet11_31 (net11_334 VSS) capacitor c=2.27059e-17
    cinet11_30 (net11_342 VSS) capacitor c=1.64637e-17
    cinet11_29 (net11_350 VSS) capacitor c=1.51948e-17
    cinet11_28 (net11_358 VSS) capacitor c=2.11871e-18
    cinet11_27 (net11_381 VSS) capacitor c=2.22299e-18
    cinet11_26 (net11_523 VSS) capacitor c=5.7393e-17
    cinet11_25 (net11_524 VSS) capacitor c=1.11612e-16
    cinet11_24 (net11_528 VSS) capacitor c=1.90215e-16
    cinet11_23 (net11_529 VSS) capacitor c=3.2986e-16
    cinet11_22 (net11_537 VSS) capacitor c=1.49104e-17
    cinet11_21 (net11_538 VSS) capacitor c=1.11989e-17
    cinet11_20 (net11_539 VSS) capacitor c=1.47567e-17
    cinet11_19 (net11_540 VSS) capacitor c=1.11989e-17
    cinet11_18 (net11_542 VSS) capacitor c=1.76069e-18
    cinet11_17 (net11_544 VSS) capacitor c=1.76069e-18
    cinet11_16 (net11_545 VSS) capacitor c=1.05073e-17
    cinet11_15 (net11_555 VSS) capacitor c=3.73691e-16
    cinet11_14 (net11_558 VSS) capacitor c=1.05476e-17
    cinet11_13 (net11_562 VSS) capacitor c=7.17012e-17
    cinet11_12 (net11_563 VSS) capacitor c=1.1682e-16
    cinet11_11 (net11_567 VSS) capacitor c=2.39915e-16
    cinet11_10 (net11_568 VSS) capacitor c=3.53405e-16
    cinet11_9 (net11_576 VSS) capacitor c=1.29022e-17
    cinet11_8 (net11_577 VSS) capacitor c=2.32907e-17
    cinet11_7 (net11_578 VSS) capacitor c=1.35433e-17
    cinet11_6 (net11_798 VSS) capacitor c=3.46855e-18
    cinet11_5 (net11_812 VSS) capacitor c=5.4682e-17
    cinet11_4 (net11_813 VSS) capacitor c=7.12206e-19
    cinet11_3 (net11_819 VSS) capacitor c=1.78365e-17
    cinet11_2 (net11_820 VSS) capacitor c=7.12206e-19
    cinet11_1 (net11_833 VSS) capacitor c=6.34877e-17
    cinet11_0 (net11_834 VSS) capacitor c=6.69133e-18
    ciI_26 (I_42 VSS) capacitor c=2.22299e-18
    ciI_25 (I_48 VSS) capacitor c=1.77256e-16
    ciI_24 (I_53 VSS) capacitor c=2.22299e-18
    ciI_23 (I_56 VSS) capacitor c=5.61723e-16
    ciI_22 (I_58 VSS) capacitor c=2.2416e-17
    ciI_21 (I_66 VSS) capacitor c=2.01409e-17
    ciI_20 (I_74 VSS) capacitor c=1.36965e-17
    ciI_19 (I_82 VSS) capacitor c=1.51948e-17
    ciI_18 (I_90 VSS) capacitor c=4.2527e-18
    ciI_17 (I_113 VSS) capacitor c=4.28147e-18
    ciI_16 (I_118 VSS) capacitor c=3.00043e-18
    ciI_15 (I_124 VSS) capacitor c=2.51351e-16
    ciI_14 (I_135 VSS) capacitor c=7.74539e-16
    ciI_13 (I_141 VSS) capacitor c=3.00043e-18
    ciI_12 (I_146 VSS) capacitor c=2.2416e-17
    ciI_11 (I_154 VSS) capacitor c=2.27015e-17
    ciI_10 (I_162 VSS) capacitor c=1.62571e-17
    ciI_9 (I_170 VSS) capacitor c=1.51948e-17
    ciI_8 (I_178 VSS) capacitor c=3.00043e-18
    ciI_7 (I_181 VSS) capacitor c=4.61887e-18
    ciI_6 (I_186 VSS) capacitor c=4.61887e-18
    ciI_5 (I_189 VSS) capacitor c=3.00043e-18
    ciI_4 (I VSS) capacitor c=3.88557e-17
    ciI_3 (I_342 VSS) capacitor c=2.64718e-17
    ciI_2 (I_384 VSS) capacitor c=2.69114e-17
    ciI_1 (I_385 VSS) capacitor c=7.12206e-19
    ciI_0 (I_390 VSS) capacitor c=8.39527e-18
    rZ_106 (Z_1 Z_3) resistor r=0.439215
    rZ_105 (Z_1 Z_18) resistor r=0.0991339
    rZ_104 (Z_3 Z_4) resistor r=13
    rZ_103 (Z_4 MM5_ELT_d) resistor r=8.44
    rZ_102 (Z_6 Z_8) resistor r=0.550482
    rZ_101 (Z_6 Z_20) resistor r=0.0972523
    rZ_100 (Z_8 Z_9) resistor r=8.66667
    rZ_99 (Z_8 Z_11) resistor r=0.702743
    rZ_98 (Z_9 MM6_ELT_d) resistor r=32.3614
    rZ_97 (Z_11 Z_12) resistor r=8.66667
    rZ_96 (Z_11 Z_14) resistor r=0.468495
    rZ_95 (Z_12 MM6_ELT_d) resistor r=16.1807
    rZ_94 (Z_12 Z_15) resistor r=32.3614
    rZ_93 (Z_14 Z_15) resistor r=26
    rZ_92 (Z_17 Z_18) resistor r=0.530412
    rZ_91 (Z_17 Z_81) resistor r=0.0547949
    rZ_90 (Z_19 Z_20) resistor r=0.625145
    rZ_89 (Z_19 Z_82) resistor r=0.061375
    rZ_88 (Z_21 Z_23) resistor r=0.439215
    rZ_87 (Z_21 Z_81) resistor r=0.0360627
    rZ_86 (Z_23 Z_24) resistor r=13
    rZ_85 (Z_24 MM4_ELT_d) resistor r=8.44
    rZ_84 (Z_26 Z_28) resistor r=0.550482
    rZ_83 (Z_26 Z_82) resistor r=0.0293231
    rZ_82 (Z_28 Z_29) resistor r=8.66667
    rZ_81 (Z_28 Z_31) resistor r=0.702743
    rZ_80 (Z_29 MM2_ELT_d) resistor r=32.3614
    rZ_79 (Z_31 Z_32) resistor r=8.66667
    rZ_78 (Z_31 Z_34) resistor r=0.468495
    rZ_77 (Z_32 MM2_ELT_d) resistor r=16.1807
    rZ_76 (Z_32 Z_35) resistor r=32.3614
    rZ_75 (Z_34 Z_35) resistor r=26
    rZ_74 (Z_37 Z_38) resistor r=0.530412
    rZ_73 (Z_37 Z_83) resistor r=0.0547949
    rZ_72 (Z_38 Z_81) resistor r=0.0547949
    rZ_71 (Z_39 Z_40) resistor r=0.625145
    rZ_70 (Z_39 Z_84) resistor r=0.061375
    rZ_69 (Z_40 Z_82) resistor r=0.061375
    rZ_68 (Z_41 Z_43) resistor r=0.439215
    rZ_67 (Z_41 Z_83) resistor r=0.0360627
    rZ_66 (Z_43 Z_44) resistor r=13
    rZ_65 (Z_44 MM1_ELT_d) resistor r=8.44
    rZ_64 (Z_46 Z_48) resistor r=0.550482
    rZ_63 (Z_46 Z_84) resistor r=0.0293231
    rZ_62 (Z_48 Z_49) resistor r=8.66667
    rZ_61 (Z_48 Z_51) resistor r=0.702743
    rZ_60 (Z_49 MM3_ELT_d) resistor r=32.3614
    rZ_59 (Z_51 Z_52) resistor r=8.66667
    rZ_58 (Z_51 Z_54) resistor r=0.468495
    rZ_57 (Z_52 MM3_ELT_d) resistor r=16.1807
    rZ_56 (Z_52 Z_55) resistor r=32.3614
    rZ_55 (Z_54 Z_55) resistor r=26
    rZ_54 (Z_57 Z_58) resistor r=0.530412
    rZ_53 (Z_57 Z_85) resistor r=0.0566013
    rZ_52 (Z_58 Z_83) resistor r=0.0547949
    rZ_51 (Z_59 Z_60) resistor r=0.625145
    rZ_50 (Z_59 Z_87) resistor r=0.0667197
    rZ_49 (Z_60 Z_84) resistor r=0.061375
    rZ_48 (Z_63 Z_64) resistor r=13
    rZ_47 (Z_63 Z_86) resistor r=0.304039
    rZ_46 (Z_64 MM15_ELT_d) resistor r=8.44
    rZ_45 (Z_66 Z) resistor r=0.0587995
    rZ_44 (Z_66 Z_85) resistor r=0.0411596
    rZ_43 (Z_67 Z) resistor r=0.170052
    rZ_42 (Z_67 Z_87) resistor r=0.035933
    rZ_41 (Z_72 Z_73) resistor r=8.66667
    rZ_40 (Z_72 Z_88) resistor r=0.341377
    rZ_39 (Z_72 Z_75) resistor r=0.640082
    rZ_38 (Z_73 MM14_ELT_d) resistor r=32.3614
    rZ_37 (Z_75 Z_76) resistor r=8.66667
    rZ_36 (Z_75 Z_78) resistor r=0.426722
    rZ_35 (Z_76 MM14_ELT_d) resistor r=16.1807
    rZ_34 (Z_76 Z_79) resistor r=32.3614
    rZ_33 (Z_78 Z_79) resistor r=26
    rZ_32 (Z_85 Z_86) resistor r=0.154607
    rZ_31 (Z_87 Z_88) resistor r=0.18928
    rVDD_195 (MM13_ELT_b MM8_ELT_b) resistor r=0.01
    rVDD_194 (MM6_ELT_b MM8_ELT_b) resistor r=0.01
    rVDD_193 (MM2_ELT_b MM8_ELT_b) resistor r=0.01
    rVDD_192 (MM3_ELT_b MM8_ELT_b) resistor r=0.01
    rVDD_191 (MM14_ELT_b MM8_ELT_b) resistor r=0.01
    rVDD_190 (MM8_ELT_b VDD_55) resistor r=8.66667
    rVDD_189 (MM8_ELT_b VDD_83) resistor r=13
    rVDD_188 (MM8_ELT_b VDD_91) resistor r=8.66667
    rVDD_187 (MM8_ELT_b VDD_40) resistor r=22.5067
    rVDD_186 (VDD_2 VDD_7) resistor r=0.114761
    rVDD_185 (VDD_2 VDD_86) resistor r=0.0221791
    rVDD_184 (VDD VDD_7) resistor r=0.102889
    rVDD_183 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_182 (VDD_8 VDD_24) resistor r=67.52
    rVDD_181 (VDD_9 VDD_18) resistor r=0.41579
    rVDD_180 (VDD_9 VDD_86) resistor r=0.0883127
    rVDD_179 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_178 (VDD_11 VDD_15) resistor r=0.702743
    rVDD_177 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_176 (VDD_15 VDD_18) resistor r=0.702743
    rVDD_175 (VDD_18 VDD_19) resistor r=8.66667
    rVDD_174 (VDD_19 MM13_ELT_s) resistor r=0.850556
    rVDD_173 (VDD_19 MM8_ELT_s) resistor r=0.850556
    rVDD_172 (VDD_19 VDD_135) resistor r=13.0961
    rVDD_171 (VDD_20 VDD_23) resistor r=0.0831028
    rVDD_170 (VDD_20 VDD_87) resistor r=0.0221791
    rVDD_169 (VDD_21 VDD_23) resistor r=0.0870601
    rVDD_168 (VDD_21 VDD_86) resistor r=0.0221791
    rVDD_167 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_166 (VDD_24 VDD_40) resistor r=67.52
    rVDD_165 (VDD_25 VDD_34) resistor r=0.41579
    rVDD_164 (VDD_25 VDD_87) resistor r=0.0883127
    rVDD_163 (VDD_27 VDD_35) resistor r=8.66667
    rVDD_162 (VDD_27 VDD_31) resistor r=0.702743
    rVDD_161 (VDD_31 VDD_35) resistor r=8.66667
    rVDD_160 (VDD_31 VDD_34) resistor r=0.702743
    rVDD_159 (VDD_34 VDD_35) resistor r=8.66667
    rVDD_158 (VDD_35 MM6_ELT_s) resistor r=4.04518
    rVDD_157 (VDD_35 VDD_139) resistor r=4.04518
    rVDD_156 (VDD_35 MM13_ELT_s) resistor r=4.04518
    rVDD_155 (VDD_35 VDD_137) resistor r=4.04518
    rVDD_154 (VDD_36 VDD_39) resistor r=0.0514446
    rVDD_153 (VDD_36 VDD_88) resistor r=0.0221791
    rVDD_152 (VDD_37 VDD_39) resistor r=0.118718
    rVDD_151 (VDD_37 VDD_87) resistor r=0.0221791
    rVDD_150 (VDD_39 VDD_40) resistor r=8.66667
    rVDD_149 (VDD_41 VDD_50) resistor r=0.41579
    rVDD_148 (VDD_41 VDD_88) resistor r=0.0883127
    rVDD_147 (VDD_43 VDD_51) resistor r=8.66667
    rVDD_146 (VDD_43 VDD_47) resistor r=0.702743
    rVDD_145 (VDD_47 VDD_51) resistor r=8.66667
    rVDD_144 (VDD_47 VDD_50) resistor r=0.702743
    rVDD_143 (VDD_50 VDD_51) resistor r=8.66667
    rVDD_142 (VDD_51 MM2_ELT_s) resistor r=4.04518
    rVDD_141 (VDD_51 VDD_143) resistor r=4.04518
    rVDD_140 (VDD_51 MM6_ELT_s) resistor r=4.04518
    rVDD_139 (VDD_51 VDD_141) resistor r=4.04518
    rVDD_138 (VDD_52 VDD_55) resistor r=0.0197864
    rVDD_137 (VDD_52 VDD_89) resistor r=0.0221791
    rVDD_136 (VDD_53 VDD_55) resistor r=0.150376
    rVDD_135 (VDD_53 VDD_88) resistor r=0.0221791
    rVDD_134 (VDD_57 VDD_66) resistor r=0.41579
    rVDD_133 (VDD_57 VDD_89) resistor r=0.0883127
    rVDD_132 (VDD_59 VDD_67) resistor r=8.66667
    rVDD_131 (VDD_59 VDD_63) resistor r=0.702743
    rVDD_130 (VDD_63 VDD_67) resistor r=8.66667
    rVDD_129 (VDD_63 VDD_66) resistor r=0.702743
    rVDD_128 (VDD_66 VDD_67) resistor r=8.66667
    rVDD_127 (VDD_67 MM3_ELT_s) resistor r=0.850556
    rVDD_126 (VDD_67 MM2_ELT_s) resistor r=0.850556
    rVDD_125 (VDD_67 VDD_145) resistor r=13.0961
    rVDD_124 (VDD_68 VDD_69) resistor r=0.170163
    rVDD_123 (VDD_68 VDD_91) resistor r=0.0221791
    rVDD_122 (VDD_69 VDD_89) resistor r=0.0221791
    rVDD_121 (VDD_70 VDD_79) resistor r=0.41579
    rVDD_120 (VDD_70 VDD_91) resistor r=0.0883127
    rVDD_119 (VDD_72 VDD_80) resistor r=8.66667
    rVDD_118 (VDD_72 VDD_76) resistor r=0.702743
    rVDD_117 (VDD_76 VDD_80) resistor r=8.66667
    rVDD_116 (VDD_76 VDD_79) resistor r=0.702743
    rVDD_115 (VDD_79 VDD_80) resistor r=8.66667
    rVDD_114 (VDD_80 MM14_ELT_s) resistor r=4.04518
    rVDD_113 (VDD_80 VDD_149) resistor r=4.04518
    rVDD_112 (VDD_80 MM3_ELT_s) resistor r=4.04518
    rVDD_111 (VDD_80 VDD_147) resistor r=4.04518
    rVDD_110 (VDD_81 VDD_83) resistor r=0.134547
    rVDD_109 (VDD_81 VDD_91) resistor r=0.0221791
    rVDD_108 (VDD_95 VDD_98) resistor r=31.2341
    rVDD_107 (VDD_95 VDD_99) resistor r=9.04595
    rVDD_106 (VDD_96 VDD_98) resistor r=31.2341
    rVDD_105 (VDD_96 VDD_102) resistor r=9.04062
    rVDD_104 (MM8_ELT_s VDD_98) resistor r=6.12113
    rVDD_103 (MM8_ELT_s VDD_100) resistor r=12.3172
    rVDD_102 (MM8_ELT_s VDD_100) resistor r=1.62887
    rVDD_101 (MM8_ELT_s VDD_103) resistor r=2.55965
    rVDD_100 (VDD_99 VDD_100) resistor r=12.3172
    rVDD_99 (VDD_101 VDD_103) resistor r=14.4784
    rVDD_98 (VDD_101 VDD_136) resistor r=10.5593
    rVDD_97 (VDD_102 VDD_103) resistor r=14.4784
    rVDD_96 (MM13_ELT_s VDD_107) resistor r=2.55965
    rVDD_95 (MM13_ELT_s VDD_109) resistor r=12.3172
    rVDD_94 (MM13_ELT_s VDD_109) resistor r=1.62887
    rVDD_93 (VDD_105 VDD_107) resistor r=14.4784
    rVDD_92 (VDD_105 VDD_140) resistor r=10.5593
    rVDD_91 (VDD_106 VDD_107) resistor r=14.4784
    rVDD_90 (VDD_106 VDD_136) resistor r=10.5593
    rVDD_89 (VDD_108 VDD_109) resistor r=12.3172
    rVDD_88 (VDD_108 VDD_138) resistor r=10.2363
    rVDD_87 (MM6_ELT_s VDD_113) resistor r=2.55965
    rVDD_86 (MM6_ELT_s VDD_115) resistor r=12.3172
    rVDD_85 (MM6_ELT_s VDD_115) resistor r=1.62887
    rVDD_84 (MM6_ELT_s VDD_138) resistor r=10.2363
    rVDD_83 (VDD_111 VDD_113) resistor r=14.4784
    rVDD_82 (VDD_111 VDD_144) resistor r=10.5593
    rVDD_81 (VDD_112 VDD_113) resistor r=14.4784
    rVDD_80 (VDD_112 VDD_140) resistor r=10.5593
    rVDD_79 (VDD_114 VDD_115) resistor r=12.3172
    rVDD_78 (VDD_114 VDD_142) resistor r=10.2363
    rVDD_77 (MM2_ELT_s VDD_118) resistor r=12.3172
    rVDD_76 (MM2_ELT_s VDD_118) resistor r=1.62887
    rVDD_75 (MM2_ELT_s VDD_121) resistor r=2.55965
    rVDD_74 (VDD_117 VDD_118) resistor r=12.3172
    rVDD_73 (VDD_117 VDD_142) resistor r=10.2363
    rVDD_72 (VDD_119 VDD_121) resistor r=14.4784
    rVDD_71 (VDD_119 VDD_146) resistor r=10.5593
    rVDD_70 (VDD_120 VDD_121) resistor r=14.4784
    rVDD_69 (VDD_120 VDD_144) resistor r=10.5593
    rVDD_68 (MM3_ELT_s VDD_125) resistor r=2.55965
    rVDD_67 (MM3_ELT_s VDD_127) resistor r=12.3172
    rVDD_66 (MM3_ELT_s VDD_127) resistor r=1.62887
    rVDD_65 (VDD_123 VDD_125) resistor r=14.4784
    rVDD_64 (VDD_123 VDD_150) resistor r=10.5593
    rVDD_63 (VDD_124 VDD_125) resistor r=14.4784
    rVDD_62 (VDD_124 VDD_146) resistor r=10.5593
    rVDD_61 (VDD_126 VDD_127) resistor r=12.3172
    rVDD_60 (VDD_126 VDD_148) resistor r=10.2363
    rVDD_59 (MM14_ELT_s VDD_130) resistor r=12.3172
    rVDD_58 (MM14_ELT_s VDD_130) resistor r=1.62887
    rVDD_57 (MM14_ELT_s VDD_133) resistor r=2.55965
    rVDD_56 (MM14_ELT_s VDD_134) resistor r=25.7298
    rVDD_55 (VDD_129 VDD_130) resistor r=12.3172
    rVDD_54 (VDD_129 VDD_148) resistor r=10.2363
    rVDD_53 (VDD_131 VDD_133) resistor r=14.4784
    rVDD_52 (VDD_131 VDD_134) resistor r=9.04062
    rVDD_51 (VDD_132 VDD_133) resistor r=14.4784
    rVDD_50 (VDD_132 VDD_150) resistor r=10.5593
    rVDD_49 (VDD_135 VDD_136) resistor r=0.730683
    rVDD_48 (VDD_137 VDD_138) resistor r=0.549089
    rVDD_47 (VDD_139 VDD_140) resistor r=0.730683
    rVDD_46 (VDD_141 VDD_142) resistor r=0.549089
    rVDD_45 (VDD_143 VDD_144) resistor r=0.730683
    rVDD_44 (VDD_145 VDD_146) resistor r=0.730683
    rVDD_43 (VDD_147 VDD_148) resistor r=0.549089
    rVDD_42 (VDD_149 VDD_150) resistor r=0.730683
    rVSS_163 (MM12_ELT_b MM7_ELT_b) resistor r=0.01
    rVSS_162 (MM5_ELT_b MM7_ELT_b) resistor r=0.01
    rVSS_161 (MM4_ELT_b MM7_ELT_b) resistor r=0.01
    rVSS_160 (MM1_ELT_b MM7_ELT_b) resistor r=0.01
    rVSS_159 (MM15_ELT_b MM7_ELT_b) resistor r=0.01
    rVSS_158 (MM7_ELT_b VSS_37) resistor r=8.66667
    rVSS_157 (MM7_ELT_b VSS_53) resistor r=13
    rVSS_156 (MM7_ELT_b VSS_61) resistor r=8.66667
    rVSS_155 (MM7_ELT_b VSS_28) resistor r=21.5743
    rVSS_154 (VSS_2 VSS_7) resistor r=0.114761
    rVSS_153 (VSS_2 VSS_56) resistor r=0.0221791
    rVSS_152 (VSS VSS_7) resistor r=0.100911
    rVSS_151 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_150 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_149 (VSS_9 VSS_11) resistor r=0.445071
    rVSS_148 (VSS_9 VSS_56) resistor r=0.0883127
    rVSS_147 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_146 (VSS_12 MM12_ELT_s) resistor r=2.27123
    rVSS_145 (VSS_12 MM7_ELT_s) resistor r=2.27123
    rVSS_144 (VSS_12 VSS_103) resistor r=8.4738
    rVSS_143 (VSS_14 VSS_17) resistor r=0.0831028
    rVSS_142 (VSS_14 VSS_57) resistor r=0.0221791
    rVSS_141 (VSS_15 VSS_17) resistor r=0.0870601
    rVSS_140 (VSS_15 VSS_56) resistor r=0.0221791
    rVSS_139 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_138 (VSS_18 VSS_28) resistor r=64.7228
    rVSS_137 (VSS_19 VSS_21) resistor r=0.445071
    rVSS_136 (VSS_19 VSS_57) resistor r=0.0883127
    rVSS_135 (VSS_21 VSS_22) resistor r=8.66667
    rVSS_134 (VSS_22 MM5_ELT_s) resistor r=4.22001
    rVSS_133 (VSS_22 VSS_107) resistor r=4.22001
    rVSS_132 (VSS_22 MM12_ELT_s) resistor r=4.22001
    rVSS_131 (VSS_22 VSS_105) resistor r=4.22001
    rVSS_130 (VSS_24 VSS_27) resistor r=0.0514446
    rVSS_129 (VSS_24 VSS_58) resistor r=0.0221791
    rVSS_128 (VSS_25 VSS_27) resistor r=0.118718
    rVSS_127 (VSS_25 VSS_57) resistor r=0.0221791
    rVSS_126 (VSS_27 VSS_28) resistor r=8.66667
    rVSS_125 (VSS_29 VSS_31) resistor r=0.445071
    rVSS_124 (VSS_29 VSS_58) resistor r=0.0883127
    rVSS_123 (VSS_31 VSS_32) resistor r=8.66667
    rVSS_122 (VSS_32 MM4_ELT_s) resistor r=4.22001
    rVSS_121 (VSS_32 VSS_111) resistor r=4.22001
    rVSS_120 (VSS_32 MM5_ELT_s) resistor r=4.22001
    rVSS_119 (VSS_32 VSS_109) resistor r=4.22001
    rVSS_118 (VSS_34 VSS_37) resistor r=0.0197864
    rVSS_117 (VSS_34 VSS_59) resistor r=0.0221791
    rVSS_116 (VSS_35 VSS_37) resistor r=0.150376
    rVSS_115 (VSS_35 VSS_58) resistor r=0.0221791
    rVSS_114 (VSS_39 VSS_41) resistor r=0.445071
    rVSS_113 (VSS_39 VSS_59) resistor r=0.0883127
    rVSS_112 (VSS_41 VSS_42) resistor r=8.66667
    rVSS_111 (VSS_42 MM1_ELT_s) resistor r=2.27123
    rVSS_110 (VSS_42 MM4_ELT_s) resistor r=2.27123
    rVSS_109 (VSS_42 VSS_113) resistor r=8.4738
    rVSS_108 (VSS_44 VSS_45) resistor r=0.170163
    rVSS_107 (VSS_44 VSS_61) resistor r=0.0221791
    rVSS_106 (VSS_45 VSS_59) resistor r=0.0221791
    rVSS_105 (VSS_46 VSS_48) resistor r=0.445071
    rVSS_104 (VSS_46 VSS_61) resistor r=0.0883127
    rVSS_103 (VSS_48 VSS_49) resistor r=8.66667
    rVSS_102 (VSS_49 MM15_ELT_s) resistor r=4.22001
    rVSS_101 (VSS_49 VSS_117) resistor r=4.22001
    rVSS_100 (VSS_49 MM1_ELT_s) resistor r=4.22001
    rVSS_99 (VSS_49 VSS_115) resistor r=4.22001
    rVSS_98 (VSS_51 VSS_53) resistor r=0.134547
    rVSS_97 (VSS_51 VSS_61) resistor r=0.0221791
    rVSS_96 (VSS_63 VSS_66) resistor r=21.1301
    rVSS_95 (VSS_63 VSS_68) resistor r=9.43134
    rVSS_94 (VSS_64 VSS_66) resistor r=21.1301
    rVSS_93 (VSS_64 VSS_70) resistor r=9.4369
    rVSS_92 (MM7_ELT_s VSS_66) resistor r=4.557
    rVSS_91 (MM7_ELT_s VSS_69) resistor r=2.67027
    rVSS_90 (MM7_ELT_s VSS_71) resistor r=12.8495
    rVSS_89 (MM7_ELT_s VSS_71) resistor r=1.69926
    rVSS_88 (VSS_67 VSS_69) resistor r=15.1041
    rVSS_87 (VSS_67 VSS_104) resistor r=11.0157
    rVSS_86 (VSS_68 VSS_69) resistor r=15.1041
    rVSS_85 (VSS_70 VSS_71) resistor r=12.8495
    rVSS_84 (MM12_ELT_s VSS_75) resistor r=2.67027
    rVSS_83 (MM12_ELT_s VSS_77) resistor r=12.8495
    rVSS_82 (MM12_ELT_s VSS_77) resistor r=1.69926
    rVSS_81 (VSS_73 VSS_75) resistor r=15.1041
    rVSS_80 (VSS_73 VSS_106) resistor r=11.0157
    rVSS_79 (VSS_74 VSS_75) resistor r=15.1041
    rVSS_78 (VSS_74 VSS_104) resistor r=11.0157
    rVSS_77 (VSS_76 VSS_77) resistor r=12.8495
    rVSS_76 (VSS_76 VSS_108) resistor r=10.6787
    rVSS_75 (MM5_ELT_s VSS_81) resistor r=2.67027
    rVSS_74 (MM5_ELT_s VSS_83) resistor r=12.8495
    rVSS_73 (MM5_ELT_s VSS_83) resistor r=1.69926
    rVSS_72 (MM5_ELT_s VSS_108) resistor r=10.6787
    rVSS_71 (VSS_79 VSS_81) resistor r=15.1041
    rVSS_70 (VSS_79 VSS_110) resistor r=11.0157
    rVSS_69 (VSS_80 VSS_81) resistor r=15.1041
    rVSS_68 (VSS_80 VSS_106) resistor r=11.0157
    rVSS_67 (VSS_82 VSS_83) resistor r=12.8495
    rVSS_66 (VSS_82 VSS_112) resistor r=10.6787
    rVSS_65 (MM4_ELT_s VSS_87) resistor r=2.67027
    rVSS_64 (MM4_ELT_s VSS_89) resistor r=12.8495
    rVSS_63 (MM4_ELT_s VSS_89) resistor r=1.69926
    rVSS_62 (VSS_85 VSS_87) resistor r=15.1041
    rVSS_61 (VSS_85 VSS_114) resistor r=11.0157
    rVSS_60 (VSS_86 VSS_87) resistor r=15.1041
    rVSS_59 (VSS_86 VSS_110) resistor r=11.0157
    rVSS_58 (VSS_88 VSS_89) resistor r=12.8495
    rVSS_57 (VSS_88 VSS_112) resistor r=10.6787
    rVSS_56 (MM1_ELT_s VSS_93) resistor r=2.67027
    rVSS_55 (MM1_ELT_s VSS_95) resistor r=12.8495
    rVSS_54 (MM1_ELT_s VSS_95) resistor r=1.69926
    rVSS_53 (VSS_91 VSS_93) resistor r=15.1041
    rVSS_52 (VSS_91 VSS_116) resistor r=11.0157
    rVSS_51 (VSS_92 VSS_93) resistor r=15.1041
    rVSS_50 (VSS_92 VSS_114) resistor r=11.0157
    rVSS_49 (VSS_94 VSS_95) resistor r=12.8495
    rVSS_48 (VSS_94 VSS_118) resistor r=10.6787
    rVSS_47 (MM15_ELT_s VSS_99) resistor r=2.67027
    rVSS_46 (MM15_ELT_s VSS_101) resistor r=12.8495
    rVSS_45 (MM15_ELT_s VSS_101) resistor r=1.69926
    rVSS_44 (MM15_ELT_s VSS_102) resistor r=18.0507
    rVSS_43 (VSS_97 VSS_99) resistor r=15.1041
    rVSS_42 (VSS_97 VSS_102) resistor r=9.43134
    rVSS_41 (VSS_98 VSS_99) resistor r=15.1041
    rVSS_40 (VSS_98 VSS_116) resistor r=11.0157
    rVSS_39 (VSS_100 VSS_101) resistor r=12.8495
    rVSS_38 (VSS_100 VSS_118) resistor r=10.6787
    rVSS_37 (VSS_103 VSS_104) resistor r=0.762262
    rVSS_36 (VSS_105 VSS_106) resistor r=0.762262
    rVSS_35 (VSS_107 VSS_108) resistor r=0.57282
    rVSS_34 (VSS_109 VSS_110) resistor r=0.762262
    rVSS_33 (VSS_111 VSS_112) resistor r=0.57282
    rVSS_32 (VSS_113 VSS_114) resistor r=0.762262
    rVSS_31 (VSS_115 VSS_116) resistor r=0.762262
    rVSS_30 (VSS_117 VSS_118) resistor r=0.57282
    rnet11_448 (MM13_ELT_d net11) resistor r=0.01
    rnet11_447 (net11_82 net11_88) resistor r=58.3583
    rnet11_446 (net11_82 net11_88) resistor r=4.16253
    rnet11_445 (net11_82 net11_88) resistor r=58.3583
    rnet11_444 (net11_82 net11_88) resistor r=4.16253
    rnet11_443 (net11_85 net11_88) resistor r=58.3583
    rnet11_442 (net11_85 net11_88) resistor r=6.30933
    rnet11_441 (net11_85 net11_88) resistor r=58.3583
    rnet11_440 (net11_85 net11_88) resistor r=6.30933
    rnet11_439 (net11_88 net11_90) resistor r=14.9
    rnet11_438 (net11_88 net11_113) resistor r=24.8333
    rnet11_437 (net11_88 net11_110) resistor r=24.8333
    rnet11_436 (net11_88 net11_121) resistor r=24.8333
    rnet11_435 (net11_88 net11_118) resistor r=24.8333
    rnet11_434 (net11_88 net11_142) resistor r=58.3583
    rnet11_433 (net11_88 net11_145) resistor r=58.3583
    rnet11_432 (net11_88 net11_113) resistor r=4.16253
    rnet11_431 (net11_88 net11_90) resistor r=6.30933
    rnet11_430 (net11_88 net11_121) resistor r=1.63969
    rnet11_429 (net11_88 net11_110) resistor r=4.16253
    rnet11_428 (net11_88 net11_142) resistor r=4.16253
    rnet11_427 (net11_88 net11_118) resistor r=4.16253
    rnet11_426 (net11_88 net11_145) resistor r=4.16253
    rnet11_425 (net11_88 net11_90) resistor r=14.9
    rnet11_424 (net11_88 net11_663) resistor r=40.975
    rnet11_423 (net11_88 net11_113) resistor r=24.8333
    rnet11_422 (net11_88 net11_110) resistor r=24.8333
    rnet11_421 (net11_88 net11_121) resistor r=24.8333
    rnet11_420 (net11_88 net11_118) resistor r=24.8333
    rnet11_419 (net11_88 net11_142) resistor r=58.3583
    rnet11_418 (net11_88 MM5_ELT_g) resistor r=7.45
    rnet11_417 (net11_88 net11_113) resistor r=4.16253
    rnet11_416 (net11_88 net11_90) resistor r=6.30933
    rnet11_415 (net11_88 net11_121) resistor r=1.63969
    rnet11_414 (net11_88 net11_110) resistor r=4.16253
    rnet11_413 (net11_88 net11_142) resistor r=4.16253
    rnet11_412 (net11_88 net11_118) resistor r=4.16253
    rnet11_411 (net11_88 net11_145) resistor r=4.16253
    rnet11_410 (net11_96 net11_99) resistor r=14.9
    rnet11_409 (net11_96 net11_99) resistor r=6.30933
    rnet11_408 (net11_96 net11_99) resistor r=14.9
    rnet11_407 (net11_96 net11_99) resistor r=6.30933
    rnet11_406 (net11_99 net11_102) resistor r=202.392
    rnet11_405 (net11_99 net11_105) resistor r=202.392
    rnet11_404 (net11_99 net11_129) resistor r=24.8333
    rnet11_403 (net11_99 net11_126) resistor r=24.8333
    rnet11_402 (net11_99 net11_137) resistor r=24.8333
    rnet11_401 (net11_99 net11_134) resistor r=24.8333
    rnet11_400 (net11_99 net11_150) resistor r=202.392
    rnet11_399 (net11_99 net11_153) resistor r=202.392
    rnet11_398 (net11_99 net11_102) resistor r=6.30933
    rnet11_397 (net11_99 net11_129) resistor r=1.63969
    rnet11_396 (net11_99 net11_137) resistor r=4.16253
    rnet11_395 (net11_99 net11_105) resistor r=4.16253
    rnet11_394 (net11_99 net11_126) resistor r=4.16253
    rnet11_393 (net11_99 net11_150) resistor r=4.16253
    rnet11_392 (net11_99 net11_134) resistor r=4.16253
    rnet11_391 (net11_99 net11_153) resistor r=4.16253
    rnet11_390 (net11_99 net11_665) resistor r=40.975
    rnet11_389 (net11_99 net11_102) resistor r=202.392
    rnet11_388 (net11_99 net11_105) resistor r=202.392
    rnet11_387 (net11_99 net11_129) resistor r=24.8333
    rnet11_386 (net11_99 net11_126) resistor r=24.8333
    rnet11_385 (net11_99 net11_137) resistor r=24.8333
    rnet11_384 (net11_99 net11_134) resistor r=24.8333
    rnet11_383 (net11_99 net11_150) resistor r=202.392
    rnet11_382 (net11_99 MM6_ELT_g) resistor r=7.45
    rnet11_381 (net11_99 net11_102) resistor r=6.30933
    rnet11_380 (net11_99 net11_129) resistor r=1.63969
    rnet11_379 (net11_99 net11_137) resistor r=4.16253
    rnet11_378 (net11_99 net11_105) resistor r=4.16253
    rnet11_377 (net11_99 net11_126) resistor r=4.16253
    rnet11_376 (net11_99 net11_150) resistor r=4.16253
    rnet11_375 (net11_99 net11_134) resistor r=4.16253
    rnet11_374 (net11_99 net11_153) resistor r=4.16253
    rnet11_373 (net11_145 MM5_ELT_g) resistor r=50.9083
    rnet11_372 (net11_153 MM6_ELT_g) resistor r=194.942
    rnet11_371 (net11_158 net11_164) resistor r=58.3583
    rnet11_370 (net11_158 net11_164) resistor r=4.16253
    rnet11_369 (net11_158 net11_164) resistor r=58.3583
    rnet11_368 (net11_158 net11_164) resistor r=4.16253
    rnet11_367 (net11_161 net11_164) resistor r=58.3583
    rnet11_366 (net11_161 net11_164) resistor r=4.16253
    rnet11_365 (net11_161 net11_164) resistor r=58.3583
    rnet11_364 (net11_161 net11_164) resistor r=4.16253
    rnet11_363 (net11_164 net11_177) resistor r=24.8333
    rnet11_362 (net11_164 net11_174) resistor r=24.8333
    rnet11_361 (net11_164 net11_185) resistor r=24.8333
    rnet11_360 (net11_164 net11_182) resistor r=24.8333
    rnet11_359 (net11_164 net11_206) resistor r=58.3583
    rnet11_358 (net11_164 net11_209) resistor r=58.3583
    rnet11_357 (net11_164 net11_214) resistor r=14.9
    rnet11_356 (net11_164 net11_177) resistor r=4.16253
    rnet11_355 (net11_164 net11_185) resistor r=4.16253
    rnet11_354 (net11_164 net11_174) resistor r=4.16253
    rnet11_353 (net11_164 net11_206) resistor r=4.16253
    rnet11_352 (net11_164 net11_214) resistor r=6.30933
    rnet11_351 (net11_164 net11_209) resistor r=6.30933
    rnet11_350 (net11_164 net11_182) resistor r=1.63969
    rnet11_349 (net11_164 net11_177) resistor r=24.8333
    rnet11_348 (net11_164 net11_174) resistor r=24.8333
    rnet11_347 (net11_164 net11_185) resistor r=24.8333
    rnet11_346 (net11_164 net11_182) resistor r=24.8333
    rnet11_345 (net11_164 net11_206) resistor r=58.3583
    rnet11_344 (net11_164 MM4_ELT_g) resistor r=22.35
    rnet11_343 (net11_164 net11_214) resistor r=14.9
    rnet11_342 (net11_164 net11_717) resistor r=40.975
    rnet11_341 (net11_164 net11_177) resistor r=4.16253
    rnet11_340 (net11_164 net11_185) resistor r=4.16253
    rnet11_339 (net11_164 net11_174) resistor r=4.16253
    rnet11_338 (net11_164 net11_206) resistor r=4.16253
    rnet11_337 (net11_164 net11_214) resistor r=6.30933
    rnet11_336 (net11_164 net11_209) resistor r=6.30933
    rnet11_335 (net11_164 net11_182) resistor r=1.63969
    rnet11_334 (net11_166 net11_172) resistor r=202.392
    rnet11_333 (net11_166 net11_172) resistor r=4.16253
    rnet11_332 (net11_166 net11_172) resistor r=202.392
    rnet11_331 (net11_166 net11_172) resistor r=4.16253
    rnet11_330 (net11_169 net11_172) resistor r=202.392
    rnet11_329 (net11_169 net11_172) resistor r=4.16253
    rnet11_328 (net11_169 net11_172) resistor r=202.392
    rnet11_327 (net11_169 net11_172) resistor r=4.16253
    rnet11_326 (net11_172 net11_193) resistor r=24.8333
    rnet11_325 (net11_172 net11_190) resistor r=24.8333
    rnet11_324 (net11_172 net11_201) resistor r=24.8333
    rnet11_323 (net11_172 net11_198) resistor r=24.8333
    rnet11_322 (net11_172 net11_220) resistor r=14.9
    rnet11_321 (net11_172 net11_226) resistor r=202.392
    rnet11_320 (net11_172 net11_229) resistor r=202.392
    rnet11_319 (net11_172 net11_193) resistor r=4.16253
    rnet11_318 (net11_172 net11_201) resistor r=4.16253
    rnet11_317 (net11_172 net11_226) resistor r=6.30933
    rnet11_316 (net11_172 net11_220) resistor r=6.30933
    rnet11_315 (net11_172 net11_190) resistor r=1.63969
    rnet11_314 (net11_172 net11_198) resistor r=4.16253
    rnet11_313 (net11_172 net11_229) resistor r=4.16253
    rnet11_312 (net11_172 net11_193) resistor r=24.8333
    rnet11_311 (net11_172 net11_190) resistor r=24.8333
    rnet11_310 (net11_172 net11_201) resistor r=24.8333
    rnet11_309 (net11_172 net11_198) resistor r=24.8333
    rnet11_308 (net11_172 net11_719) resistor r=40.975
    rnet11_307 (net11_172 net11_220) resistor r=14.9
    rnet11_306 (net11_172 net11_226) resistor r=202.392
    rnet11_305 (net11_172 MM2_ELT_g) resistor r=7.45
    rnet11_304 (net11_172 net11_193) resistor r=4.16253
    rnet11_303 (net11_172 net11_201) resistor r=4.16253
    rnet11_302 (net11_172 net11_226) resistor r=6.30933
    rnet11_301 (net11_172 net11_220) resistor r=6.30933
    rnet11_300 (net11_172 net11_190) resistor r=1.63969
    rnet11_299 (net11_172 net11_198) resistor r=4.16253
    rnet11_298 (net11_172 net11_229) resistor r=4.16253
    rnet11_297 (net11_209 MM4_ELT_g) resistor r=36.0083
    rnet11_296 (net11_229 MM2_ELT_g) resistor r=194.942
    rnet11_295 (net11_234 net11_240) resistor r=58.3583
    rnet11_294 (net11_234 net11_240) resistor r=4.16253
    rnet11_293 (net11_234 net11_240) resistor r=58.3583
    rnet11_292 (net11_234 net11_240) resistor r=4.16253
    rnet11_291 (net11_237 net11_240) resistor r=58.3583
    rnet11_290 (net11_237 net11_240) resistor r=6.30933
    rnet11_289 (net11_237 net11_240) resistor r=58.3583
    rnet11_288 (net11_237 net11_240) resistor r=6.30933
    rnet11_287 (net11_240 net11_242) resistor r=14.9
    rnet11_286 (net11_240 net11_265) resistor r=24.8333
    rnet11_285 (net11_240 net11_262) resistor r=24.8333
    rnet11_284 (net11_240 net11_273) resistor r=24.8333
    rnet11_283 (net11_240 net11_270) resistor r=24.8333
    rnet11_282 (net11_240 net11_294) resistor r=58.3583
    rnet11_281 (net11_240 net11_297) resistor r=58.3583
    rnet11_280 (net11_240 net11_265) resistor r=4.16253
    rnet11_279 (net11_240 net11_242) resistor r=6.30933
    rnet11_278 (net11_240 net11_273) resistor r=1.63969
    rnet11_277 (net11_240 net11_262) resistor r=4.16253
    rnet11_276 (net11_240 net11_294) resistor r=4.16253
    rnet11_275 (net11_240 net11_270) resistor r=4.16253
    rnet11_274 (net11_240 net11_297) resistor r=4.16253
    rnet11_273 (net11_240 net11_242) resistor r=14.9
    rnet11_272 (net11_240 net11_731) resistor r=40.975
    rnet11_271 (net11_240 net11_265) resistor r=24.8333
    rnet11_270 (net11_240 net11_262) resistor r=24.8333
    rnet11_269 (net11_240 net11_273) resistor r=24.8333
    rnet11_268 (net11_240 net11_270) resistor r=24.8333
    rnet11_267 (net11_240 net11_294) resistor r=58.3583
    rnet11_266 (net11_240 MM1_ELT_g) resistor r=7.45
    rnet11_265 (net11_240 net11_265) resistor r=4.16253
    rnet11_264 (net11_240 net11_242) resistor r=6.30933
    rnet11_263 (net11_240 net11_273) resistor r=1.63969
    rnet11_262 (net11_240 net11_262) resistor r=4.16253
    rnet11_261 (net11_240 net11_294) resistor r=4.16253
    rnet11_260 (net11_240 net11_270) resistor r=4.16253
    rnet11_259 (net11_240 net11_297) resistor r=4.16253
    rnet11_258 (net11_248 net11_251) resistor r=14.9
    rnet11_257 (net11_248 net11_251) resistor r=6.30933
    rnet11_256 (net11_248 net11_251) resistor r=14.9
    rnet11_255 (net11_248 net11_251) resistor r=6.30933
    rnet11_254 (net11_251 net11_254) resistor r=202.392
    rnet11_253 (net11_251 net11_257) resistor r=202.392
    rnet11_252 (net11_251 net11_281) resistor r=24.8333
    rnet11_251 (net11_251 net11_278) resistor r=24.8333
    rnet11_250 (net11_251 net11_289) resistor r=24.8333
    rnet11_249 (net11_251 net11_286) resistor r=24.8333
    rnet11_248 (net11_251 net11_302) resistor r=202.392
    rnet11_247 (net11_251 net11_305) resistor r=202.392
    rnet11_246 (net11_251 net11_254) resistor r=6.30933
    rnet11_245 (net11_251 net11_281) resistor r=1.63969
    rnet11_244 (net11_251 net11_289) resistor r=4.16253
    rnet11_243 (net11_251 net11_257) resistor r=4.16253
    rnet11_242 (net11_251 net11_278) resistor r=4.16253
    rnet11_241 (net11_251 net11_302) resistor r=4.16253
    rnet11_240 (net11_251 net11_286) resistor r=4.16253
    rnet11_239 (net11_251 net11_305) resistor r=4.16253
    rnet11_238 (net11_251 net11_733) resistor r=40.975
    rnet11_237 (net11_251 net11_254) resistor r=202.392
    rnet11_236 (net11_251 net11_257) resistor r=202.392
    rnet11_235 (net11_251 net11_281) resistor r=24.8333
    rnet11_234 (net11_251 net11_278) resistor r=24.8333
    rnet11_233 (net11_251 net11_289) resistor r=24.8333
    rnet11_232 (net11_251 net11_286) resistor r=24.8333
    rnet11_231 (net11_251 net11_302) resistor r=202.392
    rnet11_230 (net11_251 MM3_ELT_g) resistor r=7.45
    rnet11_229 (net11_251 net11_254) resistor r=6.30933
    rnet11_228 (net11_251 net11_281) resistor r=1.63969
    rnet11_227 (net11_251 net11_289) resistor r=4.16253
    rnet11_226 (net11_251 net11_257) resistor r=4.16253
    rnet11_225 (net11_251 net11_278) resistor r=4.16253
    rnet11_224 (net11_251 net11_302) resistor r=4.16253
    rnet11_223 (net11_251 net11_286) resistor r=4.16253
    rnet11_222 (net11_251 net11_305) resistor r=4.16253
    rnet11_221 (net11_297 MM1_ELT_g) resistor r=50.9083
    rnet11_220 (net11_305 MM3_ELT_g) resistor r=194.942
    rnet11_219 (net11_310 net11_316) resistor r=58.3583
    rnet11_218 (net11_310 net11_316) resistor r=4.16253
    rnet11_217 (net11_310 net11_316) resistor r=58.3583
    rnet11_216 (net11_310 net11_316) resistor r=4.16253
    rnet11_215 (net11_313 net11_316) resistor r=58.3583
    rnet11_214 (net11_313 net11_316) resistor r=4.16253
    rnet11_213 (net11_313 net11_316) resistor r=58.3583
    rnet11_212 (net11_313 net11_316) resistor r=4.16253
    rnet11_211 (net11_316 net11_329) resistor r=24.8333
    rnet11_210 (net11_316 net11_326) resistor r=24.8333
    rnet11_209 (net11_316 net11_337) resistor r=24.8333
    rnet11_208 (net11_316 net11_334) resistor r=24.8333
    rnet11_207 (net11_316 net11_358) resistor r=58.3583
    rnet11_206 (net11_316 net11_361) resistor r=58.3583
    rnet11_205 (net11_316 net11_366) resistor r=14.9
    rnet11_204 (net11_316 net11_329) resistor r=4.16253
    rnet11_203 (net11_316 net11_337) resistor r=4.16253
    rnet11_202 (net11_316 net11_326) resistor r=4.16253
    rnet11_201 (net11_316 net11_358) resistor r=4.16253
    rnet11_200 (net11_316 net11_366) resistor r=6.30933
    rnet11_199 (net11_316 net11_361) resistor r=6.30933
    rnet11_198 (net11_316 net11_334) resistor r=1.63969
    rnet11_197 (net11_316 net11_329) resistor r=24.8333
    rnet11_196 (net11_316 net11_326) resistor r=24.8333
    rnet11_195 (net11_316 net11_337) resistor r=24.8333
    rnet11_194 (net11_316 net11_334) resistor r=24.8333
    rnet11_193 (net11_316 net11_358) resistor r=58.3583
    rnet11_192 (net11_316 MM15_ELT_g) resistor r=22.35
    rnet11_191 (net11_316 net11_366) resistor r=14.9
    rnet11_190 (net11_316 net11_785) resistor r=40.975
    rnet11_189 (net11_316 net11_329) resistor r=4.16253
    rnet11_188 (net11_316 net11_337) resistor r=4.16253
    rnet11_187 (net11_316 net11_326) resistor r=4.16253
    rnet11_186 (net11_316 net11_358) resistor r=4.16253
    rnet11_185 (net11_316 net11_366) resistor r=6.30933
    rnet11_184 (net11_316 net11_361) resistor r=6.30933
    rnet11_183 (net11_316 net11_334) resistor r=1.63969
    rnet11_182 (net11_318 net11_324) resistor r=202.392
    rnet11_181 (net11_318 net11_324) resistor r=4.16253
    rnet11_180 (net11_318 net11_324) resistor r=202.392
    rnet11_179 (net11_318 net11_324) resistor r=4.16253
    rnet11_178 (net11_321 net11_324) resistor r=202.392
    rnet11_177 (net11_321 net11_324) resistor r=4.16253
    rnet11_176 (net11_321 net11_324) resistor r=202.392
    rnet11_175 (net11_321 net11_324) resistor r=4.16253
    rnet11_174 (net11_324 net11_345) resistor r=24.8333
    rnet11_173 (net11_324 net11_342) resistor r=24.8333
    rnet11_172 (net11_324 net11_353) resistor r=24.8333
    rnet11_171 (net11_324 net11_350) resistor r=24.8333
    rnet11_170 (net11_324 net11_372) resistor r=14.9
    rnet11_169 (net11_324 net11_378) resistor r=202.392
    rnet11_168 (net11_324 net11_381) resistor r=202.392
    rnet11_167 (net11_324 net11_345) resistor r=4.16253
    rnet11_166 (net11_324 net11_353) resistor r=4.16253
    rnet11_165 (net11_324 net11_378) resistor r=6.30933
    rnet11_164 (net11_324 net11_372) resistor r=6.30933
    rnet11_163 (net11_324 net11_342) resistor r=1.63969
    rnet11_162 (net11_324 net11_350) resistor r=4.16253
    rnet11_161 (net11_324 net11_381) resistor r=4.16253
    rnet11_160 (net11_324 net11_345) resistor r=24.8333
    rnet11_159 (net11_324 net11_342) resistor r=24.8333
    rnet11_158 (net11_324 net11_353) resistor r=24.8333
    rnet11_157 (net11_324 net11_350) resistor r=24.8333
    rnet11_156 (net11_324 net11_787) resistor r=40.975
    rnet11_155 (net11_324 net11_372) resistor r=14.9
    rnet11_154 (net11_324 net11_378) resistor r=202.392
    rnet11_153 (net11_324 MM14_ELT_g) resistor r=7.45
    rnet11_152 (net11_324 net11_345) resistor r=4.16253
    rnet11_151 (net11_324 net11_353) resistor r=4.16253
    rnet11_150 (net11_324 net11_378) resistor r=6.30933
    rnet11_149 (net11_324 net11_372) resistor r=6.30933
    rnet11_148 (net11_324 net11_342) resistor r=1.63969
    rnet11_147 (net11_324 net11_350) resistor r=4.16253
    rnet11_146 (net11_324 net11_381) resistor r=4.16253
    rnet11_145 (net11_361 MM15_ELT_g) resistor r=36.0083
    rnet11_144 (net11_381 MM14_ELT_g) resistor r=194.942
    rnet11_143 (net11_521 net11_523) resistor r=0.43739
    rnet11_142 (net11_521 net11_538) resistor r=0.0961777
    rnet11_141 (net11_523 net11_524) resistor r=13
    rnet11_140 (net11_524 MM7_ELT_d) resistor r=8.44
    rnet11_139 (net11_526 net11_528) resistor r=0.522734
    rnet11_138 (net11_526 net11_540) resistor r=0.0961777
    rnet11_137 (net11_528 net11_529) resistor r=8.66667
    rnet11_136 (net11_528 net11_531) resistor r=0.640082
    rnet11_135 (net11_529 MM8_ELT_d) resistor r=32.3614
    rnet11_134 (net11_531 net11_532) resistor r=8.66667
    rnet11_133 (net11_531 net11_534) resistor r=0.426722
    rnet11_132 (net11_532 MM8_ELT_d) resistor r=16.1807
    rnet11_131 (net11_532 net11_535) resistor r=32.3614
    rnet11_130 (net11_534 net11_535) resistor r=26
    rnet11_129 (net11_537 net11_538) resistor r=0.166059
    rnet11_128 (net11_537 net11_576) resistor r=0.106206
    rnet11_127 (net11_539 net11_540) resistor r=0.166059
    rnet11_126 (net11_539 net11_578) resistor r=0.106206
    rnet11_125 (net11_541 net11_542) resistor r=0.078054
    rnet11_124 (net11_541 net11_576) resistor r=0.00463041
    rnet11_123 (net11_542 net11_577) resistor r=0.0824444
    rnet11_122 (net11_543 net11_544) resistor r=0.078054
    rnet11_121 (net11_543 net11_577) resistor r=0.0824444
    rnet11_120 (net11_544 net11_578) resistor r=0.00463041
    rnet11_119 (net11_545 net11_546) resistor r=0.146937
    rnet11_118 (net11_545 net11_560) resistor r=0.0961777
    rnet11_117 (net11_546 net11_576) resistor r=0.106206
    rnet11_116 (net11_547 net11_549) resistor r=0.72392
    rnet11_115 (net11_547 net11_577) resistor r=0.0106599
    rnet11_114 (net11_549 net11_550) resistor r=6.66667
    rnet11_113 (net11_549 net11_552) resistor r=0.536237
    rnet11_112 (net11_550 net11_797) resistor r=31.1545
    rnet11_111 (net11_550 net11_812) resistor r=66.3727
    rnet11_110 (net11_552 net11_553) resistor r=6.66667
    rnet11_109 (net11_552 net11_555) resistor r=0.357492
    rnet11_108 (net11_553 net11_811) resistor r=6.77273
    rnet11_107 (net11_553 net11_819) resistor r=20.3182
    rnet11_106 (net11_555 net11_556) resistor r=10
    rnet11_105 (net11_556 net11_818) resistor r=25.7364
    rnet11_104 (net11_556 net11_833) resistor r=71.7909
    rnet11_103 (net11_558 net11_559) resistor r=0.146937
    rnet11_102 (net11_558 net11_565) resistor r=0.0961777
    rnet11_101 (net11_559 net11_578) resistor r=0.106206
    rnet11_100 (net11_560 net11_562) resistor r=0.480208
    rnet11_99 (net11_562 net11_563) resistor r=13
    rnet11_98 (net11_563 MM12_ELT_d) resistor r=8.44
    rnet11_97 (net11_565 net11_567) resistor r=0.573907
    rnet11_96 (net11_567 net11_568) resistor r=8.66667
    rnet11_95 (net11_567 net11_570) resistor r=0.702743
    rnet11_94 (net11_568 net11) resistor r=32.3614
    rnet11_93 (net11_570 net11_571) resistor r=8.66667
    rnet11_92 (net11_570 net11_573) resistor r=0.468495
    rnet11_91 (net11_571 net11) resistor r=16.1807
    rnet11_90 (net11_571 net11_574) resistor r=32.3614
    rnet11_89 (net11_573 net11_574) resistor r=26
    rnet11_88 (net11_663 net11_798) resistor r=10.0997
    rnet11_87 (net11_665 net11_798) resistor r=10.0997
    rnet11_86 (net11_717 net11_813) resistor r=3.725
    rnet11_85 (net11_719 net11_813) resistor r=3.725
    rnet11_84 (net11_731 net11_820) resistor r=3.725
    rnet11_83 (net11_733 net11_820) resistor r=3.725
    rnet11_82 (net11_785 net11_834) resistor r=10.0997
    rnet11_81 (net11_787 net11_834) resistor r=10.0997
    rnet11_80 (net11_797 net11_798) resistor r=0.877078
    rnet11_79 (net11_811 net11_813) resistor r=3.725
    rnet11_78 (net11_812 net11_813) resistor r=3.725
    rnet11_77 (net11_818 net11_820) resistor r=3.725
    rnet11_76 (net11_819 net11_820) resistor r=3.725
    rnet11_75 (net11_833 net11_834) resistor r=0.877078
    rI_189 (I_42 I_48) resistor r=58.3583
    rI_188 (I_42 I_48) resistor r=4.16253
    rI_187 (I_42 I_48) resistor r=58.3583
    rI_186 (I_42 I_48) resistor r=4.16253
    rI_185 (I_45 I_48) resistor r=58.3583
    rI_184 (I_45 I_48) resistor r=4.16253
    rI_183 (I_45 I_48) resistor r=58.3583
    rI_182 (I_45 I_48) resistor r=4.16253
    rI_181 (I_48 I_61) resistor r=24.8333
    rI_180 (I_48 I_58) resistor r=24.8333
    rI_179 (I_48 I_69) resistor r=24.8333
    rI_178 (I_48 I_66) resistor r=24.8333
    rI_177 (I_48 I_90) resistor r=58.3583
    rI_176 (I_48 I_93) resistor r=58.3583
    rI_175 (I_48 I_98) resistor r=14.9
    rI_174 (I_48 I_61) resistor r=4.16253
    rI_173 (I_48 I_69) resistor r=4.16253
    rI_172 (I_48 I_58) resistor r=4.16253
    rI_171 (I_48 I_90) resistor r=4.16253
    rI_170 (I_48 I_98) resistor r=6.30933
    rI_169 (I_48 I_93) resistor r=6.30933
    rI_168 (I_48 I_66) resistor r=1.63969
    rI_167 (I_48 I_61) resistor r=24.8333
    rI_166 (I_48 I_58) resistor r=24.8333
    rI_165 (I_48 I_69) resistor r=24.8333
    rI_164 (I_48 I_66) resistor r=24.8333
    rI_163 (I_48 I_90) resistor r=58.3583
    rI_162 (I_48 MM7_ELT_g) resistor r=22.35
    rI_161 (I_48 I_98) resistor r=14.9
    rI_160 (I_48 I_332) resistor r=40.975
    rI_159 (I_48 I_61) resistor r=4.16253
    rI_158 (I_48 I_69) resistor r=4.16253
    rI_157 (I_48 I_58) resistor r=4.16253
    rI_156 (I_48 I_90) resistor r=4.16253
    rI_155 (I_48 I_98) resistor r=6.30933
    rI_154 (I_48 I_93) resistor r=6.30933
    rI_153 (I_48 I_66) resistor r=1.63969
    rI_152 (I_50 I_56) resistor r=202.392
    rI_151 (I_50 I_56) resistor r=4.16253
    rI_150 (I_50 I_56) resistor r=202.392
    rI_149 (I_50 I_56) resistor r=4.16253
    rI_148 (I_53 I_56) resistor r=202.392
    rI_147 (I_53 I_56) resistor r=4.16253
    rI_146 (I_53 I_56) resistor r=202.392
    rI_145 (I_53 I_56) resistor r=4.16253
    rI_144 (I_56 I_77) resistor r=24.8333
    rI_143 (I_56 I_74) resistor r=24.8333
    rI_142 (I_56 I_85) resistor r=24.8333
    rI_141 (I_56 I_82) resistor r=24.8333
    rI_140 (I_56 I_104) resistor r=14.9
    rI_139 (I_56 I_110) resistor r=202.392
    rI_138 (I_56 I_113) resistor r=202.392
    rI_137 (I_56 I_77) resistor r=4.16253
    rI_136 (I_56 I_85) resistor r=4.16253
    rI_135 (I_56 I_110) resistor r=6.30933
    rI_134 (I_56 I_104) resistor r=6.30933
    rI_133 (I_56 I_74) resistor r=1.63969
    rI_132 (I_56 I_82) resistor r=4.16253
    rI_131 (I_56 I_113) resistor r=4.16253
    rI_130 (I_56 I_77) resistor r=24.8333
    rI_129 (I_56 I_74) resistor r=24.8333
    rI_128 (I_56 I_85) resistor r=24.8333
    rI_127 (I_56 I_82) resistor r=24.8333
    rI_126 (I_56 I_334) resistor r=40.975
    rI_125 (I_56 I_104) resistor r=14.9
    rI_124 (I_56 I_110) resistor r=202.392
    rI_123 (I_56 MM8_ELT_g) resistor r=7.45
    rI_122 (I_56 I_77) resistor r=4.16253
    rI_121 (I_56 I_85) resistor r=4.16253
    rI_120 (I_56 I_110) resistor r=6.30933
    rI_119 (I_56 I_104) resistor r=6.30933
    rI_118 (I_56 I_74) resistor r=1.63969
    rI_117 (I_56 I_82) resistor r=4.16253
    rI_116 (I_56 I_113) resistor r=4.16253
    rI_115 (I_93 MM7_ELT_g) resistor r=36.0083
    rI_114 (I_113 MM8_ELT_g) resistor r=194.942
    rI_113 (I_118 I_124) resistor r=58.3583
    rI_112 (I_118 I_124) resistor r=4.16253
    rI_111 (I_118 I_124) resistor r=58.3583
    rI_110 (I_118 I_124) resistor r=4.16253
    rI_109 (I_121 I_124) resistor r=58.3583
    rI_108 (I_121 I_124) resistor r=6.30933
    rI_107 (I_121 I_124) resistor r=58.3583
    rI_106 (I_121 I_124) resistor r=6.30933
    rI_105 (I_124 I_126) resistor r=14.9
    rI_104 (I_124 I_149) resistor r=24.8333
    rI_103 (I_124 I_146) resistor r=24.8333
    rI_102 (I_124 I_157) resistor r=24.8333
    rI_101 (I_124 I_154) resistor r=24.8333
    rI_100 (I_124 I_178) resistor r=58.3583
    rI_99 (I_124 I_181) resistor r=58.3583
    rI_98 (I_124 I_149) resistor r=4.16253
    rI_97 (I_124 I_126) resistor r=6.30933
    rI_96 (I_124 I_157) resistor r=1.63969
    rI_95 (I_124 I_146) resistor r=4.16253
    rI_94 (I_124 I_178) resistor r=4.16253
    rI_93 (I_124 I_154) resistor r=4.16253
    rI_92 (I_124 I_181) resistor r=4.16253
    rI_91 (I_124 I_126) resistor r=14.9
    rI_90 (I_124 I_348) resistor r=40.975
    rI_89 (I_124 I_149) resistor r=24.8333
    rI_88 (I_124 I_146) resistor r=24.8333
    rI_87 (I_124 I_157) resistor r=24.8333
    rI_86 (I_124 I_154) resistor r=24.8333
    rI_85 (I_124 I_178) resistor r=58.3583
    rI_84 (I_124 MM12_ELT_g) resistor r=7.45
    rI_83 (I_124 I_149) resistor r=4.16253
    rI_82 (I_124 I_126) resistor r=6.30933
    rI_81 (I_124 I_157) resistor r=1.63969
    rI_80 (I_124 I_146) resistor r=4.16253
    rI_79 (I_124 I_178) resistor r=4.16253
    rI_78 (I_124 I_154) resistor r=4.16253
    rI_77 (I_124 I_181) resistor r=4.16253
    rI_76 (I_132 I_135) resistor r=14.9
    rI_75 (I_132 I_135) resistor r=6.30933
    rI_74 (I_132 I_135) resistor r=14.9
    rI_73 (I_132 I_135) resistor r=6.30933
    rI_72 (I_135 I_138) resistor r=202.392
    rI_71 (I_135 I_141) resistor r=202.392
    rI_70 (I_135 I_165) resistor r=24.8333
    rI_69 (I_135 I_162) resistor r=24.8333
    rI_68 (I_135 I_173) resistor r=24.8333
    rI_67 (I_135 I_170) resistor r=24.8333
    rI_66 (I_135 I_186) resistor r=202.392
    rI_65 (I_135 I_189) resistor r=202.392
    rI_64 (I_135 I_138) resistor r=6.30933
    rI_63 (I_135 I_165) resistor r=1.63969
    rI_62 (I_135 I_173) resistor r=4.16253
    rI_61 (I_135 I_141) resistor r=4.16253
    rI_60 (I_135 I_162) resistor r=4.16253
    rI_59 (I_135 I_186) resistor r=4.16253
    rI_58 (I_135 I_170) resistor r=4.16253
    rI_57 (I_135 I_189) resistor r=4.16253
    rI_56 (I_135 I_350) resistor r=40.975
    rI_55 (I_135 I_138) resistor r=202.392
    rI_54 (I_135 I_141) resistor r=202.392
    rI_53 (I_135 I_165) resistor r=24.8333
    rI_52 (I_135 I_162) resistor r=24.8333
    rI_51 (I_135 I_173) resistor r=24.8333
    rI_50 (I_135 I_170) resistor r=24.8333
    rI_49 (I_135 I_186) resistor r=202.392
    rI_48 (I_135 MM13_ELT_g) resistor r=7.45
    rI_47 (I_135 I_138) resistor r=6.30933
    rI_46 (I_135 I_165) resistor r=1.63969
    rI_45 (I_135 I_173) resistor r=4.16253
    rI_44 (I_135 I_141) resistor r=4.16253
    rI_43 (I_135 I_162) resistor r=4.16253
    rI_42 (I_135 I_186) resistor r=4.16253
    rI_41 (I_135 I_170) resistor r=4.16253
    rI_40 (I_135 I_189) resistor r=4.16253
    rI_39 (I_181 MM12_ELT_g) resistor r=50.9083
    rI_38 (I_189 MM13_ELT_g) resistor r=194.942
    rI_37 (I_262 I_263) resistor r=10
    rI_36 (I_262 I) resistor r=0.0847532
    rI_35 (I_263 I_384) resistor r=41.3136
    rI_34 (I_332 I_385) resistor r=3.725
    rI_33 (I_334 I_385) resistor r=3.725
    rI_32 (I_342 I_343) resistor r=27.0909
    rI_31 (I_342 I_390) resistor r=0.877078
    rI_30 (I_343 I_385) resistor r=3.725
    rI_29 (I_348 I_390) resistor r=10.0997
    rI_28 (I_350 I_390) resistor r=10.0997
    rI_27 (I_384 I_385) resistor r=3.725
ends CKBD4_LVT_ELT
// End of subcircuit definition.
