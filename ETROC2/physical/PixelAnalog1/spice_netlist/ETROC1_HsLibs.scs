    ciCDN_37 (CDN_188 VSS) capacitor c=3.98759e-18
    ciCDN_36 (CDN_191 VSS) capacitor c=2.7683e-18
    ciCDN_35 (CDN_194 VSS) capacitor c=1.9243e-16
    ciCDN_34 (CDN_196 VSS) capacitor c=2.23814e-17
    ciCDN_33 (CDN_204 VSS) capacitor c=1.57787e-17
    ciCDN_32 (CDN_212 VSS) capacitor c=3.00043e-18
    ciCDN_31 (CDN_226 VSS) capacitor c=2.96645e-18
    ciCDN_30 (CDN_232 VSS) capacitor c=1.91262e-16
    ciCDN_29 (CDN_240 VSS) capacitor c=2.23697e-17
    ciCDN_28 (CDN_248 VSS) capacitor c=2.24819e-17
    ciCDN_27 (CDN_256 VSS) capacitor c=4.18692e-18
    ciCDN_26 (CDN_259 VSS) capacitor c=4.19476e-18
    ciCDN_25 (CDN_262 VSS) capacitor c=3.36342e-16
    ciCDN_24 (CDN_264 VSS) capacitor c=3.35294e-18
    ciCDN_23 (CDN_267 VSS) capacitor c=1.55908e-18
    ciCDN_22 (CDN_272 VSS) capacitor c=1.63877e-17
    ciCDN_21 (CDN_280 VSS) capacitor c=2.2416e-17
    ciCDN_20 (CDN_294 VSS) capacitor c=1.54276e-17
    ciCDN_19 (CDN_302 VSS) capacitor c=2.3845e-18
    ciCDN_18 (CDN_305 VSS) capacitor c=3.85496e-18
    ciCDN_17 (CDN_419 VSS) capacitor c=1.31568e-17
    ciCDN_16 (CDN_425 VSS) capacitor c=1.03141e-17
    ciCDN_15 (CDN_426 VSS) capacitor c=3.28003e-16
    ciCDN_14 (CDN_427 VSS) capacitor c=7.24841e-18
    ciCDN_13 (CDN_429 VSS) capacitor c=1.90237e-17
    ciCDN_12 (CDN_433 VSS) capacitor c=1.14929e-17
    ciCDN_11 (CDN_434 VSS) capacitor c=6.64674e-17
    ciCDN_10 (CDN_516 VSS) capacitor c=2.00727e-17
    ciCDN_9 (CDN_530 VSS) capacitor c=4.65722e-17
    ciCDN_8 (CDN_574 VSS) capacitor c=2.04818e-17
    ciCDN_7 (CDN_588 VSS) capacitor c=4.65108e-17
    ciCDN_6 (CDN_619 VSS) capacitor c=1.89325e-17
    ciCDN_5 (CDN_620 VSS) capacitor c=4.02528e-18
    ciCDN_4 (CDN_623 VSS) capacitor c=6.67042e-18
    ciCDN_3 (CDN_635 VSS) capacitor c=1.91922e-17
    ciCDN_2 (CDN_636 VSS) capacitor c=4.02528e-18
    ciCDN_1 (CDN_639 VSS) capacitor c=7.0064e-18
    ciCDN_0 (CDN VSS) capacitor c=6.50252e-17
    ciCPN_61 (CPN_42 VSS) capacitor c=6.11821e-18
    ciCPN_60 (CPN_48 VSS) capacitor c=2.2305e-16
    ciCPN_59 (CPN_56 VSS) capacitor c=3.09244e-17
    ciCPN_58 (CPN_64 VSS) capacitor c=2.33696e-17
    ciCPN_57 (CPN_72 VSS) capacitor c=1.12048e-17
    ciCPN_56 (CPN_75 VSS) capacitor c=7.60354e-18
    ciCPN_55 (CPN_83 VSS) capacitor c=1.54514e-16
    ciCPN_54 (CPN_89 VSS) capacitor c=5.55839e-18
    ciCPN_53 (CPN_94 VSS) capacitor c=1.57439e-17
    ciCPN_52 (CPN_102 VSS) capacitor c=2.93691e-17
    ciCPN_51 (CPN_110 VSS) capacitor c=4.57751e-18
    ciCPN_50 (CPN_113 VSS) capacitor c=5.77941e-18
    ciCPN_49 (CPN_118 VSS) capacitor c=4.1198e-18
    ciCPN_48 (CPN_124 VSS) capacitor c=1.62743e-16
    ciCPN_47 (CPN_132 VSS) capacitor c=2.24499e-17
    ciCPN_46 (CPN_140 VSS) capacitor c=3.00502e-17
    ciCPN_45 (CPN_148 VSS) capacitor c=5.54274e-18
    ciCPN_44 (CPN_151 VSS) capacitor c=1.07887e-17
    ciCPN_43 (CPN_156 VSS) capacitor c=2e-18
    ciCPN_42 (CPN_159 VSS) capacitor c=4.15066e-18
    ciCPN_41 (CPN_162 VSS) capacitor c=1.64728e-16
    ciCPN_40 (CPN_164 VSS) capacitor c=1.99757e-17
    ciCPN_39 (CPN_172 VSS) capacitor c=2.2416e-17
    ciCPN_38 (CPN_189 VSS) capacitor c=5.86975e-18
    ciCPN_37 (CPN_264 VSS) capacitor c=5.60767e-17
    ciCPN_36 (CPN_265 VSS) capacitor c=1.12678e-16
    ciCPN_35 (CPN_269 VSS) capacitor c=6.63856e-17
    ciCPN_34 (CPN_270 VSS) capacitor c=3.60133e-16
    ciCPN_33 (CPN_273 VSS) capacitor c=4.45441e-17
    ciCPN_32 (CPN_276 VSS) capacitor c=1.5589e-16
    ciCPN_31 (CPN_277 VSS) capacitor c=1.829e-17
    ciCPN_30 (CPN_278 VSS) capacitor c=3.61917e-17
    ciCPN_29 (CPN_279 VSS) capacitor c=1.67836e-17
    ciCPN_28 (CPN_280 VSS) capacitor c=3.22344e-17
    ciCPN_27 (CPN_281 VSS) capacitor c=1.83303e-17
    ciCPN_26 (CPN_284 VSS) capacitor c=6.24543e-17
    ciCPN_25 (CPN_288 VSS) capacitor c=9.71099e-17
    ciCPN_24 (CPN_290 VSS) capacitor c=9.11376e-17
    ciCPN_23 (CPN_291 VSS) capacitor c=7.84418e-17
    ciCPN_22 (CPN_292 VSS) capacitor c=1.57589e-17
    ciCPN_21 (CPN_294 VSS) capacitor c=2.35574e-17
    ciCPN_20 (CPN_298 VSS) capacitor c=4.46511e-18
    ciCPN_19 (CPN_300 VSS) capacitor c=4.6818e-18
    ciCPN_18 (CPN_302 VSS) capacitor c=2.17116e-17
    ciCPN_17 (CPN_306 VSS) capacitor c=1.88751e-17
    ciCPN_16 (CPN_309 VSS) capacitor c=3.78525e-16
    ciCPN_15 (CPN_310 VSS) capacitor c=4.56202e-18
    ciCPN_14 (CPN_313 VSS) capacitor c=8.23167e-17
    ciCPN_13 (CPN_314 VSS) capacitor c=9.56399e-17
    ciCPN_12 (CPN_317 VSS) capacitor c=1.72954e-17
    ciCPN_11 (CPN_320 VSS) capacitor c=1.01179e-16
    ciCPN_10 (CPN_321 VSS) capacitor c=1.0437e-16
    ciCPN_9 (CPN_323 VSS) capacitor c=8.66245e-18
    ciCPN_8 (CPN_400 VSS) capacitor c=5.21338e-17
    ciCPN_7 (CPN_401 VSS) capacitor c=1.86114e-17
    ciCPN_6 (CPN_440 VSS) capacitor c=6.30845e-17
    ciCPN_5 (CPN_443 VSS) capacitor c=1.98622e-17
    ciCPN_4 (CPN_444 VSS) capacitor c=3.01009e-17
    ciCPN_3 (CPN_456 VSS) capacitor c=2.56178e-17
    ciCPN_2 (CPN_457 VSS) capacitor c=2.9223e-17
    ciCPN_1 (CPN_465 VSS) capacitor c=1.1727e-16
    ciCPN_0 (CPN VSS) capacitor c=1.8289e-17
    cinet49_6 (net49_3 VSS) capacitor c=7.1677e-17
    cinet49_5 (net49_4 VSS) capacitor c=1.28094e-16
    cinet49_4 (net49_8 VSS) capacitor c=7.05563e-17
    cinet49_3 (net49_9 VSS) capacitor c=1.2637e-16
    cinet49_2 (net49_12 VSS) capacitor c=4.92771e-17
    cinet49_1 (net49_15 VSS) capacitor c=1.84079e-17
    cinet49_0 (net49_19 VSS) capacitor c=2.23942e-17
    ciD_17 (D_22 VSS) capacitor c=6.71104e-18
    ciD_16 (D_25 VSS) capacitor c=3.24512e-18
    ciD_15 (D_28 VSS) capacitor c=2.15492e-16
    ciD_14 (D_30 VSS) capacitor c=2.61061e-17
    ciD_13 (D_38 VSS) capacitor c=2.24523e-17
    ciD_12 (D_55 VSS) capacitor c=4.09944e-18
    ciD_11 (D_60 VSS) capacitor c=5.93984e-18
    ciD_10 (D_66 VSS) capacitor c=1.77842e-16
    ciD_9 (D_74 VSS) capacitor c=2.23351e-17
    ciD_8 (D_82 VSS) capacitor c=2.63594e-17
    ciD_7 (D_90 VSS) capacitor c=3.98759e-18
    ciD_6 (D_93 VSS) capacitor c=6.94225e-18
    ciD_5 (D VSS) capacitor c=8.77154e-17
    ciD_4 (D_175 VSS) capacitor c=3.03799e-17
    ciD_3 (D_176 VSS) capacitor c=2.09171e-17
    ciD_2 (D_184 VSS) capacitor c=1.24823e-16
    ciD_1 (D_202 VSS) capacitor c=5.36148e-17
    ciD_0 (D_203 VSS) capacitor c=9.03943e-18
    ciCPNN_68 (CPNN_62 VSS) capacitor c=3.00043e-18
    ciCPNN_67 (CPNN_68 VSS) capacitor c=1.80873e-16
    ciCPNN_66 (CPNN_79 VSS) capacitor c=6.27395e-16
    ciCPNN_65 (CPNN_85 VSS) capacitor c=3.85496e-18
    ciCPNN_64 (CPNN_90 VSS) capacitor c=2.73232e-17
    ciCPNN_63 (CPNN_98 VSS) capacitor c=2.10657e-17
    ciCPNN_62 (CPNN_106 VSS) capacitor c=1.20384e-17
    ciCPNN_61 (CPNN_114 VSS) capacitor c=1.52949e-17
    ciCPNN_60 (CPNN_122 VSS) capacitor c=5.51938e-18
    ciCPNN_59 (CPNN_125 VSS) capacitor c=4.8925e-18
    ciCPNN_58 (CPNN_130 VSS) capacitor c=3.58176e-18
    ciCPNN_57 (CPNN_133 VSS) capacitor c=3.8335e-18
    ciCPNN_56 (CPNN_138 VSS) capacitor c=7.13834e-18
    ciCPNN_55 (CPNN_144 VSS) capacitor c=1.53549e-16
    ciCPNN_54 (CPNN_152 VSS) capacitor c=3.29066e-17
    ciCPNN_53 (CPNN_160 VSS) capacitor c=2.84415e-17
    ciCPNN_52 (CPNN_168 VSS) capacitor c=9.16502e-18
    ciCPNN_51 (CPNN_171 VSS) capacitor c=6.91821e-18
    ciCPNN_50 (CPNN_176 VSS) capacitor c=3.48325e-18
    ciCPNN_49 (CPNN_179 VSS) capacitor c=4.11777e-18
    ciCPNN_48 (CPNN_182 VSS) capacitor c=1.6533e-16
    ciCPNN_47 (CPNN_184 VSS) capacitor c=2.06745e-17
    ciCPNN_46 (CPNN_192 VSS) capacitor c=2.24618e-17
    ciCPNN_45 (CPNN_209 VSS) capacitor c=5.85024e-18
    ciCPNN_44 (CPNN_214 VSS) capacitor c=6.58461e-18
    ciCPNN_43 (CPNN_220 VSS) capacitor c=2.18542e-16
    ciCPNN_42 (CPNN_228 VSS) capacitor c=3.11327e-17
    ciCPNN_41 (CPNN_236 VSS) capacitor c=2.19142e-17
    ciCPNN_40 (CPNN_244 VSS) capacitor c=1.09534e-17
    ciCPNN_39 (CPNN_247 VSS) capacitor c=7.64645e-18
    ciCPNN_38 (CPNN_255 VSS) capacitor c=1.54026e-16
    ciCPNN_37 (CPNN_261 VSS) capacitor c=5.55839e-18
    ciCPNN_36 (CPNN_266 VSS) capacitor c=1.60291e-17
    ciCPNN_35 (CPNN_274 VSS) capacitor c=2.93147e-17
    ciCPNN_34 (CPNN_282 VSS) capacitor c=4.99965e-18
    ciCPNN_33 (CPNN_285 VSS) capacitor c=5.30935e-18
    ciCPNN_32 (CPNN_393 VSS) capacitor c=5.4564e-17
    ciCPNN_31 (CPNN_394 VSS) capacitor c=1.11566e-16
    ciCPNN_30 (CPNN_398 VSS) capacitor c=1.78942e-16
    ciCPNN_29 (CPNN_399 VSS) capacitor c=3.29389e-16
    ciCPNN_28 (CPNN_407 VSS) capacitor c=5.01823e-17
    ciCPNN_27 (CPNN_408 VSS) capacitor c=1.44104e-17
    ciCPNN_26 (CPNN_409 VSS) capacitor c=4.33024e-17
    ciCPNN_25 (CPNN_410 VSS) capacitor c=1.26428e-17
    ciCPNN_24 (CPNN_412 VSS) capacitor c=3.21317e-18
    ciCPNN_23 (CPNN_414 VSS) capacitor c=8.69709e-18
    ciCPNN_22 (CPNN_416 VSS) capacitor c=1.72206e-17
    ciCPNN_21 (CPNN_417 VSS) capacitor c=2.66976e-17
    ciCPNN_20 (CPNN_419 VSS) capacitor c=7.65622e-17
    ciCPNN_19 (CPNN_423 VSS) capacitor c=1.72874e-17
    ciCPNN_18 (CPNN_425 VSS) capacitor c=1.5554e-17
    ciCPNN_17 (CPNN_426 VSS) capacitor c=3.21418e-17
    ciCPNN_16 (CPNN_429 VSS) capacitor c=4.31213e-17
    ciCPNN_15 (CPNN_432 VSS) capacitor c=9.39113e-17
    ciCPNN_14 (CPNN_433 VSS) capacitor c=3.32053e-16
    ciCPNN_13 (CPNN_434 VSS) capacitor c=1.81286e-17
    ciCPNN_12 (CPNN_437 VSS) capacitor c=1.05743e-16
    ciCPNN_11 (CPNN_441 VSS) capacitor c=1.10725e-16
    ciCPNN_10 (CPNN_442 VSS) capacitor c=1.08429e-16
    ciCPNN_9 (CPNN_443 VSS) capacitor c=1.33805e-17
    ciCPNN_8 (CPNN_445 VSS) capacitor c=2.14716e-16
    ciCPNN_7 (CPNN_446 VSS) capacitor c=6.82272e-17
    ciCPNN_6 (CPNN_526 VSS) capacitor c=7.86757e-17
    ciCPNN_5 (CPNN_630 VSS) capacitor c=2.56178e-17
    ciCPNN_4 (CPNN_631 VSS) capacitor c=2.83969e-17
    ciCPNN_3 (CPNN_636 VSS) capacitor c=5.18827e-17
    ciCPNN_2 (CPNN_639 VSS) capacitor c=1.55987e-17
    ciCPNN_1 (CPNN_640 VSS) capacitor c=2.52666e-17
    ciCPNN_0 (CPNN_656 VSS) capacitor c=1.87092e-17
    ciCP_13 (CP_22 VSS) capacitor c=2.22299e-18
    ciCP_12 (CP_28 VSS) capacitor c=1.77235e-16
    ciCP_11 (CP_39 VSS) capacitor c=5.58143e-16
    ciCP_10 (CP_45 VSS) capacitor c=2.22299e-18
    ciCP_9 (CP_50 VSS) capacitor c=2.23697e-17
    ciCP_8 (CP_58 VSS) capacitor c=2.24908e-17
    ciCP_7 (CP_66 VSS) capacitor c=1.36936e-17
    ciCP_6 (CP_74 VSS) capacitor c=1.51948e-17
    ciCP_5 (CP_82 VSS) capacitor c=4.2013e-18
    ciCP_4 (CP_85 VSS) capacitor c=8.01306e-18
    ciCP_3 (CP_90 VSS) capacitor c=5.01351e-18
    ciCP_2 (CP_93 VSS) capacitor c=5.13601e-18
    ciCP_1 (CP VSS) capacitor c=5.51613e-17
    ciCP_0 (CP_201 VSS) capacitor c=3.22364e-17
    rnet299_32 (MM6_s net299_2) resistor r=18.0507
    rnet299_31 (MM6_s net299_5) resistor r=15.1041
    rnet299_30 (MM6_s net299_5) resistor r=2.67027
    rnet299_29 (MM6_s net299_7) resistor r=12.8495
    rnet299_28 (MM6_s net299_7) resistor r=1.69926
    rnet299_27 (MM6_s net299_11) resistor r=4.22001
    rnet299_26 (MM6_s net299) resistor r=10.6787
    rnet299_25 (net299_2 net299_4) resistor r=9.43134
    rnet299_24 (net299_4 net299_5) resistor r=15.1041
    rnet299_23 (net299_6 net299_7) resistor r=12.8495
    rnet299_22 (net299_6 net299_18) resistor r=10.6787
    rnet299_21 (net299_8 net299_11) resistor r=4.22001
    rnet299_20 (net299_8 net299_18) resistor r=0.57282
    rnet299_19 (net299_9 net299_11) resistor r=4.22001
    rnet299_18 (net299_9 net299) resistor r=0.57282
    rnet299_17 (MM4_d net299_11) resistor r=4.22001
    rnet299_16 (MM4_d net299_14) resistor r=15.1041
    rnet299_15 (MM4_d net299_14) resistor r=2.67027
    rnet299_14 (MM4_d net299_16) resistor r=12.1643
    rnet299_13 (MM4_d net299_16) resistor r=1.36649
    rnet299_12 (MM4_d net299_17) resistor r=18.0507
    rnet299_11 (MM4_d net299_18) resistor r=10.6787
    rnet299_10 (net299_12 net299_14) resistor r=15.1041
    rnet299_9 (net299_12 net299_17) resistor r=9.43134
    rnet299_8 (net299_15 net299_16) resistor r=12.1643
    rnet299_7 (net299_15 net299) resistor r=10.6787
    rnet177_35 (MM5_s net177_2) resistor r=18.0507
    rnet177_34 (MM5_s net177_5) resistor r=2.67027
    rnet177_33 (MM5_s net177_7) resistor r=12.8495
    rnet177_32 (MM5_s net177_7) resistor r=1.69926
    rnet177_31 (MM5_s net177_11) resistor r=4.22001
    rnet177_30 (net177_2 net177_4) resistor r=9.43134
    rnet177_29 (net177_3 net177_5) resistor r=15.1041
    rnet177_28 (net177_3 net177_20) resistor r=11.0157
    rnet177_27 (net177_4 net177_5) resistor r=15.1041
    rnet177_26 (net177_6 net177_7) resistor r=12.8495
    rnet177_25 (net177_6 net177) resistor r=10.6787
    rnet177_24 (net177_8 net177_11) resistor r=4.22001
    rnet177_23 (net177_8 net177_20) resistor r=0.762262
    rnet177_22 (net177_9 net177_11) resistor r=4.22001
    rnet177_21 (net177_9 net177) resistor r=0.57282
    rnet177_20 (MM3_d net177_11) resistor r=4.22001
    rnet177_19 (MM3_d net177_14) resistor r=2.67027
    rnet177_18 (MM3_d net177_16) resistor r=12.8495
    rnet177_17 (MM3_d net177_16) resistor r=1.69926
    rnet177_16 (MM3_d net177_19) resistor r=4.557
    rnet177_15 (MM3_d net177) resistor r=10.6787
    rnet177_14 (net177_12 net177_14) resistor r=15.1041
    rnet177_13 (net177_12 net177_17) resistor r=9.43134
    rnet177_12 (net177_13 net177_14) resistor r=15.1041
    rnet177_11 (net177_13 net177_20) resistor r=11.0157
    rnet177_10 (net177_15 net177_16) resistor r=12.8495
    rnet177_9 (net177_15 net177_18) resistor r=9.4369
    rnet177_8 (net177_17 net177_19) resistor r=21.1301
    rnet177_7 (net177_18 net177_19) resistor r=21.1301
    rnet29_32 (MM11_ELT_s net29_2) resistor r=18.0507
    rnet29_31 (MM11_ELT_s net29_5) resistor r=15.1041
    rnet29_30 (MM11_ELT_s net29_5) resistor r=2.67027
    rnet29_29 (MM11_ELT_s net29_7) resistor r=12.8495
    rnet29_28 (MM11_ELT_s net29_7) resistor r=1.69926
    rnet29_27 (MM11_ELT_s net29_11) resistor r=4.22001
    rnet29_26 (MM11_ELT_s net29) resistor r=10.6787
    rnet29_25 (net29_2 net29_4) resistor r=9.43134
    rnet29_24 (net29_4 net29_5) resistor r=15.1041
    rnet29_23 (net29_6 net29_7) resistor r=12.8495
    rnet29_22 (net29_6 net29_18) resistor r=10.6787
    rnet29_21 (net29_8 net29_11) resistor r=4.22001
    rnet29_20 (net29_8 net29_18) resistor r=0.57282
    rnet29_19 (net29_9 net29_11) resistor r=4.22001
    rnet29_18 (net29_9 net29) resistor r=0.57282
    rnet29_17 (MM12_ELT_d net29_11) resistor r=4.22001
    rnet29_16 (MM12_ELT_d net29_14) resistor r=15.1041
    rnet29_15 (MM12_ELT_d net29_14) resistor r=2.67027
    rnet29_14 (MM12_ELT_d net29_16) resistor r=12.1643
    rnet29_13 (MM12_ELT_d net29_16) resistor r=1.36649
    rnet29_12 (MM12_ELT_d net29_17) resistor r=18.0507
    rnet29_11 (MM12_ELT_d net29_18) resistor r=10.6787
    rnet29_10 (net29_12 net29_14) resistor r=15.1041
    rnet29_9 (net29_12 net29_17) resistor r=9.43134
    rnet29_8 (net29_15 net29_16) resistor r=12.1643
    rnet29_7 (net29_15 net29) resistor r=10.6787
    rnet17_38 (MM16_ELT_s net17_2) resistor r=18.0507
    rnet17_37 (MM16_ELT_s net17_5) resistor r=2.67027
    rnet17_36 (MM16_ELT_s net17_7) resistor r=12.8495
    rnet17_35 (MM16_ELT_s net17_7) resistor r=1.69926
    rnet17_34 (MM16_ELT_s net17_11) resistor r=4.22001
    rnet17_33 (net17_2 net17_4) resistor r=9.43134
    rnet17_32 (net17_3 net17_5) resistor r=15.1041
    rnet17_31 (net17_3 net17_20) resistor r=11.0157
    rnet17_30 (net17_4 net17_5) resistor r=15.1041
    rnet17_29 (net17_6 net17_7) resistor r=12.8495
    rnet17_28 (net17_6 net17) resistor r=10.6787
    rnet17_27 (net17_8 net17_11) resistor r=4.22001
    rnet17_26 (net17_8 net17_20) resistor r=0.762262
    rnet17_25 (net17_9 net17_11) resistor r=4.22001
    rnet17_24 (net17_9 net17) resistor r=0.57282
    rnet17_23 (MM17_ELT_d net17_11) resistor r=4.22001
    rnet17_22 (MM17_ELT_d net17_14) resistor r=2.67027
    rnet17_21 (MM17_ELT_d net17_16) resistor r=12.8495
    rnet17_20 (MM17_ELT_d net17_16) resistor r=1.69926
    rnet17_19 (MM17_ELT_d net17_19) resistor r=4.557
    rnet17_18 (MM17_ELT_d net17) resistor r=10.6787
    rnet17_17 (net17_12 net17_14) resistor r=15.1041
    rnet17_16 (net17_12 net17_17) resistor r=9.43134
    rnet17_15 (net17_13 net17_14) resistor r=15.1041
    rnet17_14 (net17_13 net17_20) resistor r=11.0157
    rnet17_13 (net17_15 net17_16) resistor r=12.8495
    rnet17_12 (net17_15 net17_18) resistor r=9.4369
    rnet17_11 (net17_17 net17_19) resistor r=21.1301
    rnet17_10 (net17_18 net17_19) resistor r=21.1301
    rnet722_36 (net722_1 net722_4) resistor r=20.2547
    rnet722_35 (net722_1 net722_5) resistor r=9.04595
    rnet722_34 (net722_2 net722_4) resistor r=20.2547
    rnet722_33 (net722_2 net722_8) resistor r=9.04062
    rnet722_32 (MM8_s net722_4) resistor r=4.36821
    rnet722_31 (MM8_s net722_6) resistor r=12.3172
    rnet722_30 (MM8_s net722_6) resistor r=1.62887
    rnet722_29 (MM8_s net722_9) resistor r=2.55965
    rnet722_28 (MM8_s net722_13) resistor r=4.04518
    rnet722_27 (MM8_s net722_20) resistor r=10.2363
    rnet722_26 (net722_5 net722_6) resistor r=12.3172
    rnet722_25 (net722_7 net722_9) resistor r=14.4784
    rnet722_24 (net722_7 net722) resistor r=10.5593
    rnet722_23 (net722_8 net722_9) resistor r=14.4784
    rnet722_22 (net722_10 net722_13) resistor r=4.04518
    rnet722_21 (net722_10 net722_20) resistor r=0.549089
    rnet722_20 (net722_11 net722_13) resistor r=4.04518
    rnet722_19 (net722_11 net722) resistor r=0.730683
    rnet722_18 (MM12_d net722_13) resistor r=4.04518
    rnet722_17 (MM12_d net722_15) resistor r=11.6604
    rnet722_16 (MM12_d net722_15) resistor r=1.30988
    rnet722_15 (MM12_d net722_18) resistor r=2.55965
    rnet722_14 (MM12_d net722_19) resistor r=17.3029
    rnet722_13 (net722_14 net722_15) resistor r=11.6604
    rnet722_12 (net722_14 net722_20) resistor r=10.2363
    rnet722_11 (net722_16 net722_18) resistor r=14.4784
    rnet722_10 (net722_16 net722_19) resistor r=9.04062
    rnet722_9 (net722_17 net722_18) resistor r=14.4784
    rnet722_8 (net722_17 net722) resistor r=10.5593
    rnet72_37 (net72_1 net72_4) resistor r=20.2547
    rnet72_36 (net72_1 net72_5) resistor r=9.04595
    rnet72_35 (net72_2 net72_4) resistor r=20.2547
    rnet72_34 (net72_2 net72_8) resistor r=9.04062
    rnet72_33 (MM10_ELT_s net72_4) resistor r=4.36821
    rnet72_32 (MM10_ELT_s net72_6) resistor r=12.3172
    rnet72_31 (MM10_ELT_s net72_6) resistor r=1.62887
    rnet72_30 (MM10_ELT_s net72_9) resistor r=2.55965
    rnet72_29 (MM10_ELT_s net72_13) resistor r=4.04518
    rnet72_28 (MM10_ELT_s net72_20) resistor r=10.2363
    rnet72_27 (net72_5 net72_6) resistor r=12.3172
    rnet72_26 (net72_7 net72_9) resistor r=14.4784
    rnet72_25 (net72_7 net72) resistor r=10.5593
    rnet72_24 (net72_8 net72_9) resistor r=14.4784
    rnet72_23 (net72_10 net72_13) resistor r=4.04518
    rnet72_22 (net72_10 net72_20) resistor r=0.549089
    rnet72_21 (net72_11 net72_13) resistor r=4.04518
    rnet72_20 (net72_11 net72) resistor r=0.730683
    rnet72_19 (MM9_ELT_d net72_13) resistor r=4.04518
    rnet72_18 (MM9_ELT_d net72_15) resistor r=11.6604
    rnet72_17 (MM9_ELT_d net72_15) resistor r=1.30988
    rnet72_16 (MM9_ELT_d net72_18) resistor r=2.55965
    rnet72_15 (MM9_ELT_d net72_19) resistor r=17.3029
    rnet72_14 (net72_14 net72_15) resistor r=11.6604
    rnet72_13 (net72_14 net72_20) resistor r=10.2363
    rnet72_12 (net72_16 net72_18) resistor r=14.4784
    rnet72_11 (net72_16 net72_19) resistor r=9.04062
    rnet72_10 (net72_17 net72_18) resistor r=14.4784
    rnet72_9 (net72_17 net72) resistor r=10.5593
    rQ_130 (Q_22 Q_28) resistor r=58.3583
    rQ_129 (Q_22 Q_28) resistor r=4.16253
    rQ_128 (Q_22 Q_28) resistor r=58.3583
    rQ_127 (Q_22 Q_28) resistor r=4.16253
    rQ_126 (Q_25 Q_28) resistor r=58.3583
    rQ_125 (Q_25 Q_28) resistor r=4.16253
    rQ_124 (Q_25 Q_28) resistor r=58.3583
    rQ_123 (Q_25 Q_28) resistor r=4.16253
    rQ_122 (Q_28 Q_33) resistor r=22.35
    rQ_121 (Q_28 Q_30) resistor r=22.35
    rQ_120 (Q_28 Q_41) resistor r=24.8333
    rQ_119 (Q_28 Q_38) resistor r=24.8333
    rQ_118 (Q_28 Q_54) resistor r=11.175
    rQ_117 (Q_28 Q_76) resistor r=58.3583
    rQ_116 (Q_28 Q_79) resistor r=58.3583
    rQ_115 (Q_28 Q_33) resistor r=4.16253
    rQ_114 (Q_28 Q_41) resistor r=4.16253
    rQ_113 (Q_28 Q_76) resistor r=5.53947
    rQ_112 (Q_28 Q_54) resistor r=5.53947
    rQ_111 (Q_28 Q_30) resistor r=2.32428
    rQ_110 (Q_28 Q_38) resistor r=4.16253
    rQ_109 (Q_28 Q_79) resistor r=4.16253
    rQ_108 (Q_28 Q_33) resistor r=22.35
    rQ_107 (Q_28 Q_30) resistor r=22.35
    rQ_106 (Q_28 Q_41) resistor r=24.8333
    rQ_105 (Q_28 Q_38) resistor r=24.8333
    rQ_104 (Q_28 Q_199) resistor r=35.3875
    rQ_103 (Q_28 Q_54) resistor r=11.175
    rQ_102 (Q_28 Q_76) resistor r=58.3583
    rQ_101 (Q_28 MM12_g) resistor r=7.45
    rQ_100 (Q_28 Q_33) resistor r=4.16253
    rQ_99 (Q_28 Q_41) resistor r=4.16253
    rQ_98 (Q_28 Q_76) resistor r=5.53947
    rQ_97 (Q_28 Q_54) resistor r=5.53947
    rQ_96 (Q_28 Q_30) resistor r=2.32428
    rQ_95 (Q_28 Q_38) resistor r=4.16253
    rQ_94 (Q_28 Q_79) resistor r=4.16253
    rQ_93 (Q_46 Q_52) resistor r=58.3583
    rQ_92 (Q_46 Q_52) resistor r=4.16253
    rQ_91 (Q_46 Q_52) resistor r=58.3583
    rQ_90 (Q_46 Q_52) resistor r=4.16253
    rQ_89 (Q_49 Q_52) resistor r=58.3583
    rQ_88 (Q_49 Q_52) resistor r=4.16253
    rQ_87 (Q_49 Q_52) resistor r=58.3583
    rQ_86 (Q_49 Q_52) resistor r=4.16253
    rQ_85 (Q_52 Q_63) resistor r=24.8333
    rQ_84 (Q_52 Q_60) resistor r=24.8333
    rQ_83 (Q_52 Q_71) resistor r=22.35
    rQ_82 (Q_52 Q_68) resistor r=22.35
    rQ_81 (Q_52 Q_84) resistor r=11.175
    rQ_80 (Q_52 Q_90) resistor r=58.3583
    rQ_79 (Q_52 Q_93) resistor r=58.3583
    rQ_78 (Q_52 Q_63) resistor r=4.16253
    rQ_77 (Q_52 Q_71) resistor r=4.16253
    rQ_76 (Q_52 Q_84) resistor r=5.53947
    rQ_75 (Q_52 Q_93) resistor r=5.53947
    rQ_74 (Q_52 Q_68) resistor r=2.32428
    rQ_73 (Q_52 Q_60) resistor r=4.16253
    rQ_72 (Q_52 Q_90) resistor r=4.16253
    rQ_71 (Q_52 Q_63) resistor r=24.8333
    rQ_70 (Q_52 Q_60) resistor r=24.8333
    rQ_69 (Q_52 Q_71) resistor r=22.35
    rQ_68 (Q_52 Q_68) resistor r=22.35
    rQ_67 (Q_52 Q_84) resistor r=11.175
    rQ_66 (Q_52 Q_214) resistor r=30.7313
    rQ_65 (Q_52 Q_90) resistor r=58.3583
    rQ_64 (Q_52 MM4_g) resistor r=22.35
    rQ_63 (Q_52 Q_63) resistor r=4.16253
    rQ_62 (Q_52 Q_71) resistor r=4.16253
    rQ_61 (Q_52 Q_84) resistor r=5.53947
    rQ_60 (Q_52 Q_93) resistor r=5.53947
    rQ_59 (Q_52 Q_68) resistor r=2.32428
    rQ_58 (Q_52 Q_60) resistor r=4.16253
    rQ_57 (Q_52 Q_90) resistor r=4.16253
    rQ_56 (Q_79 MM12_g) resistor r=50.9083
    rQ_55 (Q_93 MM4_g) resistor r=36.0083
    rQ_54 (Q_131 Q_133) resistor r=0.777694
    rQ_53 (Q_131 Q_137) resistor r=0.0971872
    rQ_52 (Q_133 Q_134) resistor r=10
    rQ_51 (Q_134 Q_231) resistor r=0.677273
    rQ_50 (Q_136 Q_137) resistor r=1.24062
    rQ_49 (Q_136 Q_139) resistor r=0.096078
    rQ_48 (Q_138 Q_139) resistor r=0.458685
    rQ_47 (Q_138 Q_164) resistor r=0.0466401
    rQ_46 (Q_140 Q_142) resistor r=0.303724
    rQ_45 (Q_140 Q_160) resistor r=0.0100989
    rQ_44 (Q_142 Q_143) resistor r=13
    rQ_43 (Q_143 MM2_d) resistor r=8.44
    rQ_42 (Q_145 Q_147) resistor r=0.442265
    rQ_41 (Q_145 Q_164) resistor r=0.0100989
    rQ_40 (Q_147 Q_148) resistor r=8.66667
    rQ_39 (Q_147 Q_150) resistor r=0.639419
    rQ_38 (Q_148 MM9_d) resistor r=32.3614
    rQ_37 (Q_150 Q_151) resistor r=8.66667
    rQ_36 (Q_150 Q_153) resistor r=0.426279
    rQ_35 (Q_151 MM9_d) resistor r=16.1807
    rQ_34 (Q_151 Q_154) resistor r=32.3614
    rQ_33 (Q_153 Q_154) resistor r=26
    rQ_32 (Q_156 Q) resistor r=0.156128
    rQ_31 (Q_156 Q_162) resistor r=0.0100989
    rQ_30 (Q_157 Q) resistor r=0.497792
    rQ_29 (Q_157 Q_165) resistor r=0.0100989
    rQ_28 (Q_160 Q_162) resistor r=0.151088
    rQ_27 (Q_164 Q_165) resistor r=0.155467
    rQ_26 (Q_199 Q_231) resistor r=3.1797
    rQ_25 (Q_214 Q_232) resistor r=3.1797
    rQ_24 (Q_231 Q_232) resistor r=25.7364
    rVDD_285 (MM1_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_284 (MM15_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_283 (MM14_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_282 (MM10_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_281 (MM9_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_280 (MM8_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_279 (MM6_ELT_b MM28_ELT_b) resistor r=0.01
    rVDD_278 (MM7_b MM28_ELT_b) resistor r=0.01
    rVDD_277 (MM10_b MM28_ELT_b) resistor r=0.01
    rVDD_276 (MM8_b MM28_ELT_b) resistor r=0.01
    rVDD_275 (MM12_b MM28_ELT_b) resistor r=0.01
    rVDD_274 (MM11_b MM28_ELT_b) resistor r=0.01
    rVDD_273 (MM9_b MM28_ELT_b) resistor r=0.01
    rVDD_272 (MM28_ELT_b VDD_59) resistor r=8.66667
    rVDD_271 (MM28_ELT_b VDD_69) resistor r=8.66667
    rVDD_270 (MM28_ELT_b VDD_72) resistor r=8.66667
    rVDD_269 (MM28_ELT_b VDD_82) resistor r=8.66667
    rVDD_268 (MM28_ELT_b VDD_97) resistor r=13
    rVDD_267 (MM28_ELT_b VDD_105) resistor r=8.66667
    rVDD_266 (MM28_ELT_b VDD_109) resistor r=8.66667
    rVDD_265 (MM28_ELT_b VDD_50) resistor r=56.2667
    rVDD_264 (VDD_2 VDD_7) resistor r=0.114658
    rVDD_263 (VDD_2 VDD_100) resistor r=0.0221592
    rVDD_262 (VDD VDD_7) resistor r=0.102797
    rVDD_261 (VDD_7 VDD_8) resistor r=8.66667
    rVDD_260 (VDD_8 VDD_24) resistor r=67.52
    rVDD_259 (VDD_9 VDD_18) resistor r=0.538211
    rVDD_258 (VDD_9 VDD_100) resistor r=0.0882196
    rVDD_257 (VDD_11 VDD_19) resistor r=8.66667
    rVDD_256 (VDD_11 VDD_15) resistor r=0.702015
    rVDD_255 (VDD_15 VDD_19) resistor r=8.66667
    rVDD_254 (VDD_15 VDD_18) resistor r=0.46801
    rVDD_253 (VDD_18 VDD_19) resistor r=13
    rVDD_252 (VDD_19 MM1_ELT_s) resistor r=4.04518
    rVDD_251 (VDD_19 VDD_187) resistor r=4.04518
    rVDD_250 (VDD_19 MM28_ELT_s) resistor r=4.04518
    rVDD_249 (VDD_19 VDD_185) resistor r=4.04518
    rVDD_248 (VDD_20 VDD_23) resistor r=0.168033
    rVDD_247 (VDD_20 VDD_101) resistor r=0.0221592
    rVDD_246 (VDD_21 VDD_23) resistor r=0.0869819
    rVDD_245 (VDD_21 VDD_100) resistor r=0.0221592
    rVDD_244 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_243 (VDD_24 VDD_34) resistor r=67.52
    rVDD_242 (VDD_25 VDD_27) resistor r=0.511535
    rVDD_241 (VDD_25 VDD_101) resistor r=0.0882196
    rVDD_240 (VDD_27 VDD_28) resistor r=8.66667
    rVDD_239 (VDD_28 VDD_190) resistor r=16.4995
    rVDD_238 (VDD_28 VDD_189) resistor r=16.4995
    rVDD_237 (VDD_28 MM14_ELT_s) resistor r=3.29107
    rVDD_236 (VDD_30 VDD_39) resistor r=0.0336066
    rVDD_235 (VDD_30 VDD_102) resistor r=0.0221592
    rVDD_234 (VDD_31 VDD_33) resistor r=0.0336066
    rVDD_233 (VDD_31 VDD_101) resistor r=0.0221592
    rVDD_232 (VDD_33 VDD_34) resistor r=8.66667
    rVDD_231 (VDD_33 VDD_36) resistor r=0.237223
    rVDD_230 (VDD_34 VDD_37) resistor r=67.52
    rVDD_229 (VDD_36 VDD_37) resistor r=8.66667
    rVDD_228 (VDD_36 VDD_39) resistor r=0.237223
    rVDD_227 (VDD_37 VDD_40) resistor r=67.52
    rVDD_226 (VDD_39 VDD_40) resistor r=8.66667
    rVDD_225 (VDD_40 VDD_50) resistor r=67.52
    rVDD_224 (VDD_41 VDD_43) resistor r=0.565966
    rVDD_223 (VDD_41 VDD_102) resistor r=0.0882196
    rVDD_222 (VDD_43 VDD_44) resistor r=13
    rVDD_221 (VDD_44 MM9_ELT_s) resistor r=8.09035
    rVDD_220 (VDD_46 VDD_49) resistor r=0.168033
    rVDD_219 (VDD_46 VDD_103) resistor r=0.0221592
    rVDD_218 (VDD_47 VDD_49) resistor r=0.168033
    rVDD_217 (VDD_47 VDD_102) resistor r=0.0221592
    rVDD_216 (VDD_49 VDD_50) resistor r=8.66667
    rVDD_215 (VDD_51 VDD_53) resistor r=0.538211
    rVDD_214 (VDD_51 VDD_103) resistor r=0.0882196
    rVDD_213 (VDD_53 VDD_54) resistor r=8.66667
    rVDD_212 (VDD_54 MM6_ELT_s) resistor r=4.04518
    rVDD_211 (VDD_54 VDD_197) resistor r=4.04518
    rVDD_210 (VDD_54 MM8_ELT_s) resistor r=4.04518
    rVDD_209 (VDD_54 VDD_195) resistor r=4.04518
    rVDD_208 (VDD_56 VDD_59) resistor r=0.221409
    rVDD_207 (VDD_56 VDD_105) resistor r=0.0221592
    rVDD_206 (VDD_57 VDD_59) resistor r=0.0336066
    rVDD_205 (VDD_57 VDD_103) resistor r=0.0221592
    rVDD_204 (VDD_61 VDD_63) resistor r=0.511535
    rVDD_203 (VDD_61 VDD_105) resistor r=0.0882196
    rVDD_202 (VDD_63 VDD_64) resistor r=8.66667
    rVDD_201 (VDD_64 VDD_202) resistor r=16.4995
    rVDD_200 (VDD_64 VDD_201) resistor r=16.4995
    rVDD_199 (VDD_64 MM10_s) resistor r=3.29107
    rVDD_198 (VDD_66 VDD_72) resistor r=0.0869819
    rVDD_197 (VDD_66 VDD_107) resistor r=0.0221592
    rVDD_196 (VDD_67 VDD_69) resistor r=0.217455
    rVDD_195 (VDD_67 VDD_105) resistor r=0.0221592
    rVDD_194 (VDD_69 VDD_72) resistor r=0.237223
    rVDD_193 (VDD_74 VDD_76) resistor r=0.565966
    rVDD_192 (VDD_74 VDD_107) resistor r=0.0882196
    rVDD_191 (VDD_76 VDD_77) resistor r=13
    rVDD_190 (VDD_77 MM12_s) resistor r=8.09035
    rVDD_189 (VDD_79 VDD_82) resistor r=0.221409
    rVDD_188 (VDD_79 VDD_109) resistor r=0.0221592
    rVDD_187 (VDD_80 VDD_82) resistor r=0.114658
    rVDD_186 (VDD_80 VDD_107) resistor r=0.0221592
    rVDD_185 (VDD_84 VDD_93) resistor r=0.538211
    rVDD_184 (VDD_84 VDD_109) resistor r=0.0882196
    rVDD_183 (VDD_86 VDD_87) resistor r=8.66667
    rVDD_182 (VDD_86 VDD_90) resistor r=0.822703
    rVDD_181 (VDD_87 MM9_s) resistor r=2.31356
    rVDD_180 (VDD_87 VDD_229) resistor r=15.7867
    rVDD_179 (VDD_90 VDD_91) resistor r=8.66667
    rVDD_178 (VDD_90 VDD_93) resistor r=0.46801
    rVDD_177 (VDD_91 MM9_s) resistor r=3.65427
    rVDD_176 (VDD_91 VDD_231) resistor r=3.65427
    rVDD_175 (VDD_91 VDD_174) resistor r=4.45033
    rVDD_174 (VDD_91 VDD_229) resistor r=4.45033
    rVDD_173 (VDD_93 VDD_94) resistor r=13
    rVDD_172 (VDD_94 MM9_s) resistor r=4.04518
    rVDD_171 (VDD_94 VDD_203) resistor r=4.04518
    rVDD_170 (VDD_94 MM11_s) resistor r=4.04518
    rVDD_169 (VDD_94 VDD_231) resistor r=4.04518
    rVDD_168 (VDD_95 VDD_97) resistor r=0.13838
    rVDD_167 (VDD_95 VDD_109) resistor r=0.0221592
    rVDD_166 (MM28_ELT_s VDD_114) resistor r=25.7298
    rVDD_165 (MM28_ELT_s VDD_117) resistor r=2.55965
    rVDD_164 (MM28_ELT_s VDD_119) resistor r=12.3172
    rVDD_163 (MM28_ELT_s VDD_119) resistor r=1.62887
    rVDD_162 (VDD_114 VDD_116) resistor r=9.04062
    rVDD_161 (VDD_115 VDD_117) resistor r=14.4784
    rVDD_160 (VDD_115 VDD_188) resistor r=10.5593
    rVDD_159 (VDD_116 VDD_117) resistor r=14.4784
    rVDD_158 (VDD_118 VDD_119) resistor r=12.3172
    rVDD_157 (VDD_118 VDD_186) resistor r=10.2363
    rVDD_156 (MM1_ELT_s VDD_123) resistor r=2.55965
    rVDD_155 (MM1_ELT_s VDD_125) resistor r=12.3172
    rVDD_154 (MM1_ELT_s VDD_125) resistor r=1.62887
    rVDD_153 (MM1_ELT_s VDD_128) resistor r=6.12113
    rVDD_152 (MM1_ELT_s VDD_186) resistor r=10.2363
    rVDD_151 (VDD_121 VDD_123) resistor r=14.4784
    rVDD_150 (VDD_121 VDD_127) resistor r=9.04062
    rVDD_149 (VDD_122 VDD_123) resistor r=14.4784
    rVDD_148 (VDD_122 VDD_188) resistor r=10.5593
    rVDD_147 (VDD_124 VDD_125) resistor r=12.3172
    rVDD_146 (VDD_124 VDD_126) resistor r=9.04595
    rVDD_145 (VDD_126 VDD_128) resistor r=31.2341
    rVDD_144 (VDD_127 VDD_128) resistor r=31.2341
    rVDD_143 (MM14_ELT_s VDD_131) resistor r=12.3172
    rVDD_142 (MM14_ELT_s VDD_131) resistor r=1.62887
    rVDD_141 (MM14_ELT_s VDD_134) resistor r=2.55965
    rVDD_140 (MM14_ELT_s VDD_135) resistor r=17.3029
    rVDD_139 (VDD_130 VDD_131) resistor r=12.3172
    rVDD_138 (VDD_130 VDD_189) resistor r=9.39461
    rVDD_137 (VDD_132 VDD_134) resistor r=14.4784
    rVDD_136 (VDD_132 VDD_135) resistor r=9.04062
    rVDD_135 (VDD_133 VDD_134) resistor r=14.4784
    rVDD_134 (VDD_133 VDD_190) resistor r=9.48555
    rVDD_133 (VDD_136 VDD_139) resistor r=20.2547
    rVDD_132 (VDD_136 VDD_140) resistor r=9.04595
    rVDD_131 (VDD_137 VDD_139) resistor r=20.2547
    rVDD_130 (VDD_137 VDD_143) resistor r=9.04062
    rVDD_129 (MM8_ELT_s VDD_139) resistor r=4.36821
    rVDD_128 (MM8_ELT_s VDD_141) resistor r=7.31976
    rVDD_127 (MM8_ELT_s VDD_141) resistor r=1.40052
    rVDD_126 (MM8_ELT_s VDD_144) resistor r=2.55965
    rVDD_125 (MM8_ELT_s VDD_191) resistor r=0.294905
    rVDD_124 (MM8_ELT_s VDD_191) resistor r=8.76455
    rVDD_123 (VDD_140 VDD_141) resistor r=7.31976
    rVDD_122 (VDD_142 VDD_144) resistor r=14.4784
    rVDD_121 (VDD_142 VDD_198) resistor r=10.5593
    rVDD_120 (VDD_143 VDD_144) resistor r=14.4784
    rVDD_119 (VDD_145 VDD_191) resistor r=16.8549
    rVDD_118 (VDD_145 VDD_195) resistor r=5.39357
    rVDD_117 (MM6_ELT_s VDD_150) resistor r=2.55965
    rVDD_116 (MM6_ELT_s VDD_152) resistor r=7.31976
    rVDD_115 (MM6_ELT_s VDD_152) resistor r=1.40052
    rVDD_114 (MM6_ELT_s VDD_157) resistor r=20.2547
    rVDD_113 (MM6_ELT_s VDD_157) resistor r=4.36821
    rVDD_112 (MM6_ELT_s VDD_195) resistor r=13.4839
    rVDD_111 (MM6_ELT_s VDD_151) resistor r=8.54901
    rVDD_110 (VDD_148 VDD_150) resistor r=14.4784
    rVDD_109 (VDD_148 VDD_156) resistor r=9.04062
    rVDD_108 (VDD_149 VDD_150) resistor r=14.4784
    rVDD_107 (VDD_149 VDD_198) resistor r=10.5593
    rVDD_106 (VDD_151 VDD_152) resistor r=7.31976
    rVDD_105 (VDD_156 VDD_157) resistor r=20.2547
    rVDD_104 (MM10_s VDD_160) resistor r=12.3172
    rVDD_103 (MM10_s VDD_160) resistor r=1.62887
    rVDD_102 (MM10_s VDD_163) resistor r=2.55965
    rVDD_101 (MM10_s VDD_164) resistor r=17.3029
    rVDD_100 (VDD_159 VDD_160) resistor r=12.3172
    rVDD_99 (VDD_159 VDD_201) resistor r=9.39461
    rVDD_98 (VDD_161 VDD_163) resistor r=14.4784
    rVDD_97 (VDD_161 VDD_164) resistor r=9.04062
    rVDD_96 (VDD_162 VDD_163) resistor r=14.4784
    rVDD_95 (VDD_162 VDD_202) resistor r=9.48555
    rVDD_94 (VDD_165 VDD_168) resistor r=20.2547
    rVDD_93 (VDD_165 VDD_169) resistor r=9.04595
    rVDD_92 (VDD_166 VDD_168) resistor r=20.2547
    rVDD_91 (VDD_166 VDD_172) resistor r=9.04062
    rVDD_90 (MM11_s VDD_168) resistor r=4.36821
    rVDD_89 (MM11_s VDD_170) resistor r=7.31976
    rVDD_88 (MM11_s VDD_170) resistor r=1.40052
    rVDD_87 (MM11_s VDD_173) resistor r=2.55965
    rVDD_86 (MM11_s VDD_175) resistor r=7.31976
    rVDD_85 (MM11_s VDD_175) resistor r=1.40052
    rVDD_84 (VDD_169 VDD_170) resistor r=7.31976
    rVDD_83 (VDD_171 VDD_173) resistor r=14.4784
    rVDD_82 (VDD_171 VDD_204) resistor r=10.5593
    rVDD_81 (VDD_172 VDD_173) resistor r=14.4784
    rVDD_80 (VDD_174 VDD_175) resistor r=7.31976
    rVDD_79 (MM9_s VDD_179) resistor r=2.55965
    rVDD_78 (MM9_s VDD_181) resistor r=11.6604
    rVDD_77 (MM9_s VDD_181) resistor r=1.30988
    rVDD_76 (MM9_s VDD_184) resistor r=6.12113
    rVDD_75 (VDD_177 VDD_179) resistor r=14.4784
    rVDD_74 (VDD_177 VDD_183) resistor r=9.04062
    rVDD_73 (VDD_178 VDD_179) resistor r=14.4784
    rVDD_72 (VDD_178 VDD_204) resistor r=10.5593
    rVDD_71 (VDD_180 VDD_181) resistor r=11.6604
    rVDD_70 (VDD_180 VDD_182) resistor r=9.04595
    rVDD_69 (VDD_182 VDD_184) resistor r=31.2341
    rVDD_68 (VDD_183 VDD_184) resistor r=31.2341
    rVDD_67 (VDD_185 VDD_186) resistor r=0.549089
    rVDD_66 (VDD_187 VDD_188) resistor r=0.730683
    rVDD_65 (VDD_197 VDD_198) resistor r=0.730683
    rVDD_64 (VDD_203 VDD_204) resistor r=0.730683
    rVSS_234 (MM0_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_233 (MM16_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_232 (MM17_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_231 (MM11_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_230 (MM18_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_229 (MM12_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_228 (MM13_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_227 (MM7_ELT_b MM29_ELT_b) resistor r=0.01
    rVSS_226 (MM5_b MM29_ELT_b) resistor r=0.01
    rVSS_225 (MM3_b MM29_ELT_b) resistor r=0.01
    rVSS_224 (MM6_b MM29_ELT_b) resistor r=0.01
    rVSS_223 (MM0_b MM29_ELT_b) resistor r=0.01
    rVSS_222 (MM4_b MM29_ELT_b) resistor r=0.01
    rVSS_221 (MM1_b MM29_ELT_b) resistor r=0.01
    rVSS_220 (MM2_b MM29_ELT_b) resistor r=0.01
    rVSS_219 (MM29_ELT_b VSS_49) resistor r=8.66667
    rVSS_218 (MM29_ELT_b VSS_52) resistor r=8.66667
    rVSS_217 (MM29_ELT_b VSS_55) resistor r=8.66667
    rVSS_216 (MM29_ELT_b VSS_58) resistor r=8.66667
    rVSS_215 (MM29_ELT_b VSS_68) resistor r=8.66667
    rVSS_214 (MM29_ELT_b VSS_80) resistor r=13
    rVSS_213 (MM29_ELT_b VSS_88) resistor r=8.66667
    rVSS_212 (MM29_ELT_b VSS_37) resistor r=53.9357
    rVSS_211 (VSS_2 VSS_7) resistor r=0.114658
    rVSS_210 (VSS_2 VSS_83) resistor r=0.0221592
    rVSS_209 (VSS VSS_7) resistor r=0.10082
    rVSS_208 (VSS_7 VSS_8) resistor r=8.66667
    rVSS_207 (VSS_8 VSS_18) resistor r=64.7228
    rVSS_206 (VSS_9 VSS_11) resistor r=0.438759
    rVSS_205 (VSS_9 VSS_83) resistor r=0.0882196
    rVSS_204 (VSS_11 VSS_12) resistor r=8.66667
    rVSS_203 (VSS_12 MM0_ELT_s) resistor r=4.22001
    rVSS_202 (VSS_12 VSS_162) resistor r=4.22001
    rVSS_201 (VSS_12 MM29_ELT_s) resistor r=4.22001
    rVSS_200 (VSS_12 VSS_160) resistor r=4.22001
    rVSS_199 (VSS_14 VSS_26) resistor r=0.114658
    rVSS_198 (VSS_14 VSS_84) resistor r=0.0221592
    rVSS_197 (VSS_15 VSS_17) resistor r=0.0871072
    rVSS_196 (VSS_15 VSS_83) resistor r=0.0221592
    rVSS_195 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_194 (VSS_17 VSS_20) resistor r=0.237565
    rVSS_193 (VSS_18 VSS_21) resistor r=64.7228
    rVSS_192 (VSS_20 VSS_21) resistor r=8.66667
    rVSS_191 (VSS_20 VSS_23) resistor r=0.237565
    rVSS_190 (VSS_21 VSS_24) resistor r=64.7228
    rVSS_189 (VSS_23 VSS_24) resistor r=8.66667
    rVSS_188 (VSS_23 VSS_26) resistor r=0.237223
    rVSS_187 (VSS_24 VSS_27) resistor r=64.7228
    rVSS_186 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_185 (VSS_27 VSS_37) resistor r=64.7228
    rVSS_184 (VSS_28 VSS_30) resistor r=0.438759
    rVSS_183 (VSS_28 VSS_84) resistor r=0.0882196
    rVSS_182 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_181 (VSS_31 MM13_ELT_s) resistor r=2.27123
    rVSS_180 (VSS_31 MM18_ELT_s) resistor r=2.27123
    rVSS_179 (VSS_31 VSS_164) resistor r=8.4738
    rVSS_178 (VSS_33 VSS_36) resistor r=0.168033
    rVSS_177 (VSS_33 VSS_85) resistor r=0.0221592
    rVSS_176 (VSS_34 VSS_36) resistor r=0.0869819
    rVSS_175 (VSS_34 VSS_84) resistor r=0.0221592
    rVSS_174 (VSS_36 VSS_37) resistor r=8.66667
    rVSS_173 (VSS_38 VSS_40) resistor r=0.399637
    rVSS_172 (VSS_38 VSS_85) resistor r=0.0882196
    rVSS_171 (VSS_40 VSS_44) resistor r=8.66667
    rVSS_170 (VSS_40 VSS_43) resistor r=0.426279
    rVSS_169 (VSS_43 VSS_44) resistor r=26
    rVSS_168 (VSS_44 MM7_ELT_s) resistor r=2.90692
    rVSS_167 (VSS_44 VSS_166) resistor r=12.1406
    rVSS_166 (VSS_46 VSS_58) resistor r=0.168033
    rVSS_165 (VSS_46 VSS_86) resistor r=0.0221592
    rVSS_164 (VSS_47 VSS_49) resistor r=0.0336066
    rVSS_163 (VSS_47 VSS_85) resistor r=0.0221592
    rVSS_162 (VSS_49 VSS_52) resistor r=0.237223
    rVSS_161 (VSS_52 VSS_55) resistor r=0.237223
    rVSS_160 (VSS_55 VSS_58) resistor r=0.237223
    rVSS_159 (VSS_60 VSS_62) resistor r=0.438759
    rVSS_158 (VSS_60 VSS_86) resistor r=0.0882196
    rVSS_157 (VSS_62 VSS_63) resistor r=8.66667
    rVSS_156 (VSS_63 MM1_s) resistor r=2.27123
    rVSS_155 (VSS_63 MM0_s) resistor r=2.27123
    rVSS_154 (VSS_63 VSS_167) resistor r=8.4738
    rVSS_153 (VSS_65 VSS_68) resistor r=0.221409
    rVSS_152 (VSS_65 VSS_88) resistor r=0.0221592
    rVSS_151 (VSS_66 VSS_68) resistor r=0.0336066
    rVSS_150 (VSS_66 VSS_86) resistor r=0.0221592
    rVSS_149 (VSS_70 VSS_72) resistor r=0.399637
    rVSS_148 (VSS_70 VSS_88) resistor r=0.0882196
    rVSS_147 (VSS_72 VSS_76) resistor r=8.66667
    rVSS_146 (VSS_72 VSS_75) resistor r=0.426279
    rVSS_145 (VSS_75 VSS_76) resistor r=26
    rVSS_144 (VSS_76 MM2_s) resistor r=2.90692
    rVSS_143 (VSS_76 VSS_169) resistor r=12.1406
    rVSS_142 (VSS_78 VSS_80) resistor r=0.13838
    rVSS_141 (VSS_78 VSS_88) resistor r=0.0221592
    rVSS_140 (MM29_ELT_s VSS_91) resistor r=18.0507
    rVSS_139 (MM29_ELT_s VSS_94) resistor r=2.67027
    rVSS_138 (MM29_ELT_s VSS_96) resistor r=12.8495
    rVSS_137 (MM29_ELT_s VSS_96) resistor r=1.69926
    rVSS_136 (VSS_91 VSS_93) resistor r=9.43134
    rVSS_135 (VSS_92 VSS_94) resistor r=15.1041
    rVSS_134 (VSS_92 VSS_161) resistor r=11.0157
    rVSS_133 (VSS_93 VSS_94) resistor r=15.1041
    rVSS_132 (VSS_95 VSS_96) resistor r=12.8495
    rVSS_131 (VSS_95 VSS_163) resistor r=10.6787
    rVSS_130 (MM0_ELT_s VSS_100) resistor r=2.67027
    rVSS_129 (MM0_ELT_s VSS_102) resistor r=12.8495
    rVSS_128 (MM0_ELT_s VSS_102) resistor r=1.69926
    rVSS_127 (MM0_ELT_s VSS_105) resistor r=4.557
    rVSS_126 (MM0_ELT_s VSS_163) resistor r=10.6787
    rVSS_125 (VSS_98 VSS_100) resistor r=15.1041
    rVSS_124 (VSS_98 VSS_103) resistor r=9.43134
    rVSS_123 (VSS_99 VSS_100) resistor r=15.1041
    rVSS_122 (VSS_99 VSS_161) resistor r=11.0157
    rVSS_121 (VSS_101 VSS_102) resistor r=12.8495
    rVSS_120 (VSS_101 VSS_104) resistor r=9.4369
    rVSS_119 (VSS_103 VSS_105) resistor r=21.1301
    rVSS_118 (VSS_104 VSS_105) resistor r=21.1301
    rVSS_117 (VSS_106 VSS_109) resistor r=21.1301
    rVSS_116 (VSS_106 VSS_111) resistor r=9.43134
    rVSS_115 (VSS_107 VSS_109) resistor r=21.1301
    rVSS_114 (VSS_107 VSS_113) resistor r=9.4369
    rVSS_113 (MM18_ELT_s VSS_109) resistor r=4.557
    rVSS_112 (MM18_ELT_s VSS_112) resistor r=2.67027
    rVSS_111 (MM18_ELT_s VSS_114) resistor r=12.8495
    rVSS_110 (MM18_ELT_s VSS_114) resistor r=1.69926
    rVSS_109 (VSS_110 VSS_112) resistor r=15.1041
    rVSS_108 (VSS_110 VSS_165) resistor r=11.0157
    rVSS_107 (VSS_111 VSS_112) resistor r=15.1041
    rVSS_106 (VSS_113 VSS_114) resistor r=12.8495
    rVSS_105 (MM13_ELT_s VSS_118) resistor r=2.67027
    rVSS_104 (MM13_ELT_s VSS_120) resistor r=12.8495
    rVSS_103 (MM13_ELT_s VSS_120) resistor r=1.69926
    rVSS_102 (MM13_ELT_s VSS_123) resistor r=4.557
    rVSS_101 (VSS_116 VSS_118) resistor r=15.1041
    rVSS_100 (VSS_116 VSS_121) resistor r=9.43134
    rVSS_99 (VSS_117 VSS_118) resistor r=15.1041
    rVSS_98 (VSS_117 VSS_165) resistor r=11.0157
    rVSS_97 (VSS_119 VSS_120) resistor r=12.8495
    rVSS_96 (VSS_119 VSS_122) resistor r=9.4369
    rVSS_95 (VSS_121 VSS_123) resistor r=21.1301
    rVSS_94 (VSS_122 VSS_123) resistor r=21.1301
    rVSS_93 (MM7_ELT_s VSS_127) resistor r=2.67027
    rVSS_92 (MM7_ELT_s VSS_129) resistor r=12.1643
    rVSS_91 (MM7_ELT_s VSS_129) resistor r=1.36649
    rVSS_90 (MM7_ELT_s VSS_132) resistor r=4.557
    rVSS_89 (VSS_125 VSS_127) resistor r=15.1041
    rVSS_88 (VSS_125 VSS_130) resistor r=9.43134
    rVSS_87 (VSS_126 VSS_127) resistor r=15.1041
    rVSS_86 (VSS_126 VSS_166) resistor r=9.89549
    rVSS_85 (VSS_128 VSS_129) resistor r=12.1643
    rVSS_84 (VSS_128 VSS_131) resistor r=9.4369
    rVSS_83 (VSS_130 VSS_132) resistor r=21.1301
    rVSS_82 (VSS_131 VSS_132) resistor r=21.1301
    rVSS_81 (VSS_133 VSS_136) resistor r=21.1301
    rVSS_80 (VSS_133 VSS_138) resistor r=9.43134
    rVSS_79 (VSS_134 VSS_136) resistor r=21.1301
    rVSS_78 (VSS_134 VSS_140) resistor r=9.4369
    rVSS_77 (MM0_s VSS_136) resistor r=4.557
    rVSS_76 (MM0_s VSS_139) resistor r=2.67027
    rVSS_75 (MM0_s VSS_141) resistor r=12.8495
    rVSS_74 (MM0_s VSS_141) resistor r=1.69926
    rVSS_73 (VSS_137 VSS_139) resistor r=15.1041
    rVSS_72 (VSS_137 VSS_168) resistor r=11.0157
    rVSS_71 (VSS_138 VSS_139) resistor r=15.1041
    rVSS_70 (VSS_140 VSS_141) resistor r=12.8495
    rVSS_69 (MM1_s VSS_145) resistor r=2.67027
    rVSS_68 (MM1_s VSS_147) resistor r=12.8495
    rVSS_67 (MM1_s VSS_147) resistor r=1.69926
    rVSS_66 (MM1_s VSS_150) resistor r=4.557
    rVSS_65 (VSS_143 VSS_145) resistor r=15.1041
    rVSS_64 (VSS_143 VSS_148) resistor r=9.43134
    rVSS_63 (VSS_144 VSS_145) resistor r=15.1041
    rVSS_62 (VSS_144 VSS_168) resistor r=11.0157
    rVSS_61 (VSS_146 VSS_147) resistor r=12.8495
    rVSS_60 (VSS_146 VSS_149) resistor r=9.4369
    rVSS_59 (VSS_148 VSS_150) resistor r=21.1301
    rVSS_58 (VSS_149 VSS_150) resistor r=21.1301
    rVSS_57 (MM2_s VSS_154) resistor r=2.67027
    rVSS_56 (MM2_s VSS_156) resistor r=12.1643
    rVSS_55 (MM2_s VSS_156) resistor r=1.36649
    rVSS_54 (MM2_s VSS_159) resistor r=4.557
    rVSS_53 (VSS_152 VSS_154) resistor r=15.1041
    rVSS_52 (VSS_152 VSS_157) resistor r=9.43134
    rVSS_51 (VSS_153 VSS_154) resistor r=15.1041
    rVSS_50 (VSS_153 VSS_169) resistor r=9.89549
    rVSS_49 (VSS_155 VSS_156) resistor r=12.1643
    rVSS_48 (VSS_155 VSS_158) resistor r=9.4369
    rVSS_47 (VSS_157 VSS_159) resistor r=21.1301
    rVSS_46 (VSS_158 VSS_159) resistor r=21.1301
    rVSS_45 (VSS_160 VSS_161) resistor r=0.762262
    rVSS_44 (VSS_162 VSS_163) resistor r=0.57282
    rVSS_43 (VSS_164 VSS_165) resistor r=0.762262
    rVSS_42 (VSS_167 VSS_168) resistor r=0.762262
    rnet68_189 (MM11_d net68) resistor r=0.01
    rnet68_188 (net68_22 net68_28) resistor r=58.3583
    rnet68_187 (net68_22 net68_28) resistor r=4.16253
    rnet68_186 (net68_22 net68_28) resistor r=58.3583
    rnet68_185 (net68_22 net68_28) resistor r=4.16253
    rnet68_184 (net68_25 net68_28) resistor r=58.3583
    rnet68_183 (net68_25 net68_28) resistor r=5.53947
    rnet68_182 (net68_25 net68_28) resistor r=58.3583
    rnet68_181 (net68_25 net68_28) resistor r=5.53947
    rnet68_180 (net68_28 net68_30) resistor r=11.175
    rnet68_179 (net68_28 net68_53) resistor r=24.8333
    rnet68_178 (net68_28 net68_50) resistor r=24.8333
    rnet68_177 (net68_28 net68_69) resistor r=22.35
    rnet68_176 (net68_28 net68_66) resistor r=22.35
    rnet68_175 (net68_28 net68_82) resistor r=58.3583
    rnet68_174 (net68_28 net68_85) resistor r=58.3583
    rnet68_173 (net68_28 net68_53) resistor r=4.16253
    rnet68_172 (net68_28 net68_30) resistor r=5.53947
    rnet68_171 (net68_28 net68_69) resistor r=2.32428
    rnet68_170 (net68_28 net68_50) resistor r=4.16253
    rnet68_169 (net68_28 net68_82) resistor r=4.16253
    rnet68_168 (net68_28 net68_66) resistor r=4.16253
    rnet68_167 (net68_28 net68_85) resistor r=4.16253
    rnet68_166 (net68_28 net68_30) resistor r=11.175
    rnet68_165 (net68_28 net68_211) resistor r=29.8
    rnet68_164 (net68_28 net68_53) resistor r=24.8333
    rnet68_163 (net68_28 net68_50) resistor r=24.8333
    rnet68_162 (net68_28 net68_69) resistor r=22.35
    rnet68_161 (net68_28 net68_66) resistor r=22.35
    rnet68_160 (net68_28 net68_82) resistor r=58.3583
    rnet68_159 (net68_28 MM2_g) resistor r=7.45
    rnet68_158 (net68_28 net68_53) resistor r=4.16253
    rnet68_157 (net68_28 net68_30) resistor r=5.53947
    rnet68_156 (net68_28 net68_69) resistor r=2.32428
    rnet68_155 (net68_28 net68_50) resistor r=4.16253
    rnet68_154 (net68_28 net68_82) resistor r=4.16253
    rnet68_153 (net68_28 net68_66) resistor r=4.16253
    rnet68_152 (net68_28 net68_85) resistor r=4.16253
    rnet68_151 (net68_36 net68_39) resistor r=11.175
    rnet68_150 (net68_36 net68_39) resistor r=5.53947
    rnet68_149 (net68_36 net68_39) resistor r=11.175
    rnet68_148 (net68_36 net68_39) resistor r=5.53947
    rnet68_147 (net68_39 net68_42) resistor r=202.392
    rnet68_146 (net68_39 net68_45) resistor r=202.392
    rnet68_145 (net68_39 net68_61) resistor r=24.8333
    rnet68_144 (net68_39 net68_58) resistor r=24.8333
    rnet68_143 (net68_39 net68_77) resistor r=22.35
    rnet68_142 (net68_39 net68_74) resistor r=22.35
    rnet68_141 (net68_39 net68_90) resistor r=202.392
    rnet68_140 (net68_39 net68_93) resistor r=202.392
    rnet68_139 (net68_39 net68_42) resistor r=5.53947
    rnet68_138 (net68_39 net68_77) resistor r=2.32428
    rnet68_137 (net68_39 net68_61) resistor r=4.16253
    rnet68_136 (net68_39 net68_45) resistor r=4.16253
    rnet68_135 (net68_39 net68_74) resistor r=4.16253
    rnet68_134 (net68_39 net68_90) resistor r=4.16253
    rnet68_133 (net68_39 net68_58) resistor r=4.16253
    rnet68_132 (net68_39 net68_93) resistor r=4.16253
    rnet68_131 (net68_39 net68_213) resistor r=31.6625
    rnet68_130 (net68_39 net68_42) resistor r=202.392
    rnet68_129 (net68_39 net68_45) resistor r=202.392
    rnet68_128 (net68_39 net68_61) resistor r=24.8333
    rnet68_127 (net68_39 net68_58) resistor r=24.8333
    rnet68_126 (net68_39 net68_77) resistor r=22.35
    rnet68_125 (net68_39 net68_74) resistor r=22.35
    rnet68_124 (net68_39 net68_90) resistor r=202.392
    rnet68_123 (net68_39 MM9_g) resistor r=7.45
    rnet68_122 (net68_39 net68_42) resistor r=5.53947
    rnet68_121 (net68_39 net68_77) resistor r=2.32428
    rnet68_120 (net68_39 net68_61) resistor r=4.16253
    rnet68_119 (net68_39 net68_45) resistor r=4.16253
    rnet68_118 (net68_39 net68_74) resistor r=4.16253
    rnet68_117 (net68_39 net68_90) resistor r=4.16253
    rnet68_116 (net68_39 net68_58) resistor r=4.16253
    rnet68_115 (net68_39 net68_93) resistor r=4.16253
    rnet68_114 (net68_85 MM2_g) resistor r=50.9083
    rnet68_113 (net68_93 MM9_g) resistor r=194.942
    rnet68_112 (net68_131 net68_133) resistor r=0.402078
    rnet68_111 (net68_131 net68_137) resistor r=0.0963523
    rnet68_110 (net68_133 net68_134) resistor r=8.66667
    rnet68_109 (net68_134 MM7_d) resistor r=2.78649
    rnet68_108 (net68_134 net68_260) resistor r=11.6377
    rnet68_107 (net68_136 net68_137) resistor r=0.922362
    rnet68_106 (net68_136 net68_183) resistor r=0.0135764
    rnet68_105 (net68_138 net68_140) resistor r=0.365926
    rnet68_104 (net68_138 net68_144) resistor r=0.096078
    rnet68_103 (net68_140 net68_141) resistor r=13
    rnet68_102 (net68_141 MM5_d) resistor r=8.44
    rnet68_101 (net68_143 net68_144) resistor r=0.504174
    rnet68_100 (net68_143 net68_145) resistor r=0.096078
    rnet68_99 (net68_145 net68_146) resistor r=0.687833
    rnet68_98 (net68_146 net68_183) resistor r=0.0794152
    rnet68_97 (net68_147 net68_148) resistor r=0.59524
    rnet68_96 (net68_147 net68_183) resistor r=0.0794152
    rnet68_95 (net68_148 net68_150) resistor r=0.096078
    rnet68_94 (net68_149 net68_150) resistor r=0.389671
    rnet68_93 (net68_149 net68_184) resistor r=0.0728149
    rnet68_92 (net68_151 net68_153) resistor r=0.209798
    rnet68_91 (net68_151 net68_157) resistor r=0.096078
    rnet68_90 (net68_153 net68_154) resistor r=13
    rnet68_89 (net68_154 MM8_d) resistor r=8.09035
    rnet68_88 (net68_156 net68_157) resistor r=0.385547
    rnet68_87 (net68_156 net68_186) resistor r=0.0728149
    rnet68_86 (net68_158 net68_160) resistor r=0.414716
    rnet68_85 (net68_158 net68_184) resistor r=0.0189233
    rnet68_84 (net68_160 net68_161) resistor r=13
    rnet68_83 (net68_161 MM6_d) resistor r=8.44
    rnet68_82 (net68_163 net68_164) resistor r=0.167002
    rnet68_81 (net68_163 net68_185) resistor r=0.0728149
    rnet68_80 (net68_164 net68_184) resistor r=0.0728149
    rnet68_79 (net68_165 net68_166) resistor r=0.617286
    rnet68_78 (net68_165 net68_185) resistor r=0.0189233
    rnet68_77 (net68_166 net68_186) resistor r=0.0189233
    rnet68_76 (net68_167 net68_168) resistor r=0.857372
    rnet68_75 (net68_167 net68_172) resistor r=0.096078
    rnet68_74 (net68_168 net68_185) resistor r=0.0728149
    rnet68_73 (net68_169 net68_170) resistor r=0.980142
    rnet68_72 (net68_169 net68_178) resistor r=0.096078
    rnet68_71 (net68_170 net68_186) resistor r=0.0728149
    rnet68_70 (net68_171 net68_172) resistor r=1.41843
    rnet68_69 (net68_171 net68_173) resistor r=0.101343
    rnet68_68 (net68_173 net68_175) resistor r=0.335142
    rnet68_67 (net68_175 net68_176) resistor r=10
    rnet68_66 (net68_176 net68_243) resistor r=12.8682
    rnet68_65 (net68_178 net68_180) resistor r=0.229125
    rnet68_64 (net68_180 net68_181) resistor r=13
    rnet68_63 (net68_181 net68) resistor r=8.09035
    rnet68_62 (net68_211 net68_244) resistor r=8.1518
    rnet68_61 (net68_213 net68_244) resistor r=8.1518
    rnet68_60 (net68_243 net68_244) resistor r=0.275023
    rnet68_59 (MM7_d net68_254) resistor r=2.55965
    rnet68_58 (MM7_d net68_256) resistor r=12.3172
    rnet68_57 (MM7_d net68_256) resistor r=1.62887
    rnet68_56 (MM7_d net68_259) resistor r=4.36821
    rnet68_55 (net68_252 net68_254) resistor r=14.4784
    rnet68_54 (net68_252 net68_257) resistor r=9.04062
    rnet68_53 (net68_253 net68_254) resistor r=14.4784
    rnet68_52 (net68_253 net68_260) resistor r=9.48555
    rnet68_51 (net68_255 net68_256) resistor r=12.3172
    rnet68_50 (net68_255 net68_258) resistor r=9.04595
    rnet68_49 (net68_257 net68_259) resistor r=20.2547
    rnet68_48 (net68_258 net68_259) resistor r=20.2547
    rnet255_21 (MM1_d net255) resistor r=0.01
    rnet255_20 (net255_1 net255_3) resistor r=0.170766
    rnet255_19 (net255_1 net255_7) resistor r=0.096078
    rnet255_18 (net255_3 net255_4) resistor r=13
    rnet255_17 (net255_4 MM4_s) resistor r=8.44
    rnet255_16 (net255_6 net255_7) resistor r=0.0927013
    rnet255_15 (net255_6 net255_9) resistor r=0.096078
    rnet255_14 (net255_8 net255_9) resistor r=0.687578
    rnet255_13 (net255_8 net255_15) resistor r=0.0100989
    rnet255_12 (net255_10 net255_12) resistor r=0.399637
    rnet255_11 (net255_10 net255_17) resistor r=0.0100989
    rnet255_10 (net255_12 net255_13) resistor r=13
    rnet255_9 (net255_13 net255) resistor r=8.44
    rnet255_8 (net255_15 net255_17) resistor r=0.0878223
    rnet200_18 (MM0_d net200) resistor r=0.01
    rnet200_17 (net200_1 net200_3) resistor r=0.0536692
    rnet200_16 (net200_1 net200_17) resistor r=0.0728149
    rnet200_15 (net200_3 net200_4) resistor r=13
    rnet200_14 (net200_4 MM3_s) resistor r=8.44
    rnet200_13 (net200_8 net200_9) resistor r=0.575724
    rnet200_12 (net200_8 net200_18) resistor r=0.0189233
    rnet200_11 (net200_9 net200_17) resistor r=0.0189233
    rnet200_10 (net200_10 net200_12) resistor r=0.0586134
    rnet200_9 (net200_10 net200_18) resistor r=0.0728149
    rnet200_8 (net200_12 net200_13) resistor r=13
    rnet200_7 (net200_13 net200) resistor r=8.44
    rnet499_20 (MM10_d net499) resistor r=0.01
    rnet499_19 (net499_1 net499_3) resistor r=0.426279
    rnet499_18 (net499_1 net499_13) resistor r=0.0100989
    rnet499_17 (net499_3 net499_4) resistor r=13
    rnet499_16 (net499_4 MM7_s) resistor r=8.09035
    rnet499_15 (net499_6 net499_8) resistor r=0.266425
    rnet499_14 (net499_6 net499_17) resistor r=0.0100989
    rnet499_13 (net499_8 net499_9) resistor r=13
    rnet499_12 (net499_9 net499) resistor r=8.09035
    rnet499_11 (net499_11 net499_12) resistor r=0.427591
    rnet499_10 (net499_11 net499_15) resistor r=0.0100989
    rnet499_9 (net499_12 net499_19) resistor r=0.0100989
    rnet499_8 (net499_13 net499_15) resistor r=0.0927013
    rnet499_7 (net499_17 net499_19) resistor r=0.0927013
    rnet5_240 (MM6_ELT_d net5) resistor r=0.01
    rnet5_239 (net5_42 net5_48) resistor r=58.3583
    rnet5_238 (net5_42 net5_48) resistor r=4.16253
    rnet5_237 (net5_42 net5_48) resistor r=58.3583
    rnet5_236 (net5_42 net5_48) resistor r=4.16253
    rnet5_235 (net5_45 net5_48) resistor r=58.3583
    rnet5_234 (net5_45 net5_48) resistor r=4.16253
    rnet5_233 (net5_45 net5_48) resistor r=58.3583
    rnet5_232 (net5_45 net5_48) resistor r=4.16253
    rnet5_231 (net5_48 net5_53) resistor r=22.35
    rnet5_230 (net5_48 net5_50) resistor r=22.35
    rnet5_229 (net5_48 net5_61) resistor r=24.8333
    rnet5_228 (net5_48 net5_58) resistor r=24.8333
    rnet5_227 (net5_48 net5_74) resistor r=11.175
    rnet5_226 (net5_48 net5_96) resistor r=58.3583
    rnet5_225 (net5_48 net5_99) resistor r=58.3583
    rnet5_224 (net5_48 net5_53) resistor r=4.16253
    rnet5_223 (net5_48 net5_61) resistor r=4.16253
    rnet5_222 (net5_48 net5_96) resistor r=5.53947
    rnet5_221 (net5_48 net5_74) resistor r=5.53947
    rnet5_220 (net5_48 net5_50) resistor r=2.32428
    rnet5_219 (net5_48 net5_58) resistor r=4.16253
    rnet5_218 (net5_48 net5_99) resistor r=4.16253
    rnet5_217 (net5_48 net5_53) resistor r=22.35
    rnet5_216 (net5_48 net5_50) resistor r=22.35
    rnet5_215 (net5_48 net5_61) resistor r=24.8333
    rnet5_214 (net5_48 net5_58) resistor r=24.8333
    rnet5_213 (net5_48 net5_351) resistor r=35.3875
    rnet5_212 (net5_48 net5_74) resistor r=11.175
    rnet5_211 (net5_48 net5_96) resistor r=58.3583
    rnet5_210 (net5_48 MM9_ELT_g) resistor r=7.45
    rnet5_209 (net5_48 net5_53) resistor r=4.16253
    rnet5_208 (net5_48 net5_61) resistor r=4.16253
    rnet5_207 (net5_48 net5_96) resistor r=5.53947
    rnet5_206 (net5_48 net5_74) resistor r=5.53947
    rnet5_205 (net5_48 net5_50) resistor r=2.32428
    rnet5_204 (net5_48 net5_58) resistor r=4.16253
    rnet5_203 (net5_48 net5_99) resistor r=4.16253
    rnet5_202 (net5_66 net5_72) resistor r=58.3583
    rnet5_201 (net5_66 net5_72) resistor r=4.16253
    rnet5_200 (net5_66 net5_72) resistor r=58.3583
    rnet5_199 (net5_66 net5_72) resistor r=4.16253
    rnet5_198 (net5_69 net5_72) resistor r=58.3583
    rnet5_197 (net5_69 net5_72) resistor r=4.16253
    rnet5_196 (net5_69 net5_72) resistor r=58.3583
    rnet5_195 (net5_69 net5_72) resistor r=4.16253
    rnet5_194 (net5_72 net5_83) resistor r=24.8333
    rnet5_193 (net5_72 net5_80) resistor r=24.8333
    rnet5_192 (net5_72 net5_91) resistor r=22.35
    rnet5_191 (net5_72 net5_88) resistor r=22.35
    rnet5_190 (net5_72 net5_104) resistor r=11.175
    rnet5_189 (net5_72 net5_110) resistor r=58.3583
    rnet5_188 (net5_72 net5_113) resistor r=58.3583
    rnet5_187 (net5_72 net5_83) resistor r=4.16253
    rnet5_186 (net5_72 net5_91) resistor r=4.16253
    rnet5_185 (net5_72 net5_104) resistor r=5.53947
    rnet5_184 (net5_72 net5_113) resistor r=5.53947
    rnet5_183 (net5_72 net5_88) resistor r=2.32428
    rnet5_182 (net5_72 net5_80) resistor r=4.16253
    rnet5_181 (net5_72 net5_110) resistor r=4.16253
    rnet5_180 (net5_72 net5_83) resistor r=24.8333
    rnet5_179 (net5_72 net5_80) resistor r=24.8333
    rnet5_178 (net5_72 net5_91) resistor r=22.35
    rnet5_177 (net5_72 net5_88) resistor r=22.35
    rnet5_176 (net5_72 net5_104) resistor r=11.175
    rnet5_175 (net5_72 net5_366) resistor r=30.7313
    rnet5_174 (net5_72 net5_110) resistor r=58.3583
    rnet5_173 (net5_72 MM12_ELT_g) resistor r=22.35
    rnet5_172 (net5_72 net5_83) resistor r=4.16253
    rnet5_171 (net5_72 net5_91) resistor r=4.16253
    rnet5_170 (net5_72 net5_104) resistor r=5.53947
    rnet5_169 (net5_72 net5_113) resistor r=5.53947
    rnet5_168 (net5_72 net5_88) resistor r=2.32428
    rnet5_167 (net5_72 net5_80) resistor r=4.16253
    rnet5_166 (net5_72 net5_110) resistor r=4.16253
    rnet5_165 (net5_99 MM9_ELT_g) resistor r=50.9083
    rnet5_164 (net5_113 MM12_ELT_g) resistor r=36.0083
    rnet5_163 (net5_118 net5_124) resistor r=58.3583
    rnet5_162 (net5_118 net5_124) resistor r=4.16253
    rnet5_161 (net5_118 net5_124) resistor r=58.3583
    rnet5_160 (net5_118 net5_124) resistor r=4.16253
    rnet5_159 (net5_121 net5_124) resistor r=58.3583
    rnet5_158 (net5_121 net5_124) resistor r=4.16253
    rnet5_157 (net5_121 net5_124) resistor r=58.3583
    rnet5_156 (net5_121 net5_124) resistor r=4.16253
    rnet5_155 (net5_124 net5_129) resistor r=24.8333
    rnet5_154 (net5_124 net5_126) resistor r=24.8333
    rnet5_153 (net5_124 net5_137) resistor r=24.8333
    rnet5_152 (net5_124 net5_134) resistor r=24.8333
    rnet5_151 (net5_124 net5_142) resistor r=14.9
    rnet5_150 (net5_124 net5_148) resistor r=58.3583
    rnet5_149 (net5_124 net5_151) resistor r=58.3583
    rnet5_148 (net5_124 net5_129) resistor r=4.16253
    rnet5_147 (net5_124 net5_137) resistor r=4.16253
    rnet5_146 (net5_124 net5_148) resistor r=6.30933
    rnet5_145 (net5_124 net5_142) resistor r=6.30933
    rnet5_144 (net5_124 net5_126) resistor r=1.63969
    rnet5_143 (net5_124 net5_134) resistor r=4.16253
    rnet5_142 (net5_124 net5_151) resistor r=4.16253
    rnet5_141 (net5_124 net5_129) resistor r=24.8333
    rnet5_140 (net5_124 net5_126) resistor r=24.8333
    rnet5_139 (net5_124 net5_137) resistor r=24.8333
    rnet5_138 (net5_124 net5_134) resistor r=24.8333
    rnet5_137 (net5_124 net5_382) resistor r=47.1833
    rnet5_136 (net5_124 net5_142) resistor r=14.9
    rnet5_135 (net5_124 net5_148) resistor r=58.3583
    rnet5_134 (net5_124 MM10_g) resistor r=7.45
    rnet5_133 (net5_124 net5_129) resistor r=4.16253
    rnet5_132 (net5_124 net5_137) resistor r=4.16253
    rnet5_131 (net5_124 net5_148) resistor r=6.30933
    rnet5_130 (net5_124 net5_142) resistor r=6.30933
    rnet5_129 (net5_124 net5_126) resistor r=1.63969
    rnet5_128 (net5_124 net5_134) resistor r=4.16253
    rnet5_127 (net5_124 net5_151) resistor r=4.16253
    rnet5_126 (net5_151 MM10_g) resistor r=50.9083
    rnet5_125 (net5_156 net5_162) resistor r=58.3583
    rnet5_124 (net5_156 net5_162) resistor r=4.16253
    rnet5_123 (net5_156 net5_162) resistor r=58.3583
    rnet5_122 (net5_156 net5_162) resistor r=4.16253
    rnet5_121 (net5_159 net5_162) resistor r=58.3583
    rnet5_120 (net5_159 net5_162) resistor r=6.30933
    rnet5_119 (net5_159 net5_162) resistor r=58.3583
    rnet5_118 (net5_159 net5_162) resistor r=6.30933
    rnet5_117 (net5_162 net5_164) resistor r=14.9
    rnet5_116 (net5_162 net5_173) resistor r=24.8333
    rnet5_115 (net5_162 net5_170) resistor r=24.8333
    rnet5_114 (net5_162 net5_181) resistor r=24.8333
    rnet5_113 (net5_162 net5_178) resistor r=24.8333
    rnet5_112 (net5_162 net5_186) resistor r=58.3583
    rnet5_111 (net5_162 net5_189) resistor r=58.3583
    rnet5_110 (net5_162 net5_173) resistor r=4.16253
    rnet5_109 (net5_162 net5_164) resistor r=6.30933
    rnet5_108 (net5_162 net5_181) resistor r=1.63969
    rnet5_107 (net5_162 net5_170) resistor r=4.16253
    rnet5_106 (net5_162 net5_186) resistor r=4.16253
    rnet5_105 (net5_162 net5_178) resistor r=4.16253
    rnet5_104 (net5_162 net5_189) resistor r=4.16253
    rnet5_103 (net5_162 net5_164) resistor r=14.9
    rnet5_102 (net5_162 net5_396) resistor r=39.7333
    rnet5_101 (net5_162 net5_173) resistor r=24.8333
    rnet5_100 (net5_162 net5_170) resistor r=24.8333
    rnet5_99 (net5_162 net5_181) resistor r=24.8333
    rnet5_98 (net5_162 net5_178) resistor r=24.8333
    rnet5_97 (net5_162 net5_186) resistor r=58.3583
    rnet5_96 (net5_162 MM3_g) resistor r=7.45
    rnet5_95 (net5_162 net5_173) resistor r=4.16253
    rnet5_94 (net5_162 net5_164) resistor r=6.30933
    rnet5_93 (net5_162 net5_181) resistor r=1.63969
    rnet5_92 (net5_162 net5_170) resistor r=4.16253
    rnet5_91 (net5_162 net5_186) resistor r=4.16253
    rnet5_90 (net5_162 net5_178) resistor r=4.16253
    rnet5_89 (net5_162 net5_189) resistor r=4.16253
    rnet5_88 (net5_189 MM3_g) resistor r=50.9083
    rnet5_87 (net5_261 net5_263) resistor r=0.950514
    rnet5_86 (net5_261 net5_293) resistor r=0.0114995
    rnet5_85 (net5_263 net5_264) resistor r=10
    rnet5_84 (net5_264 net5_433) resistor r=0.677273
    rnet5_83 (net5_266 net5_267) resistor r=0.0575331
    rnet5_82 (net5_266 net5_293) resistor r=0.0820855
    rnet5_81 (net5_267 net5_273) resistor r=0.0962173
    rnet5_80 (net5_268 net5_269) resistor r=0.786895
    rnet5_79 (net5_268 net5_271) resistor r=0.096078
    rnet5_78 (net5_269 net5_293) resistor r=0.0820855
    rnet5_77 (net5_270 net5_271) resistor r=0.514295
    rnet5_76 (net5_270 net5_287) resistor r=0.096078
    rnet5_75 (net5_272 net5_273) resistor r=0.326892
    rnet5_74 (net5_272 net5_279) resistor r=0.0971872
    rnet5_73 (net5_274 net5_276) resistor r=0.303724
    rnet5_72 (net5_274 net5_294) resistor r=0.0100989
    rnet5_71 (net5_276 net5_277) resistor r=13
    rnet5_70 (net5_277 MM7_ELT_d) resistor r=8.44
    rnet5_69 (net5_279 net5_281) resistor r=0.293067
    rnet5_68 (net5_281 net5_282) resistor r=13
    rnet5_67 (net5_282 net5) resistor r=8.09035
    rnet5_66 (net5_284 net5_285) resistor r=0.175645
    rnet5_65 (net5_284 net5_296) resistor r=0.0100989
    rnet5_64 (net5_285 net5_298) resistor r=0.133147
    rnet5_63 (net5_286 net5_287) resistor r=0.170024
    rnet5_62 (net5_286 net5_298) resistor r=0.133147
    rnet5_61 (net5_288 net5_290) resistor r=0.435732
    rnet5_60 (net5_288 net5_298) resistor r=0.0190219
    rnet5_59 (net5_290 net5_291) resistor r=10
    rnet5_58 (net5_291 net5_425) resistor r=34.5409
    rnet5_57 (net5_294 net5_296) resistor r=0.151088
    rnet5_56 (net5_351 net5_433) resistor r=3.1797
    rnet5_55 (net5_366 net5_434) resistor r=3.1797
    rnet5_54 (net5_382 net5_391) resistor r=9.29775
    rnet5_53 (net5_390 net5_391) resistor r=22.35
    rnet5_52 (net5_390 net5_399) resistor r=9.29775
    rnet5_51 (net5_396 net5_426) resistor r=10.0997
    rnet5_50 (net5_398 net5_399) resistor r=255.783
    rnet5_49 (net5_398 net5_426) resistor r=10.0997
    rnet5_48 (net5_425 net5_426) resistor r=0.877078
    rnet5_47 (net5_433 net5_434) resistor r=25.7364
    rnet67_188 (MM8_ELT_d net67) resistor r=0.01
    rnet67_187 (net67_22 net67_28) resistor r=58.3583
    rnet67_186 (net67_22 net67_28) resistor r=4.16253
    rnet67_185 (net67_22 net67_28) resistor r=58.3583
    rnet67_184 (net67_22 net67_28) resistor r=4.16253
    rnet67_183 (net67_25 net67_28) resistor r=58.3583
    rnet67_182 (net67_25 net67_28) resistor r=5.53947
    rnet67_181 (net67_25 net67_28) resistor r=58.3583
    rnet67_180 (net67_25 net67_28) resistor r=5.53947
    rnet67_179 (net67_28 net67_30) resistor r=11.175
    rnet67_178 (net67_28 net67_53) resistor r=24.8333
    rnet67_177 (net67_28 net67_50) resistor r=24.8333
    rnet67_176 (net67_28 net67_69) resistor r=22.35
    rnet67_175 (net67_28 net67_66) resistor r=22.35
    rnet67_174 (net67_28 net67_82) resistor r=58.3583
    rnet67_173 (net67_28 net67_85) resistor r=58.3583
    rnet67_172 (net67_28 net67_53) resistor r=4.16253
    rnet67_171 (net67_28 net67_30) resistor r=5.53947
    rnet67_170 (net67_28 net67_69) resistor r=2.32428
    rnet67_169 (net67_28 net67_50) resistor r=4.16253
    rnet67_168 (net67_28 net67_82) resistor r=4.16253
    rnet67_167 (net67_28 net67_66) resistor r=4.16253
    rnet67_166 (net67_28 net67_85) resistor r=4.16253
    rnet67_165 (net67_28 net67_30) resistor r=11.175
    rnet67_164 (net67_28 net67_211) resistor r=29.8
    rnet67_163 (net67_28 net67_53) resistor r=24.8333
    rnet67_162 (net67_28 net67_50) resistor r=24.8333
    rnet67_161 (net67_28 net67_69) resistor r=22.35
    rnet67_160 (net67_28 net67_66) resistor r=22.35
    rnet67_159 (net67_28 net67_82) resistor r=58.3583
    rnet67_158 (net67_28 MM7_ELT_g) resistor r=7.45
    rnet67_157 (net67_28 net67_53) resistor r=4.16253
    rnet67_156 (net67_28 net67_30) resistor r=5.53947
    rnet67_155 (net67_28 net67_69) resistor r=2.32428
    rnet67_154 (net67_28 net67_50) resistor r=4.16253
    rnet67_153 (net67_28 net67_82) resistor r=4.16253
    rnet67_152 (net67_28 net67_66) resistor r=4.16253
    rnet67_151 (net67_28 net67_85) resistor r=4.16253
    rnet67_150 (net67_36 net67_39) resistor r=11.175
    rnet67_149 (net67_36 net67_39) resistor r=5.53947
    rnet67_148 (net67_36 net67_39) resistor r=11.175
    rnet67_147 (net67_36 net67_39) resistor r=5.53947
    rnet67_146 (net67_39 net67_42) resistor r=58.3583
    rnet67_145 (net67_39 net67_45) resistor r=58.3583
    rnet67_144 (net67_39 net67_61) resistor r=24.8333
    rnet67_143 (net67_39 net67_58) resistor r=24.8333
    rnet67_142 (net67_39 net67_77) resistor r=22.35
    rnet67_141 (net67_39 net67_74) resistor r=22.35
    rnet67_140 (net67_39 net67_90) resistor r=58.3583
    rnet67_139 (net67_39 net67_93) resistor r=58.3583
    rnet67_138 (net67_39 net67_42) resistor r=5.53947
    rnet67_137 (net67_39 net67_77) resistor r=2.32428
    rnet67_136 (net67_39 net67_61) resistor r=4.16253
    rnet67_135 (net67_39 net67_45) resistor r=4.16253
    rnet67_134 (net67_39 net67_74) resistor r=4.16253
    rnet67_133 (net67_39 net67_90) resistor r=4.16253
    rnet67_132 (net67_39 net67_58) resistor r=4.16253
    rnet67_131 (net67_39 net67_93) resistor r=4.16253
    rnet67_130 (net67_39 net67_213) resistor r=247.712
    rnet67_129 (net67_39 net67_42) resistor r=58.3583
    rnet67_128 (net67_39 net67_45) resistor r=58.3583
    rnet67_127 (net67_39 net67_61) resistor r=24.8333
    rnet67_126 (net67_39 net67_58) resistor r=24.8333
    rnet67_125 (net67_39 net67_77) resistor r=22.35
    rnet67_124 (net67_39 net67_74) resistor r=22.35
    rnet67_123 (net67_39 net67_90) resistor r=58.3583
    rnet67_122 (net67_39 MM6_ELT_g) resistor r=7.45
    rnet67_121 (net67_39 net67_42) resistor r=5.53947
    rnet67_120 (net67_39 net67_77) resistor r=2.32428
    rnet67_119 (net67_39 net67_61) resistor r=4.16253
    rnet67_118 (net67_39 net67_45) resistor r=4.16253
    rnet67_117 (net67_39 net67_74) resistor r=4.16253
    rnet67_116 (net67_39 net67_90) resistor r=4.16253
    rnet67_115 (net67_39 net67_58) resistor r=4.16253
    rnet67_114 (net67_39 net67_93) resistor r=4.16253
    rnet67_113 (net67_85 MM7_ELT_g) resistor r=50.9083
    rnet67_112 (net67_93 MM6_ELT_g) resistor r=50.9083
    rnet67_111 (net67_131 net67_132) resistor r=0.529252
    rnet67_110 (net67_131 net67_139) resistor r=0.096078
    rnet67_109 (net67_132 net67_183) resistor r=0.0728149
    rnet67_108 (net67_133 net67_135) resistor r=0.372922
    rnet67_107 (net67_133 net67_183) resistor r=0.0728149
    rnet67_106 (net67_135 net67_136) resistor r=8.66667
    rnet67_105 (net67_136 MM15_ELT_d) resistor r=2.78649
    rnet67_104 (net67_136 net67_260) resistor r=11.6377
    rnet67_103 (net67_138 net67_139) resistor r=0.112217
    rnet67_102 (net67_138 net67_142) resistor r=0.096078
    rnet67_101 (net67_140 net67_141) resistor r=1.02443
    rnet67_100 (net67_140 net67_147) resistor r=0.096078
    rnet67_99 (net67_141 net67_183) resistor r=0.0189233
    rnet67_98 (net67_142 net67_144) resistor r=0.399637
    rnet67_97 (net67_144 net67_145) resistor r=13
    rnet67_96 (net67_145 MM16_ELT_d) resistor r=8.44
    rnet67_95 (net67_147 net67_148) resistor r=0.580603
    rnet67_94 (net67_148 net67_150) resistor r=0.096078
    rnet67_93 (net67_149 net67_150) resistor r=0.389671
    rnet67_92 (net67_149 net67_184) resistor r=0.0728149
    rnet67_91 (net67_151 net67_153) resistor r=0.209798
    rnet67_90 (net67_151 net67_157) resistor r=0.096078
    rnet67_89 (net67_153 net67_154) resistor r=13
    rnet67_88 (net67_154 MM10_ELT_d) resistor r=8.09035
    rnet67_87 (net67_156 net67_157) resistor r=0.385547
    rnet67_86 (net67_156 net67_186) resistor r=0.0728149
    rnet67_85 (net67_158 net67_160) resistor r=0.414716
    rnet67_84 (net67_158 net67_184) resistor r=0.0189233
    rnet67_83 (net67_160 net67_161) resistor r=13
    rnet67_82 (net67_161 MM11_ELT_d) resistor r=8.44
    rnet67_81 (net67_163 net67_164) resistor r=0.167002
    rnet67_80 (net67_163 net67_185) resistor r=0.0728149
    rnet67_79 (net67_164 net67_184) resistor r=0.0728149
    rnet67_78 (net67_165 net67_166) resistor r=0.617286
    rnet67_77 (net67_165 net67_185) resistor r=0.0189233
    rnet67_76 (net67_166 net67_186) resistor r=0.0189233
    rnet67_75 (net67_167 net67_168) resistor r=0.864827
    rnet67_74 (net67_167 net67_172) resistor r=0.096078
    rnet67_73 (net67_168 net67_185) resistor r=0.0728149
    rnet67_72 (net67_169 net67_170) resistor r=0.980142
    rnet67_71 (net67_169 net67_178) resistor r=0.096078
    rnet67_70 (net67_170 net67_186) resistor r=0.0728149
    rnet67_69 (net67_171 net67_172) resistor r=1.08887
    rnet67_68 (net67_171 net67_173) resistor r=0.101343
    rnet67_67 (net67_173 net67_175) resistor r=0.330213
    rnet67_66 (net67_175 net67_176) resistor r=10
    rnet67_65 (net67_176 net67_243) resistor r=12.8682
    rnet67_64 (net67_178 net67_180) resistor r=0.229125
    rnet67_63 (net67_180 net67_181) resistor r=13
    rnet67_62 (net67_181 net67) resistor r=8.09035
    rnet67_61 (net67_211 net67_244) resistor r=8.1518
    rnet67_60 (net67_213 net67_244) resistor r=8.1518
    rnet67_59 (net67_243 net67_244) resistor r=0.275023
    rnet67_58 (MM15_ELT_d net67_254) resistor r=2.55965
    rnet67_57 (MM15_ELT_d net67_256) resistor r=12.3172
    rnet67_56 (MM15_ELT_d net67_256) resistor r=1.62887
    rnet67_55 (MM15_ELT_d net67_259) resistor r=4.36821
    rnet67_54 (net67_252 net67_254) resistor r=14.4784
    rnet67_53 (net67_252 net67_257) resistor r=9.04062
    rnet67_52 (net67_253 net67_254) resistor r=14.4784
    rnet67_51 (net67_253 net67_260) resistor r=9.48555
    rnet67_50 (net67_255 net67_256) resistor r=12.3172
    rnet67_49 (net67_255 net67_258) resistor r=9.04595
    rnet67_48 (net67_257 net67_259) resistor r=20.2547
    rnet67_47 (net67_258 net67_259) resistor r=20.2547
    rnet25_21 (MM13_ELT_d net25) resistor r=0.01
    rnet25_20 (net25_1 net25_3) resistor r=0.170766
    rnet25_19 (net25_1 net25_7) resistor r=0.096078
    rnet25_18 (net25_3 net25_4) resistor r=13
    rnet25_17 (net25_4 MM12_ELT_s) resistor r=8.44
    rnet25_16 (net25_6 net25_7) resistor r=0.127201
    rnet25_15 (net25_6 net25_9) resistor r=0.096078
    rnet25_14 (net25_8 net25_9) resistor r=0.70521
    rnet25_13 (net25_8 net25_15) resistor r=0.0100989
    rnet25_12 (net25_10 net25_12) resistor r=0.399637
    rnet25_11 (net25_10 net25_17) resistor r=0.0100989
    rnet25_10 (net25_12 net25_13) resistor r=13
    rnet25_9 (net25_13 net25) resistor r=8.44
    rnet25_8 (net25_15 net25_17) resistor r=0.0780642
    rnet20_18 (MM18_ELT_d net20) resistor r=0.01
    rnet20_17 (net20_1 net20_3) resistor r=0.0586134
    rnet20_16 (net20_1 net20_17) resistor r=0.0728149
    rnet20_15 (net20_3 net20_4) resistor r=13
    rnet20_14 (net20_4 MM17_ELT_s) resistor r=8.44
    rnet20_13 (net20_8 net20_9) resistor r=0.592175
    rnet20_12 (net20_8 net20_18) resistor r=0.0189233
    rnet20_11 (net20_9 net20_17) resistor r=0.0189233
    rnet20_10 (net20_10 net20_12) resistor r=0.0586134
    rnet20_9 (net20_10 net20_18) resistor r=0.0728149
    rnet20_8 (net20_12 net20_13) resistor r=13
    rnet20_7 (net20_13 net20) resistor r=8.44
    rCDN_333 (CDN_66 CDN_72) resistor r=58.3583
    rCDN_332 (CDN_66 CDN_72) resistor r=4.16253
    rCDN_331 (CDN_66 CDN_72) resistor r=58.3583
    rCDN_330 (CDN_66 CDN_72) resistor r=4.16253
    rCDN_329 (CDN_69 CDN_72) resistor r=58.3583
    rCDN_328 (CDN_69 CDN_72) resistor r=4.16253
    rCDN_327 (CDN_69 CDN_72) resistor r=58.3583
    rCDN_326 (CDN_69 CDN_72) resistor r=4.16253
    rCDN_325 (CDN_72 CDN_77) resistor r=24.8333
    rCDN_324 (CDN_72 CDN_74) resistor r=24.8333
    rCDN_323 (CDN_72 CDN_85) resistor r=24.8333
    rCDN_322 (CDN_72 CDN_82) resistor r=24.8333
    rCDN_321 (CDN_72 CDN_90) resistor r=58.3583
    rCDN_320 (CDN_72 CDN_93) resistor r=58.3583
    rCDN_319 (CDN_72 CDN_98) resistor r=14.9
    rCDN_318 (CDN_72 CDN_77) resistor r=4.16253
    rCDN_317 (CDN_72 CDN_85) resistor r=4.16253
    rCDN_316 (CDN_72 CDN_74) resistor r=4.16253
    rCDN_315 (CDN_72 CDN_90) resistor r=4.16253
    rCDN_314 (CDN_72 CDN_98) resistor r=6.30933
    rCDN_313 (CDN_72 CDN_93) resistor r=6.30933
    rCDN_312 (CDN_72 CDN_82) resistor r=1.63969
    rCDN_311 (CDN_72 CDN_77) resistor r=24.8333
    rCDN_310 (CDN_72 CDN_74) resistor r=24.8333
    rCDN_309 (CDN_72 CDN_85) resistor r=24.8333
    rCDN_308 (CDN_72 CDN_82) resistor r=24.8333
    rCDN_307 (CDN_72 CDN_90) resistor r=58.3583
    rCDN_306 (CDN_72 MM18_ELT_g) resistor r=22.35
    rCDN_305 (CDN_72 CDN_98) resistor r=14.9
    rCDN_304 (CDN_72 CDN_514) resistor r=39.7333
    rCDN_303 (CDN_72 CDN_77) resistor r=4.16253
    rCDN_302 (CDN_72 CDN_85) resistor r=4.16253
    rCDN_301 (CDN_72 CDN_74) resistor r=4.16253
    rCDN_300 (CDN_72 CDN_90) resistor r=4.16253
    rCDN_299 (CDN_72 CDN_98) resistor r=6.30933
    rCDN_298 (CDN_72 CDN_93) resistor r=6.30933
    rCDN_297 (CDN_72 CDN_82) resistor r=1.63969
    rCDN_296 (CDN_93 MM18_ELT_g) resistor r=36.0083
    rCDN_295 (CDN_104 CDN_110) resistor r=58.3583
    rCDN_294 (CDN_104 CDN_110) resistor r=4.16253
    rCDN_293 (CDN_104 CDN_110) resistor r=58.3583
    rCDN_292 (CDN_104 CDN_110) resistor r=4.16253
    rCDN_291 (CDN_107 CDN_110) resistor r=58.3583
    rCDN_290 (CDN_107 CDN_110) resistor r=6.30933
    rCDN_289 (CDN_107 CDN_110) resistor r=58.3583
    rCDN_288 (CDN_107 CDN_110) resistor r=6.30933
    rCDN_287 (CDN_110 CDN_112) resistor r=14.9
    rCDN_286 (CDN_110 CDN_121) resistor r=24.8333
    rCDN_285 (CDN_110 CDN_118) resistor r=24.8333
    rCDN_284 (CDN_110 CDN_129) resistor r=24.8333
    rCDN_283 (CDN_110 CDN_126) resistor r=24.8333
    rCDN_282 (CDN_110 CDN_142) resistor r=58.3583
    rCDN_281 (CDN_110 CDN_145) resistor r=58.3583
    rCDN_280 (CDN_110 CDN_121) resistor r=4.16253
    rCDN_279 (CDN_110 CDN_112) resistor r=6.30933
    rCDN_278 (CDN_110 CDN_129) resistor r=1.63969
    rCDN_277 (CDN_110 CDN_118) resistor r=4.16253
    rCDN_276 (CDN_110 CDN_142) resistor r=4.16253
    rCDN_275 (CDN_110 CDN_126) resistor r=4.16253
    rCDN_274 (CDN_110 CDN_145) resistor r=4.16253
    rCDN_273 (CDN_110 CDN_112) resistor r=14.9
    rCDN_272 (CDN_110 CDN_522) resistor r=39.7333
    rCDN_271 (CDN_110 CDN_121) resistor r=24.8333
    rCDN_270 (CDN_110 CDN_118) resistor r=24.8333
    rCDN_269 (CDN_110 CDN_129) resistor r=24.8333
    rCDN_268 (CDN_110 CDN_126) resistor r=24.8333
    rCDN_267 (CDN_110 CDN_142) resistor r=58.3583
    rCDN_266 (CDN_110 MM13_ELT_g) resistor r=7.45
    rCDN_265 (CDN_110 CDN_121) resistor r=4.16253
    rCDN_264 (CDN_110 CDN_112) resistor r=6.30933
    rCDN_263 (CDN_110 CDN_129) resistor r=1.63969
    rCDN_262 (CDN_110 CDN_118) resistor r=4.16253
    rCDN_261 (CDN_110 CDN_142) resistor r=4.16253
    rCDN_260 (CDN_110 CDN_126) resistor r=4.16253
    rCDN_259 (CDN_110 CDN_145) resistor r=4.16253
    rCDN_258 (CDN_134 CDN_140) resistor r=58.3583
    rCDN_257 (CDN_134 CDN_140) resistor r=4.16253
    rCDN_256 (CDN_134 CDN_140) resistor r=58.3583
    rCDN_255 (CDN_134 CDN_140) resistor r=4.16253
    rCDN_254 (CDN_137 CDN_140) resistor r=58.3583
    rCDN_253 (CDN_137 CDN_140) resistor r=4.16253
    rCDN_252 (CDN_137 CDN_140) resistor r=58.3583
    rCDN_251 (CDN_137 CDN_140) resistor r=4.16253
    rCDN_250 (CDN_140 CDN_153) resistor r=8.69167
    rCDN_249 (CDN_140 CDN_150) resistor r=8.69167
    rCDN_248 (CDN_140 CDN_161) resistor r=24.8333
    rCDN_247 (CDN_140 CDN_158) resistor r=24.8333
    rCDN_246 (CDN_140 CDN_166) resistor r=14.9
    rCDN_245 (CDN_140 CDN_175) resistor r=8.69167
    rCDN_244 (CDN_140 CDN_172) resistor r=8.69167
    rCDN_243 (CDN_140 CDN_180) resistor r=58.3583
    rCDN_242 (CDN_140 CDN_183) resistor r=58.3583
    rCDN_241 (CDN_140 CDN_153) resistor r=4.16253
    rCDN_240 (CDN_140 CDN_161) resistor r=4.16253
    rCDN_239 (CDN_140 CDN_175) resistor r=6.30933
    rCDN_238 (CDN_140 CDN_150) resistor r=6.30933
    rCDN_237 (CDN_140 CDN_166) resistor r=1.63969
    rCDN_236 (CDN_140 CDN_172) resistor r=4.16253
    rCDN_235 (CDN_140 CDN_180) resistor r=4.16253
    rCDN_234 (CDN_140 CDN_158) resistor r=4.16253
    rCDN_233 (CDN_140 CDN_183) resistor r=4.16253
    rCDN_232 (CDN_140 CDN_153) resistor r=8.69167
    rCDN_231 (CDN_140 CDN_150) resistor r=8.69167
    rCDN_230 (CDN_140 CDN_161) resistor r=24.8333
    rCDN_229 (CDN_140 CDN_158) resistor r=24.8333
    rCDN_228 (CDN_140 CDN_546) resistor r=330.283
    rCDN_227 (CDN_140 CDN_166) resistor r=14.9
    rCDN_226 (CDN_140 CDN_175) resistor r=8.69167
    rCDN_225 (CDN_140 CDN_172) resistor r=8.69167
    rCDN_224 (CDN_140 CDN_180) resistor r=58.3583
    rCDN_223 (CDN_140 MM8_ELT_g) resistor r=7.45
    rCDN_222 (CDN_140 CDN_153) resistor r=4.16253
    rCDN_221 (CDN_140 CDN_161) resistor r=4.16253
    rCDN_220 (CDN_140 CDN_175) resistor r=6.30933
    rCDN_219 (CDN_140 CDN_150) resistor r=6.30933
    rCDN_218 (CDN_140 CDN_166) resistor r=1.63969
    rCDN_217 (CDN_140 CDN_172) resistor r=4.16253
    rCDN_216 (CDN_140 CDN_180) resistor r=4.16253
    rCDN_215 (CDN_140 CDN_158) resistor r=4.16253
    rCDN_214 (CDN_140 CDN_183) resistor r=4.16253
    rCDN_213 (CDN_145 MM13_ELT_g) resistor r=50.9083
    rCDN_212 (CDN_183 MM8_ELT_g) resistor r=50.9083
    rCDN_211 (CDN_188 CDN_194) resistor r=58.3583
    rCDN_210 (CDN_188 CDN_194) resistor r=4.16253
    rCDN_209 (CDN_188 CDN_194) resistor r=58.3583
    rCDN_208 (CDN_188 CDN_194) resistor r=4.16253
    rCDN_207 (CDN_191 CDN_194) resistor r=58.3583
    rCDN_206 (CDN_191 CDN_194) resistor r=4.16253
    rCDN_205 (CDN_191 CDN_194) resistor r=58.3583
    rCDN_204 (CDN_191 CDN_194) resistor r=4.16253
    rCDN_203 (CDN_194 CDN_199) resistor r=24.8333
    rCDN_202 (CDN_194 CDN_196) resistor r=24.8333
    rCDN_201 (CDN_194 CDN_207) resistor r=24.8333
    rCDN_200 (CDN_194 CDN_204) resistor r=24.8333
    rCDN_199 (CDN_194 CDN_212) resistor r=58.3583
    rCDN_198 (CDN_194 CDN_215) resistor r=58.3583
    rCDN_197 (CDN_194 CDN_220) resistor r=14.9
    rCDN_196 (CDN_194 CDN_199) resistor r=4.16253
    rCDN_195 (CDN_194 CDN_207) resistor r=4.16253
    rCDN_194 (CDN_194 CDN_196) resistor r=4.16253
    rCDN_193 (CDN_194 CDN_212) resistor r=4.16253
    rCDN_192 (CDN_194 CDN_220) resistor r=6.30933
    rCDN_191 (CDN_194 CDN_215) resistor r=6.30933
    rCDN_190 (CDN_194 CDN_204) resistor r=1.63969
    rCDN_189 (CDN_194 CDN_199) resistor r=24.8333
    rCDN_188 (CDN_194 CDN_196) resistor r=24.8333
    rCDN_187 (CDN_194 CDN_207) resistor r=24.8333
    rCDN_186 (CDN_194 CDN_204) resistor r=24.8333
    rCDN_185 (CDN_194 CDN_212) resistor r=58.3583
    rCDN_184 (CDN_194 MM0_g) resistor r=22.35
    rCDN_183 (CDN_194 CDN_220) resistor r=14.9
    rCDN_182 (CDN_194 CDN_572) resistor r=39.7333
    rCDN_181 (CDN_194 CDN_199) resistor r=4.16253
    rCDN_180 (CDN_194 CDN_207) resistor r=4.16253
    rCDN_179 (CDN_194 CDN_196) resistor r=4.16253
    rCDN_178 (CDN_194 CDN_212) resistor r=4.16253
    rCDN_177 (CDN_194 CDN_220) resistor r=6.30933
    rCDN_176 (CDN_194 CDN_215) resistor r=6.30933
    rCDN_175 (CDN_194 CDN_204) resistor r=1.63969
    rCDN_174 (CDN_215 MM0_g) resistor r=36.0083
    rCDN_173 (CDN_226 CDN_232) resistor r=58.3583
    rCDN_172 (CDN_226 CDN_232) resistor r=4.16253
    rCDN_171 (CDN_226 CDN_232) resistor r=58.3583
    rCDN_170 (CDN_226 CDN_232) resistor r=4.16253
    rCDN_169 (CDN_229 CDN_232) resistor r=58.3583
    rCDN_168 (CDN_229 CDN_232) resistor r=6.30933
    rCDN_167 (CDN_229 CDN_232) resistor r=58.3583
    rCDN_166 (CDN_229 CDN_232) resistor r=6.30933
    rCDN_165 (CDN_232 CDN_234) resistor r=14.9
    rCDN_164 (CDN_232 CDN_243) resistor r=24.8333
    rCDN_163 (CDN_232 CDN_240) resistor r=24.8333
    rCDN_162 (CDN_232 CDN_251) resistor r=24.8333
    rCDN_161 (CDN_232 CDN_248) resistor r=24.8333
    rCDN_160 (CDN_232 CDN_264) resistor r=58.3583
    rCDN_159 (CDN_232 CDN_267) resistor r=58.3583
    rCDN_158 (CDN_232 CDN_243) resistor r=4.16253
    rCDN_157 (CDN_232 CDN_234) resistor r=6.30933
    rCDN_156 (CDN_232 CDN_251) resistor r=1.63969
    rCDN_155 (CDN_232 CDN_240) resistor r=4.16253
    rCDN_154 (CDN_232 CDN_264) resistor r=4.16253
    rCDN_153 (CDN_232 CDN_248) resistor r=4.16253
    rCDN_152 (CDN_232 CDN_267) resistor r=4.16253
    rCDN_151 (CDN_232 CDN_234) resistor r=14.9
    rCDN_150 (CDN_232 CDN_580) resistor r=39.7333
    rCDN_149 (CDN_232 CDN_243) resistor r=24.8333
    rCDN_148 (CDN_232 CDN_240) resistor r=24.8333
    rCDN_147 (CDN_232 CDN_251) resistor r=24.8333
    rCDN_146 (CDN_232 CDN_248) resistor r=24.8333
    rCDN_145 (CDN_232 CDN_264) resistor r=58.3583
    rCDN_144 (CDN_232 MM1_g) resistor r=7.45
    rCDN_143 (CDN_232 CDN_243) resistor r=4.16253
    rCDN_142 (CDN_232 CDN_234) resistor r=6.30933
    rCDN_141 (CDN_232 CDN_251) resistor r=1.63969
    rCDN_140 (CDN_232 CDN_240) resistor r=4.16253
    rCDN_139 (CDN_232 CDN_264) resistor r=4.16253
    rCDN_138 (CDN_232 CDN_248) resistor r=4.16253
    rCDN_137 (CDN_232 CDN_267) resistor r=4.16253
    rCDN_136 (CDN_256 CDN_262) resistor r=58.3583
    rCDN_135 (CDN_256 CDN_262) resistor r=4.16253
    rCDN_134 (CDN_256 CDN_262) resistor r=58.3583
    rCDN_133 (CDN_256 CDN_262) resistor r=4.16253
    rCDN_132 (CDN_259 CDN_262) resistor r=58.3583
    rCDN_131 (CDN_259 CDN_262) resistor r=4.16253
    rCDN_130 (CDN_259 CDN_262) resistor r=58.3583
    rCDN_129 (CDN_259 CDN_262) resistor r=4.16253
    rCDN_128 (CDN_262 CDN_275) resistor r=8.69167
    rCDN_127 (CDN_262 CDN_272) resistor r=8.69167
    rCDN_126 (CDN_262 CDN_283) resistor r=24.8333
    rCDN_125 (CDN_262 CDN_280) resistor r=24.8333
    rCDN_124 (CDN_262 CDN_288) resistor r=14.9
    rCDN_123 (CDN_262 CDN_297) resistor r=8.69167
    rCDN_122 (CDN_262 CDN_294) resistor r=8.69167
    rCDN_121 (CDN_262 CDN_302) resistor r=58.3583
    rCDN_120 (CDN_262 CDN_305) resistor r=58.3583
    rCDN_119 (CDN_262 CDN_275) resistor r=4.16253
    rCDN_118 (CDN_262 CDN_283) resistor r=4.16253
    rCDN_117 (CDN_262 CDN_297) resistor r=6.30933
    rCDN_116 (CDN_262 CDN_272) resistor r=6.30933
    rCDN_115 (CDN_262 CDN_288) resistor r=1.63969
    rCDN_114 (CDN_262 CDN_294) resistor r=4.16253
    rCDN_113 (CDN_262 CDN_302) resistor r=4.16253
    rCDN_112 (CDN_262 CDN_280) resistor r=4.16253
    rCDN_111 (CDN_262 CDN_305) resistor r=4.16253
    rCDN_110 (CDN_262 CDN_275) resistor r=8.69167
    rCDN_109 (CDN_262 CDN_272) resistor r=8.69167
    rCDN_108 (CDN_262 CDN_283) resistor r=24.8333
    rCDN_107 (CDN_262 CDN_280) resistor r=24.8333
    rCDN_106 (CDN_262 CDN_604) resistor r=330.283
    rCDN_105 (CDN_262 CDN_288) resistor r=14.9
    rCDN_104 (CDN_262 CDN_297) resistor r=8.69167
    rCDN_103 (CDN_262 CDN_294) resistor r=8.69167
    rCDN_102 (CDN_262 CDN_302) resistor r=58.3583
    rCDN_101 (CDN_262 MM11_g) resistor r=7.45
    rCDN_100 (CDN_262 CDN_275) resistor r=4.16253
    rCDN_99 (CDN_262 CDN_283) resistor r=4.16253
    rCDN_98 (CDN_262 CDN_297) resistor r=6.30933
    rCDN_97 (CDN_262 CDN_272) resistor r=6.30933
    rCDN_96 (CDN_262 CDN_288) resistor r=1.63969
    rCDN_95 (CDN_262 CDN_294) resistor r=4.16253
    rCDN_94 (CDN_262 CDN_302) resistor r=4.16253
    rCDN_93 (CDN_262 CDN_280) resistor r=4.16253
    rCDN_92 (CDN_262 CDN_305) resistor r=4.16253
    rCDN_91 (CDN_267 MM1_g) resistor r=50.9083
    rCDN_90 (CDN_305 MM11_g) resistor r=50.9083
    rCDN_89 (CDN_419 CDN_421) resistor r=0.147977
    rCDN_88 (CDN_419 CDN_425) resistor r=0.0765118
    rCDN_87 (CDN_421 CDN) resistor r=0.75
    rCDN_86 (CDN_424 CDN_425) resistor r=0.116824
    rCDN_85 (CDN_424 CDN_427) resistor r=0.0765118
    rCDN_84 (CDN_426 CDN_427) resistor r=2.51043
    rCDN_83 (CDN_426 CDN_428) resistor r=0.0765118
    rCDN_82 (CDN_428 CDN_429) resistor r=0.116824
    rCDN_81 (CDN_429 CDN_433) resistor r=0.0382559
    rCDN_80 (CDN_433 CDN_434) resistor r=0.75
    rCDN_79 (CDN_434 CDN_652) resistor r=10
    rCDN_78 (CDN_514 CDN_620) resistor r=4.38767
    rCDN_77 (CDN_516 CDN_517) resistor r=27.0909
    rCDN_76 (CDN_516 CDN_623) resistor r=3.71511
    rCDN_75 (CDN_517 CDN_620) resistor r=3.71511
    rCDN_74 (CDN_522 CDN_623) resistor r=4.38767
    rCDN_73 (CDN_530 CDN_531) resistor r=38.6045
    rCDN_72 (CDN_530 CDN_546) resistor r=9.29775
    rCDN_71 (CDN_531 CDN_623) resistor r=3.71511
    rCDN_70 (CDN_572 CDN_636) resistor r=4.38767
    rCDN_69 (CDN_574 CDN_575) resistor r=27.0909
    rCDN_68 (CDN_574 CDN_639) resistor r=3.71511
    rCDN_67 (CDN_575 CDN_636) resistor r=3.71511
    rCDN_66 (CDN_580 CDN_639) resistor r=4.38767
    rCDN_65 (CDN_588 CDN_589) resistor r=38.6045
    rCDN_64 (CDN_588 CDN_604) resistor r=9.29775
    rCDN_63 (CDN_589 CDN_639) resistor r=3.71511
    rCDN_62 (CDN_619 CDN_620) resistor r=3.71511
    rCDN_61 (CDN_619 CDN_648) resistor r=11.5136
    rCDN_60 (CDN_635 CDN_636) resistor r=3.71511
    rCDN_59 (CDN_635 CDN_652) resistor r=11.5136
    rCDN_58 (CDN_648 CDN) resistor r=10
    rCPN_278 (CPN_42 CPN_48) resistor r=58.3583
    rCPN_277 (CPN_42 CPN_48) resistor r=4.16253
    rCPN_276 (CPN_42 CPN_48) resistor r=58.3583
    rCPN_275 (CPN_42 CPN_48) resistor r=4.16253
    rCPN_274 (CPN_45 CPN_48) resistor r=58.3583
    rCPN_273 (CPN_45 CPN_48) resistor r=6.30933
    rCPN_272 (CPN_45 CPN_48) resistor r=58.3583
    rCPN_271 (CPN_45 CPN_48) resistor r=6.30933
    rCPN_270 (CPN_48 CPN_50) resistor r=14.9
    rCPN_269 (CPN_48 CPN_59) resistor r=24.8333
    rCPN_268 (CPN_48 CPN_56) resistor r=24.8333
    rCPN_267 (CPN_48 CPN_67) resistor r=24.8333
    rCPN_266 (CPN_48 CPN_64) resistor r=24.8333
    rCPN_265 (CPN_48 CPN_72) resistor r=58.3583
    rCPN_264 (CPN_48 CPN_75) resistor r=58.3583
    rCPN_263 (CPN_48 CPN_59) resistor r=4.16253
    rCPN_262 (CPN_48 CPN_50) resistor r=6.30933
    rCPN_261 (CPN_48 CPN_67) resistor r=1.63969
    rCPN_260 (CPN_48 CPN_56) resistor r=4.16253
    rCPN_259 (CPN_48 CPN_72) resistor r=4.16253
    rCPN_258 (CPN_48 CPN_64) resistor r=4.16253
    rCPN_257 (CPN_48 CPN_75) resistor r=4.16253
    rCPN_256 (CPN_48 CPN_50) resistor r=14.9
    rCPN_255 (CPN_48 CPN_368) resistor r=39.7333
    rCPN_254 (CPN_48 CPN_59) resistor r=24.8333
    rCPN_253 (CPN_48 CPN_56) resistor r=24.8333
    rCPN_252 (CPN_48 CPN_67) resistor r=24.8333
    rCPN_251 (CPN_48 CPN_64) resistor r=24.8333
    rCPN_250 (CPN_48 CPN_72) resistor r=58.3583
    rCPN_249 (CPN_48 MM15_ELT_g) resistor r=7.45
    rCPN_248 (CPN_48 CPN_59) resistor r=4.16253
    rCPN_247 (CPN_48 CPN_50) resistor r=6.30933
    rCPN_246 (CPN_48 CPN_67) resistor r=1.63969
    rCPN_245 (CPN_48 CPN_56) resistor r=4.16253
    rCPN_244 (CPN_48 CPN_72) resistor r=4.16253
    rCPN_243 (CPN_48 CPN_64) resistor r=4.16253
    rCPN_242 (CPN_48 CPN_75) resistor r=4.16253
    rCPN_241 (CPN_75 MM15_ELT_g) resistor r=50.9083
    rCPN_240 (CPN_80 CPN_83) resistor r=14.9
    rCPN_239 (CPN_80 CPN_83) resistor r=6.30933
    rCPN_238 (CPN_80 CPN_83) resistor r=14.9
    rCPN_237 (CPN_80 CPN_83) resistor r=6.30933
    rCPN_236 (CPN_83 CPN_86) resistor r=58.3583
    rCPN_235 (CPN_83 CPN_89) resistor r=58.3583
    rCPN_234 (CPN_83 CPN_97) resistor r=24.8333
    rCPN_233 (CPN_83 CPN_94) resistor r=24.8333
    rCPN_232 (CPN_83 CPN_105) resistor r=24.8333
    rCPN_231 (CPN_83 CPN_102) resistor r=24.8333
    rCPN_230 (CPN_83 CPN_110) resistor r=58.3583
    rCPN_229 (CPN_83 CPN_113) resistor r=58.3583
    rCPN_228 (CPN_83 CPN_86) resistor r=6.30933
    rCPN_227 (CPN_83 CPN_97) resistor r=1.63969
    rCPN_226 (CPN_83 CPN_105) resistor r=4.16253
    rCPN_225 (CPN_83 CPN_89) resistor r=4.16253
    rCPN_224 (CPN_83 CPN_94) resistor r=4.16253
    rCPN_223 (CPN_83 CPN_110) resistor r=4.16253
    rCPN_222 (CPN_83 CPN_102) resistor r=4.16253
    rCPN_221 (CPN_83 CPN_113) resistor r=4.16253
    rCPN_220 (CPN_83 CPN_381) resistor r=39.7333
    rCPN_219 (CPN_83 CPN_86) resistor r=58.3583
    rCPN_218 (CPN_83 CPN_89) resistor r=58.3583
    rCPN_217 (CPN_83 CPN_97) resistor r=24.8333
    rCPN_216 (CPN_83 CPN_94) resistor r=24.8333
    rCPN_215 (CPN_83 CPN_105) resistor r=24.8333
    rCPN_214 (CPN_83 CPN_102) resistor r=24.8333
    rCPN_213 (CPN_83 CPN_110) resistor r=58.3583
    rCPN_212 (CPN_83 MM11_ELT_g) resistor r=7.45
    rCPN_211 (CPN_83 CPN_86) resistor r=6.30933
    rCPN_210 (CPN_83 CPN_97) resistor r=1.63969
    rCPN_209 (CPN_83 CPN_105) resistor r=4.16253
    rCPN_208 (CPN_83 CPN_89) resistor r=4.16253
    rCPN_207 (CPN_83 CPN_94) resistor r=4.16253
    rCPN_206 (CPN_83 CPN_110) resistor r=4.16253
    rCPN_205 (CPN_83 CPN_102) resistor r=4.16253
    rCPN_204 (CPN_83 CPN_113) resistor r=4.16253
    rCPN_203 (CPN_113 MM11_ELT_g) resistor r=50.9083
    rCPN_202 (CPN_118 CPN_124) resistor r=58.3583
    rCPN_201 (CPN_118 CPN_124) resistor r=4.16253
    rCPN_200 (CPN_118 CPN_124) resistor r=58.3583
    rCPN_199 (CPN_118 CPN_124) resistor r=4.16253
    rCPN_198 (CPN_121 CPN_124) resistor r=58.3583
    rCPN_197 (CPN_121 CPN_124) resistor r=6.30933
    rCPN_196 (CPN_121 CPN_124) resistor r=58.3583
    rCPN_195 (CPN_121 CPN_124) resistor r=6.30933
    rCPN_194 (CPN_124 CPN_126) resistor r=14.9
    rCPN_193 (CPN_124 CPN_135) resistor r=24.8333
    rCPN_192 (CPN_124 CPN_132) resistor r=24.8333
    rCPN_191 (CPN_124 CPN_143) resistor r=24.8333
    rCPN_190 (CPN_124 CPN_140) resistor r=24.8333
    rCPN_189 (CPN_124 CPN_148) resistor r=58.3583
    rCPN_188 (CPN_124 CPN_151) resistor r=58.3583
    rCPN_187 (CPN_124 CPN_135) resistor r=4.16253
    rCPN_186 (CPN_124 CPN_126) resistor r=6.30933
    rCPN_185 (CPN_124 CPN_143) resistor r=1.63969
    rCPN_184 (CPN_124 CPN_132) resistor r=4.16253
    rCPN_183 (CPN_124 CPN_148) resistor r=4.16253
    rCPN_182 (CPN_124 CPN_140) resistor r=4.16253
    rCPN_181 (CPN_124 CPN_151) resistor r=4.16253
    rCPN_180 (CPN_124 CPN_126) resistor r=14.9
    rCPN_179 (CPN_124 CPN_406) resistor r=40.975
    rCPN_178 (CPN_124 CPN_135) resistor r=24.8333
    rCPN_177 (CPN_124 CPN_132) resistor r=24.8333
    rCPN_176 (CPN_124 CPN_143) resistor r=24.8333
    rCPN_175 (CPN_124 CPN_140) resistor r=24.8333
    rCPN_174 (CPN_124 CPN_148) resistor r=58.3583
    rCPN_173 (CPN_124 MM5_g) resistor r=7.45
    rCPN_172 (CPN_124 CPN_135) resistor r=4.16253
    rCPN_171 (CPN_124 CPN_126) resistor r=6.30933
    rCPN_170 (CPN_124 CPN_143) resistor r=1.63969
    rCPN_169 (CPN_124 CPN_132) resistor r=4.16253
    rCPN_168 (CPN_124 CPN_148) resistor r=4.16253
    rCPN_167 (CPN_124 CPN_140) resistor r=4.16253
    rCPN_166 (CPN_124 CPN_151) resistor r=4.16253
    rCPN_165 (CPN_151 MM5_g) resistor r=50.9083
    rCPN_164 (CPN_156 CPN_162) resistor r=58.3583
    rCPN_163 (CPN_156 CPN_162) resistor r=4.16253
    rCPN_162 (CPN_156 CPN_162) resistor r=58.3583
    rCPN_161 (CPN_156 CPN_162) resistor r=4.16253
    rCPN_160 (CPN_159 CPN_162) resistor r=58.3583
    rCPN_159 (CPN_159 CPN_162) resistor r=4.16253
    rCPN_158 (CPN_159 CPN_162) resistor r=58.3583
    rCPN_157 (CPN_159 CPN_162) resistor r=4.16253
    rCPN_156 (CPN_162 CPN_167) resistor r=24.8333
    rCPN_155 (CPN_162 CPN_164) resistor r=24.8333
    rCPN_154 (CPN_162 CPN_175) resistor r=24.8333
    rCPN_153 (CPN_162 CPN_172) resistor r=24.8333
    rCPN_152 (CPN_162 CPN_180) resistor r=14.9
    rCPN_151 (CPN_162 CPN_186) resistor r=58.3583
    rCPN_150 (CPN_162 CPN_189) resistor r=58.3583
    rCPN_149 (CPN_162 CPN_167) resistor r=4.16253
    rCPN_148 (CPN_162 CPN_175) resistor r=4.16253
    rCPN_147 (CPN_162 CPN_186) resistor r=6.30933
    rCPN_146 (CPN_162 CPN_180) resistor r=6.30933
    rCPN_145 (CPN_162 CPN_164) resistor r=1.63969
    rCPN_144 (CPN_162 CPN_172) resistor r=4.16253
    rCPN_143 (CPN_162 CPN_189) resistor r=4.16253
    rCPN_142 (CPN_162 CPN_167) resistor r=24.8333
    rCPN_141 (CPN_162 CPN_164) resistor r=24.8333
    rCPN_140 (CPN_162 CPN_175) resistor r=24.8333
    rCPN_139 (CPN_162 CPN_172) resistor r=24.8333
    rCPN_138 (CPN_162 CPN_428) resistor r=47.1833
    rCPN_137 (CPN_162 CPN_180) resistor r=14.9
    rCPN_136 (CPN_162 CPN_186) resistor r=58.3583
    rCPN_135 (CPN_162 MM8_g) resistor r=7.45
    rCPN_134 (CPN_162 CPN_167) resistor r=4.16253
    rCPN_133 (CPN_162 CPN_175) resistor r=4.16253
    rCPN_132 (CPN_162 CPN_186) resistor r=6.30933
    rCPN_131 (CPN_162 CPN_180) resistor r=6.30933
    rCPN_130 (CPN_162 CPN_164) resistor r=1.63969
    rCPN_129 (CPN_162 CPN_172) resistor r=4.16253
    rCPN_128 (CPN_162 CPN_189) resistor r=4.16253
    rCPN_127 (CPN_189 MM8_g) resistor r=50.9083
    rCPN_126 (CPN_261 CPN_264) resistor r=0.191826
    rCPN_125 (CPN_261 CPN_277) resistor r=0.096078
    rCPN_124 (CPN_262 CPN_264) resistor r=0.399637
    rCPN_123 (CPN_262 CPN_279) resistor r=0.096078
    rCPN_122 (CPN_264 CPN_265) resistor r=13
    rCPN_121 (CPN_265 MM0_ELT_d) resistor r=8.44
    rCPN_120 (CPN_266 CPN_269) resistor r=0.399637
    rCPN_119 (CPN_266 CPN_281) resistor r=0.096078
    rCPN_118 (CPN_267 CPN_269) resistor r=0.362337
    rCPN_117 (CPN_267 CPN_298) resistor r=0.0695687
    rCPN_116 (CPN_269 CPN_270) resistor r=8.66667
    rCPN_115 (CPN_270 MM1_ELT_d) resistor r=32.3614
    rCPN_114 (CPN_273 CPN_274) resistor r=26
    rCPN_113 (CPN_273 CPN_300) resistor r=0.298396
    rCPN_112 (CPN_274 CPN_482) resistor r=32.3614
    rCPN_111 (CPN_276 CPN_277) resistor r=1.4073
    rCPN_110 (CPN_276 CPN_289) resistor r=0.096078
    rCPN_109 (CPN_278 CPN_279) resistor r=0.219465
    rCPN_108 (CPN_278 CPN_287) resistor r=0.096078
    rCPN_107 (CPN_280 CPN_281) resistor r=0.189014
    rCPN_106 (CPN_280 CPN_288) resistor r=0.096078
    rCPN_105 (CPN_282 CPN_284) resistor r=0.34641
    rCPN_104 (CPN_282 CPN_298) resistor r=0.0216905
    rCPN_103 (CPN_284 CPN_285) resistor r=10
    rCPN_102 (CPN_285 CPN_440) resistor r=22.35
    rCPN_101 (CPN_287 CPN_288) resistor r=0.838148
    rCPN_100 (CPN_289 CPN_290) resistor r=0.649364
    rCPN_99 (CPN_290 CPN_292) resistor r=0.096078
    rCPN_98 (CPN_291 CPN_292) resistor r=0.547359
    rCPN_97 (CPN_291 CPN_293) resistor r=0.096078
    rCPN_96 (CPN_293 CPN_294) resistor r=0.179081
    rCPN_95 (CPN_294 CPN_302) resistor r=0.048039
    rCPN_94 (CPN_298 CPN_307) resistor r=0.0695687
    rCPN_93 (CPN_299 CPN_300) resistor r=0.0528187
    rCPN_92 (CPN_299 CPN) resistor r=0.0726295
    rCPN_91 (CPN_302 CPN_303) resistor r=10
    rCPN_90 (CPN_303 CPN_443) resistor r=5.41818
    rCPN_89 (CPN_304 CPN_306) resistor r=0.147977
    rCPN_88 (CPN_304 CPN_310) resistor r=0.0765118
    rCPN_87 (CPN_306 CPN_307) resistor r=0.75
    rCPN_86 (CPN_307 CPN) resistor r=0.176386
    rCPN_85 (CPN_309 CPN_310) resistor r=2.6851
    rCPN_84 (CPN_309 CPN_317) resistor r=0.0765118
    rCPN_83 (CPN_311 CPN_313) resistor r=0.479491
    rCPN_82 (CPN_311 CPN_323) resistor r=0.0579862
    rCPN_81 (CPN_313 CPN_314) resistor r=0.75
    rCPN_80 (CPN_314 CPN_465) resistor r=10
    rCPN_79 (CPN_316 CPN_317) resistor r=0.147977
    rCPN_78 (CPN_316 CPN_323) resistor r=0.0579862
    rCPN_77 (CPN_318 CPN_320) resistor r=0.864498
    rCPN_76 (CPN_318 CPN_323) resistor r=0.0150696
    rCPN_75 (CPN_320 CPN_321) resistor r=0.75
    rCPN_74 (CPN_321 CPN_469) resistor r=10
    rCPN_73 (CPN_368 CPN_440) resistor r=9.29775
    rCPN_72 (CPN_381 CPN_444) resistor r=4.38767
    rCPN_71 (CPN_400 CPN_401) resistor r=29.8
    rCPN_70 (CPN_400 CPN_406) resistor r=9.29775
    rCPN_69 (CPN_401 CPN_449) resistor r=8.32506
    rCPN_68 (CPN_428 CPN_457) resistor r=4.38767
    rCPN_67 (CPN_443 CPN_444) resistor r=3.71511
    rCPN_66 (CPN_449 CPN_465) resistor r=62.9864
    rCPN_65 (CPN_456 CPN_457) resistor r=3.71511
    rCPN_64 (CPN_456 CPN_469) resistor r=14.9
    rCPN_63 (MM1_ELT_d CPN_482) resistor r=16.1807
    rCPN_62 (CPN_482 CPN) resistor r=8.66667
    rnet49_20 (MM14_ELT_d net49) resistor r=0.01
    rnet49_19 (net49_1 net49_3) resistor r=0.447593
    rnet49_18 (net49_1 net49_13) resistor r=0.0100989
    rnet49_17 (net49_3 net49_4) resistor r=13
    rnet49_16 (net49_4 MM15_ELT_s) resistor r=8.09035
    rnet49_15 (net49_6 net49_8) resistor r=0.266425
    rnet49_14 (net49_6 net49_17) resistor r=0.0100989
    rnet49_13 (net49_8 net49_9) resistor r=13
    rnet49_12 (net49_9 net49) resistor r=8.09035
    rnet49_11 (net49_11 net49_12) resistor r=0.402063
    rnet49_10 (net49_11 net49_15) resistor r=0.0100989
    rnet49_9 (net49_12 net49_19) resistor r=0.0100989
    rnet49_8 (net49_13 net49_15) resistor r=0.0927013
    rnet49_7 (net49_17 net49_19) resistor r=0.0927013
    rD_103 (D_22 D_28) resistor r=58.3583
    rD_102 (D_22 D_28) resistor r=4.16253
    rD_101 (D_22 D_28) resistor r=58.3583
    rD_100 (D_22 D_28) resistor r=4.16253
    rD_99 (D_25 D_28) resistor r=58.3583
    rD_98 (D_25 D_28) resistor r=4.16253
    rD_97 (D_25 D_28) resistor r=58.3583
    rD_96 (D_25 D_28) resistor r=4.16253
    rD_95 (D_28 D_33) resistor r=24.8333
    rD_94 (D_28 D_30) resistor r=24.8333
    rD_93 (D_28 D_41) resistor r=24.8333
    rD_92 (D_28 D_38) resistor r=24.8333
    rD_91 (D_28 D_46) resistor r=14.9
    rD_90 (D_28 D_52) resistor r=58.3583
    rD_89 (D_28 D_55) resistor r=58.3583
    rD_88 (D_28 D_33) resistor r=4.16253
    rD_87 (D_28 D_41) resistor r=4.16253
    rD_86 (D_28 D_52) resistor r=6.30933
    rD_85 (D_28 D_46) resistor r=6.30933
    rD_84 (D_28 D_30) resistor r=1.63969
    rD_83 (D_28 D_38) resistor r=4.16253
    rD_82 (D_28 D_55) resistor r=4.16253
    rD_81 (D_28 D_33) resistor r=24.8333
    rD_80 (D_28 D_30) resistor r=24.8333
    rD_79 (D_28 D_41) resistor r=24.8333
    rD_78 (D_28 D_38) resistor r=24.8333
    rD_77 (D_28 D_167) resistor r=47.1833
    rD_76 (D_28 D_46) resistor r=14.9
    rD_75 (D_28 D_52) resistor r=58.3583
    rD_74 (D_28 MM14_ELT_g) resistor r=7.45
    rD_73 (D_28 D_33) resistor r=4.16253
    rD_72 (D_28 D_41) resistor r=4.16253
    rD_71 (D_28 D_52) resistor r=6.30933
    rD_70 (D_28 D_46) resistor r=6.30933
    rD_69 (D_28 D_30) resistor r=1.63969
    rD_68 (D_28 D_38) resistor r=4.16253
    rD_67 (D_28 D_55) resistor r=4.16253
    rD_66 (D_55 MM14_ELT_g) resistor r=50.9083
    rD_65 (D_60 D_66) resistor r=58.3583
    rD_64 (D_60 D_66) resistor r=4.16253
    rD_63 (D_60 D_66) resistor r=58.3583
    rD_62 (D_60 D_66) resistor r=4.16253
    rD_61 (D_63 D_66) resistor r=58.3583
    rD_60 (D_63 D_66) resistor r=6.30933
    rD_59 (D_63 D_66) resistor r=58.3583
    rD_58 (D_63 D_66) resistor r=6.30933
    rD_57 (D_66 D_68) resistor r=14.9
    rD_56 (D_66 D_77) resistor r=24.8333
    rD_55 (D_66 D_74) resistor r=24.8333
    rD_54 (D_66 D_85) resistor r=24.8333
    rD_53 (D_66 D_82) resistor r=24.8333
    rD_52 (D_66 D_90) resistor r=58.3583
    rD_51 (D_66 D_93) resistor r=58.3583
    rD_50 (D_66 D_77) resistor r=4.16253
    rD_49 (D_66 D_68) resistor r=6.30933
    rD_48 (D_66 D_85) resistor r=1.63969
    rD_47 (D_66 D_74) resistor r=4.16253
    rD_46 (D_66 D_90) resistor r=4.16253
    rD_45 (D_66 D_82) resistor r=4.16253
    rD_44 (D_66 D_93) resistor r=4.16253
    rD_43 (D_66 D_68) resistor r=14.9
    rD_42 (D_66 D_181) resistor r=39.7333
    rD_41 (D_66 D_77) resistor r=24.8333
    rD_40 (D_66 D_74) resistor r=24.8333
    rD_39 (D_66 D_85) resistor r=24.8333
    rD_38 (D_66 D_82) resistor r=24.8333
    rD_37 (D_66 D_90) resistor r=58.3583
    rD_36 (D_66 MM17_ELT_g) resistor r=7.45
    rD_35 (D_66 D_77) resistor r=4.16253
    rD_34 (D_66 D_68) resistor r=6.30933
    rD_33 (D_66 D_85) resistor r=1.63969
    rD_32 (D_66 D_74) resistor r=4.16253
    rD_31 (D_66 D_90) resistor r=4.16253
    rD_30 (D_66 D_82) resistor r=4.16253
    rD_29 (D_66 D_93) resistor r=4.16253
    rD_28 (D_93 MM17_ELT_g) resistor r=50.9083
    rD_27 (D_132 D_133) resistor r=10
    rD_26 (D_132 D) resistor r=0.0866456
    rD_25 (D_133 D_202) resistor r=34.5409
    rD_24 (D_167 D_176) resistor r=9.29775
    rD_23 (D_175 D_176) resistor r=22.35
    rD_22 (D_175 D_184) resistor r=9.29775
    rD_21 (D_181 D_203) resistor r=10.0997
    rD_20 (D_183 D_184) resistor r=255.783
    rD_19 (D_183 D_203) resistor r=10.0997
    rD_18 (D_202 D_203) resistor r=0.877078
    rCPNN_358 (MM28_ELT_d CPNN) resistor r=0.01
    rCPNN_357 (CPNN_62 CPNN_68) resistor r=58.3583
    rCPNN_356 (CPNN_62 CPNN_68) resistor r=4.16253
    rCPNN_355 (CPNN_62 CPNN_68) resistor r=58.3583
    rCPNN_354 (CPNN_62 CPNN_68) resistor r=4.16253
    rCPNN_353 (CPNN_65 CPNN_68) resistor r=58.3583
    rCPNN_352 (CPNN_65 CPNN_68) resistor r=6.30933
    rCPNN_351 (CPNN_65 CPNN_68) resistor r=58.3583
    rCPNN_350 (CPNN_65 CPNN_68) resistor r=6.30933
    rCPNN_349 (CPNN_68 CPNN_70) resistor r=14.9
    rCPNN_348 (CPNN_68 CPNN_93) resistor r=24.8333
    rCPNN_347 (CPNN_68 CPNN_90) resistor r=24.8333
    rCPNN_346 (CPNN_68 CPNN_101) resistor r=24.8333
    rCPNN_345 (CPNN_68 CPNN_98) resistor r=24.8333
    rCPNN_344 (CPNN_68 CPNN_122) resistor r=58.3583
    rCPNN_343 (CPNN_68 CPNN_125) resistor r=58.3583
    rCPNN_342 (CPNN_68 CPNN_93) resistor r=4.16253
    rCPNN_341 (CPNN_68 CPNN_70) resistor r=6.30933
    rCPNN_340 (CPNN_68 CPNN_101) resistor r=1.63969
    rCPNN_339 (CPNN_68 CPNN_90) resistor r=4.16253
    rCPNN_338 (CPNN_68 CPNN_122) resistor r=4.16253
    rCPNN_337 (CPNN_68 CPNN_98) resistor r=4.16253
    rCPNN_336 (CPNN_68 CPNN_125) resistor r=4.16253
    rCPNN_335 (CPNN_68 CPNN_70) resistor r=14.9
    rCPNN_334 (CPNN_68 CPNN_512) resistor r=40.975
    rCPNN_333 (CPNN_68 CPNN_93) resistor r=24.8333
    rCPNN_332 (CPNN_68 CPNN_90) resistor r=24.8333
    rCPNN_331 (CPNN_68 CPNN_101) resistor r=24.8333
    rCPNN_330 (CPNN_68 CPNN_98) resistor r=24.8333
    rCPNN_329 (CPNN_68 CPNN_122) resistor r=58.3583
    rCPNN_328 (CPNN_68 MM0_ELT_g) resistor r=7.45
    rCPNN_327 (CPNN_68 CPNN_93) resistor r=4.16253
    rCPNN_326 (CPNN_68 CPNN_70) resistor r=6.30933
    rCPNN_325 (CPNN_68 CPNN_101) resistor r=1.63969
    rCPNN_324 (CPNN_68 CPNN_90) resistor r=4.16253
    rCPNN_323 (CPNN_68 CPNN_122) resistor r=4.16253
    rCPNN_322 (CPNN_68 CPNN_98) resistor r=4.16253
    rCPNN_321 (CPNN_68 CPNN_125) resistor r=4.16253
    rCPNN_320 (CPNN_76 CPNN_79) resistor r=14.9
    rCPNN_319 (CPNN_76 CPNN_79) resistor r=6.30933
    rCPNN_318 (CPNN_76 CPNN_79) resistor r=14.9
    rCPNN_317 (CPNN_76 CPNN_79) resistor r=6.30933
    rCPNN_316 (CPNN_79 CPNN_82) resistor r=202.392
    rCPNN_315 (CPNN_79 CPNN_85) resistor r=202.392
    rCPNN_314 (CPNN_79 CPNN_109) resistor r=24.8333
    rCPNN_313 (CPNN_79 CPNN_106) resistor r=24.8333
    rCPNN_312 (CPNN_79 CPNN_117) resistor r=24.8333
    rCPNN_311 (CPNN_79 CPNN_114) resistor r=24.8333
    rCPNN_310 (CPNN_79 CPNN_130) resistor r=202.392
    rCPNN_309 (CPNN_79 CPNN_133) resistor r=202.392
    rCPNN_308 (CPNN_79 CPNN_82) resistor r=6.30933
    rCPNN_307 (CPNN_79 CPNN_109) resistor r=1.63969
    rCPNN_306 (CPNN_79 CPNN_117) resistor r=4.16253
    rCPNN_305 (CPNN_79 CPNN_85) resistor r=4.16253
    rCPNN_304 (CPNN_79 CPNN_106) resistor r=4.16253
    rCPNN_303 (CPNN_79 CPNN_130) resistor r=4.16253
    rCPNN_302 (CPNN_79 CPNN_114) resistor r=4.16253
    rCPNN_301 (CPNN_79 CPNN_133) resistor r=4.16253
    rCPNN_300 (CPNN_79 CPNN_514) resistor r=40.975
    rCPNN_299 (CPNN_79 CPNN_82) resistor r=202.392
    rCPNN_298 (CPNN_79 CPNN_85) resistor r=202.392
    rCPNN_297 (CPNN_79 CPNN_109) resistor r=24.8333
    rCPNN_296 (CPNN_79 CPNN_106) resistor r=24.8333
    rCPNN_295 (CPNN_79 CPNN_117) resistor r=24.8333
    rCPNN_294 (CPNN_79 CPNN_114) resistor r=24.8333
    rCPNN_293 (CPNN_79 CPNN_130) resistor r=202.392
    rCPNN_292 (CPNN_79 MM1_ELT_g) resistor r=7.45
    rCPNN_291 (CPNN_79 CPNN_82) resistor r=6.30933
    rCPNN_290 (CPNN_79 CPNN_109) resistor r=1.63969
    rCPNN_289 (CPNN_79 CPNN_117) resistor r=4.16253
    rCPNN_288 (CPNN_79 CPNN_85) resistor r=4.16253
    rCPNN_287 (CPNN_79 CPNN_106) resistor r=4.16253
    rCPNN_286 (CPNN_79 CPNN_130) resistor r=4.16253
    rCPNN_285 (CPNN_79 CPNN_114) resistor r=4.16253
    rCPNN_284 (CPNN_79 CPNN_133) resistor r=4.16253
    rCPNN_283 (CPNN_125 MM0_ELT_g) resistor r=50.9083
    rCPNN_282 (CPNN_133 MM1_ELT_g) resistor r=194.942
    rCPNN_281 (CPNN_138 CPNN_144) resistor r=58.3583
    rCPNN_280 (CPNN_138 CPNN_144) resistor r=4.16253
    rCPNN_279 (CPNN_138 CPNN_144) resistor r=58.3583
    rCPNN_278 (CPNN_138 CPNN_144) resistor r=4.16253
    rCPNN_277 (CPNN_141 CPNN_144) resistor r=58.3583
    rCPNN_276 (CPNN_141 CPNN_144) resistor r=6.30933
    rCPNN_275 (CPNN_141 CPNN_144) resistor r=58.3583
    rCPNN_274 (CPNN_141 CPNN_144) resistor r=6.30933
    rCPNN_273 (CPNN_144 CPNN_146) resistor r=14.9
    rCPNN_272 (CPNN_144 CPNN_155) resistor r=24.8333
    rCPNN_271 (CPNN_144 CPNN_152) resistor r=24.8333
    rCPNN_270 (CPNN_144 CPNN_163) resistor r=24.8333
    rCPNN_269 (CPNN_144 CPNN_160) resistor r=24.8333
    rCPNN_268 (CPNN_144 CPNN_168) resistor r=58.3583
    rCPNN_267 (CPNN_144 CPNN_171) resistor r=58.3583
    rCPNN_266 (CPNN_144 CPNN_155) resistor r=4.16253
    rCPNN_265 (CPNN_144 CPNN_146) resistor r=6.30933
    rCPNN_264 (CPNN_144 CPNN_163) resistor r=1.63969
    rCPNN_263 (CPNN_144 CPNN_152) resistor r=4.16253
    rCPNN_262 (CPNN_144 CPNN_168) resistor r=4.16253
    rCPNN_261 (CPNN_144 CPNN_160) resistor r=4.16253
    rCPNN_260 (CPNN_144 CPNN_171) resistor r=4.16253
    rCPNN_259 (CPNN_144 CPNN_146) resistor r=14.9
    rCPNN_258 (CPNN_144 CPNN_548) resistor r=40.975
    rCPNN_257 (CPNN_144 CPNN_155) resistor r=24.8333
    rCPNN_256 (CPNN_144 CPNN_152) resistor r=24.8333
    rCPNN_255 (CPNN_144 CPNN_163) resistor r=24.8333
    rCPNN_254 (CPNN_144 CPNN_160) resistor r=24.8333
    rCPNN_253 (CPNN_144 CPNN_168) resistor r=58.3583
    rCPNN_252 (CPNN_144 MM16_ELT_g) resistor r=7.45
    rCPNN_251 (CPNN_144 CPNN_155) resistor r=4.16253
    rCPNN_250 (CPNN_144 CPNN_146) resistor r=6.30933
    rCPNN_249 (CPNN_144 CPNN_163) resistor r=1.63969
    rCPNN_248 (CPNN_144 CPNN_152) resistor r=4.16253
    rCPNN_247 (CPNN_144 CPNN_168) resistor r=4.16253
    rCPNN_246 (CPNN_144 CPNN_160) resistor r=4.16253
    rCPNN_245 (CPNN_144 CPNN_171) resistor r=4.16253
    rCPNN_244 (CPNN_171 MM16_ELT_g) resistor r=50.9083
    rCPNN_243 (CPNN_176 CPNN_182) resistor r=58.3583
    rCPNN_242 (CPNN_176 CPNN_182) resistor r=4.16253
    rCPNN_241 (CPNN_176 CPNN_182) resistor r=58.3583
    rCPNN_240 (CPNN_176 CPNN_182) resistor r=4.16253
    rCPNN_239 (CPNN_179 CPNN_182) resistor r=58.3583
    rCPNN_238 (CPNN_179 CPNN_182) resistor r=4.16253
    rCPNN_237 (CPNN_179 CPNN_182) resistor r=58.3583
    rCPNN_236 (CPNN_179 CPNN_182) resistor r=4.16253
    rCPNN_235 (CPNN_182 CPNN_187) resistor r=24.8333
    rCPNN_234 (CPNN_182 CPNN_184) resistor r=24.8333
    rCPNN_233 (CPNN_182 CPNN_195) resistor r=24.8333
    rCPNN_232 (CPNN_182 CPNN_192) resistor r=24.8333
    rCPNN_231 (CPNN_182 CPNN_200) resistor r=14.9
    rCPNN_230 (CPNN_182 CPNN_206) resistor r=58.3583
    rCPNN_229 (CPNN_182 CPNN_209) resistor r=58.3583
    rCPNN_228 (CPNN_182 CPNN_187) resistor r=4.16253
    rCPNN_227 (CPNN_182 CPNN_195) resistor r=4.16253
    rCPNN_226 (CPNN_182 CPNN_206) resistor r=6.30933
    rCPNN_225 (CPNN_182 CPNN_200) resistor r=6.30933
    rCPNN_224 (CPNN_182 CPNN_184) resistor r=1.63969
    rCPNN_223 (CPNN_182 CPNN_192) resistor r=4.16253
    rCPNN_222 (CPNN_182 CPNN_209) resistor r=4.16253
    rCPNN_221 (CPNN_182 CPNN_187) resistor r=24.8333
    rCPNN_220 (CPNN_182 CPNN_184) resistor r=24.8333
    rCPNN_219 (CPNN_182 CPNN_195) resistor r=24.8333
    rCPNN_218 (CPNN_182 CPNN_192) resistor r=24.8333
    rCPNN_217 (CPNN_182 CPNN_570) resistor r=47.1833
    rCPNN_216 (CPNN_182 CPNN_200) resistor r=14.9
    rCPNN_215 (CPNN_182 CPNN_206) resistor r=58.3583
    rCPNN_214 (CPNN_182 MM10_ELT_g) resistor r=7.45
    rCPNN_213 (CPNN_182 CPNN_187) resistor r=4.16253
    rCPNN_212 (CPNN_182 CPNN_195) resistor r=4.16253
    rCPNN_211 (CPNN_182 CPNN_206) resistor r=6.30933
    rCPNN_210 (CPNN_182 CPNN_200) resistor r=6.30933
    rCPNN_209 (CPNN_182 CPNN_184) resistor r=1.63969
    rCPNN_208 (CPNN_182 CPNN_192) resistor r=4.16253
    rCPNN_207 (CPNN_182 CPNN_209) resistor r=4.16253
    rCPNN_206 (CPNN_209 MM10_ELT_g) resistor r=50.9083
    rCPNN_205 (CPNN_214 CPNN_220) resistor r=58.3583
    rCPNN_204 (CPNN_214 CPNN_220) resistor r=4.16253
    rCPNN_203 (CPNN_214 CPNN_220) resistor r=58.3583
    rCPNN_202 (CPNN_214 CPNN_220) resistor r=4.16253
    rCPNN_201 (CPNN_217 CPNN_220) resistor r=58.3583
    rCPNN_200 (CPNN_217 CPNN_220) resistor r=6.30933
    rCPNN_199 (CPNN_217 CPNN_220) resistor r=58.3583
    rCPNN_198 (CPNN_217 CPNN_220) resistor r=6.30933
    rCPNN_197 (CPNN_220 CPNN_222) resistor r=14.9
    rCPNN_196 (CPNN_220 CPNN_231) resistor r=24.8333
    rCPNN_195 (CPNN_220 CPNN_228) resistor r=24.8333
    rCPNN_194 (CPNN_220 CPNN_239) resistor r=24.8333
    rCPNN_193 (CPNN_220 CPNN_236) resistor r=24.8333
    rCPNN_192 (CPNN_220 CPNN_244) resistor r=58.3583
    rCPNN_191 (CPNN_220 CPNN_247) resistor r=58.3583
    rCPNN_190 (CPNN_220 CPNN_231) resistor r=4.16253
    rCPNN_189 (CPNN_220 CPNN_222) resistor r=6.30933
    rCPNN_188 (CPNN_220 CPNN_239) resistor r=1.63969
    rCPNN_187 (CPNN_220 CPNN_228) resistor r=4.16253
    rCPNN_186 (CPNN_220 CPNN_244) resistor r=4.16253
    rCPNN_185 (CPNN_220 CPNN_236) resistor r=4.16253
    rCPNN_184 (CPNN_220 CPNN_247) resistor r=4.16253
    rCPNN_183 (CPNN_220 CPNN_222) resistor r=14.9
    rCPNN_182 (CPNN_220 CPNN_584) resistor r=39.7333
    rCPNN_181 (CPNN_220 CPNN_231) resistor r=24.8333
    rCPNN_180 (CPNN_220 CPNN_228) resistor r=24.8333
    rCPNN_179 (CPNN_220 CPNN_239) resistor r=24.8333
    rCPNN_178 (CPNN_220 CPNN_236) resistor r=24.8333
    rCPNN_177 (CPNN_220 CPNN_244) resistor r=58.3583
    rCPNN_176 (CPNN_220 MM7_g) resistor r=7.45
    rCPNN_175 (CPNN_220 CPNN_231) resistor r=4.16253
    rCPNN_174 (CPNN_220 CPNN_222) resistor r=6.30933
    rCPNN_173 (CPNN_220 CPNN_239) resistor r=1.63969
    rCPNN_172 (CPNN_220 CPNN_228) resistor r=4.16253
    rCPNN_171 (CPNN_220 CPNN_244) resistor r=4.16253
    rCPNN_170 (CPNN_220 CPNN_236) resistor r=4.16253
    rCPNN_169 (CPNN_220 CPNN_247) resistor r=4.16253
    rCPNN_168 (CPNN_247 MM7_g) resistor r=50.9083
    rCPNN_167 (CPNN_252 CPNN_255) resistor r=14.9
    rCPNN_166 (CPNN_252 CPNN_255) resistor r=6.30933
    rCPNN_165 (CPNN_252 CPNN_255) resistor r=14.9
    rCPNN_164 (CPNN_252 CPNN_255) resistor r=6.30933
    rCPNN_163 (CPNN_255 CPNN_258) resistor r=58.3583
    rCPNN_162 (CPNN_255 CPNN_261) resistor r=58.3583
    rCPNN_161 (CPNN_255 CPNN_269) resistor r=24.8333
    rCPNN_160 (CPNN_255 CPNN_266) resistor r=24.8333
    rCPNN_159 (CPNN_255 CPNN_277) resistor r=24.8333
    rCPNN_158 (CPNN_255 CPNN_274) resistor r=24.8333
    rCPNN_157 (CPNN_255 CPNN_282) resistor r=58.3583
    rCPNN_156 (CPNN_255 CPNN_285) resistor r=58.3583
    rCPNN_155 (CPNN_255 CPNN_258) resistor r=6.30933
    rCPNN_154 (CPNN_255 CPNN_269) resistor r=1.63969
    rCPNN_153 (CPNN_255 CPNN_277) resistor r=4.16253
    rCPNN_152 (CPNN_255 CPNN_261) resistor r=4.16253
    rCPNN_151 (CPNN_255 CPNN_266) resistor r=4.16253
    rCPNN_150 (CPNN_255 CPNN_282) resistor r=4.16253
    rCPNN_149 (CPNN_255 CPNN_274) resistor r=4.16253
    rCPNN_148 (CPNN_255 CPNN_285) resistor r=4.16253
    rCPNN_147 (CPNN_255 CPNN_597) resistor r=39.7333
    rCPNN_146 (CPNN_255 CPNN_258) resistor r=58.3583
    rCPNN_145 (CPNN_255 CPNN_261) resistor r=58.3583
    rCPNN_144 (CPNN_255 CPNN_269) resistor r=24.8333
    rCPNN_143 (CPNN_255 CPNN_266) resistor r=24.8333
    rCPNN_142 (CPNN_255 CPNN_277) resistor r=24.8333
    rCPNN_141 (CPNN_255 CPNN_274) resistor r=24.8333
    rCPNN_140 (CPNN_255 CPNN_282) resistor r=58.3583
    rCPNN_139 (CPNN_255 MM6_g) resistor r=7.45
    rCPNN_138 (CPNN_255 CPNN_258) resistor r=6.30933
    rCPNN_137 (CPNN_255 CPNN_269) resistor r=1.63969
    rCPNN_136 (CPNN_255 CPNN_277) resistor r=4.16253
    rCPNN_135 (CPNN_255 CPNN_261) resistor r=4.16253
    rCPNN_134 (CPNN_255 CPNN_266) resistor r=4.16253
    rCPNN_133 (CPNN_255 CPNN_282) resistor r=4.16253
    rCPNN_132 (CPNN_255 CPNN_274) resistor r=4.16253
    rCPNN_131 (CPNN_255 CPNN_285) resistor r=4.16253
    rCPNN_130 (CPNN_285 MM6_g) resistor r=50.9083
    rCPNN_129 (CPNN_391 CPNN_393) resistor r=0.399637
    rCPNN_128 (CPNN_391 CPNN_408) resistor r=0.096078
    rCPNN_127 (CPNN_393 CPNN_394) resistor r=13
    rCPNN_126 (CPNN_394 MM29_ELT_d) resistor r=8.44
    rCPNN_125 (CPNN_396 CPNN_398) resistor r=0.399637
    rCPNN_124 (CPNN_396 CPNN_410) resistor r=0.096078
    rCPNN_123 (CPNN_398 CPNN_399) resistor r=8.66667
    rCPNN_122 (CPNN_398 CPNN_401) resistor r=0.639419
    rCPNN_121 (CPNN_399 CPNN) resistor r=32.3614
    rCPNN_120 (CPNN_401 CPNN_402) resistor r=8.66667
    rCPNN_119 (CPNN_401 CPNN_404) resistor r=0.426279
    rCPNN_118 (CPNN_402 CPNN) resistor r=16.1807
    rCPNN_117 (CPNN_402 CPNN_405) resistor r=32.3614
    rCPNN_116 (CPNN_404 CPNN_405) resistor r=26
    rCPNN_115 (CPNN_407 CPNN_408) resistor r=0.346855
    rCPNN_114 (CPNN_407 CPNN_411) resistor r=0.0964246
    rCPNN_113 (CPNN_409 CPNN_410) resistor r=0.28985
    rCPNN_112 (CPNN_409 CPNN_414) resistor r=0.0964246
    rCPNN_111 (CPNN_411 CPNN_412) resistor r=0.119861
    rCPNN_110 (CPNN_412 CPNN_423) resistor r=0.110292
    rCPNN_109 (CPNN_413 CPNN_414) resistor r=0.196571
    rCPNN_108 (CPNN_413 CPNN_423) resistor r=0.110292
    rCPNN_107 (CPNN_416 CPNN_425) resistor r=0.144105
    rCPNN_106 (CPNN_416 CPNN_424) resistor r=0.0962173
    rCPNN_105 (CPNN_417 CPNN_419) resistor r=0.104821
    rCPNN_104 (CPNN_417 CPNN_425) resistor r=0.133555
    rCPNN_103 (CPNN_419 CPNN_420) resistor r=10
    rCPNN_102 (CPNN_420 CPNN_636) resistor r=22.35
    rCPNN_101 (CPNN_422 CPNN_423) resistor r=0.00724043
    rCPNN_100 (CPNN_422 CPNN_429) resistor r=0.00846647
    rCPNN_99 (CPNN_424 CPNN_442) resistor r=0.635549
    rCPNN_98 (CPNN_426 CPNN_428) resistor r=0.342684
    rCPNN_97 (CPNN_426 CPNN_431) resistor r=0.0765118
    rCPNN_96 (CPNN_428 CPNN_429) resistor r=0.75
    rCPNN_95 (CPNN_429 CPNN_656) resistor r=10
    rCPNN_94 (CPNN_431 CPNN_432) resistor r=0.806086
    rCPNN_93 (CPNN_432 CPNN_434) resistor r=0.0765118
    rCPNN_92 (CPNN_433 CPNN_436) resistor r=1.3528
    rCPNN_91 (CPNN_433 CPNN_439) resistor r=0.0765118
    rCPNN_90 (CPNN_434 CPNN_436) resistor r=0.832177
    rCPNN_89 (CPNN_436 CPNN_437) resistor r=0.75
    rCPNN_88 (CPNN_437 CPNN_646) resistor r=10
    rCPNN_87 (CPNN_438 CPNN_441) resistor r=0.403112
    rCPNN_86 (CPNN_438 CPNN_443) resistor r=0.0765118
    rCPNN_85 (CPNN_439 CPNN_441) resistor r=0.479491
    rCPNN_84 (CPNN_441 CPNN_442) resistor r=0.75
    rCPNN_83 (CPNN_443 CPNN_445) resistor r=1.23272
    rCPNN_82 (CPNN_445 CPNN_446) resistor r=0.75
    rCPNN_81 (CPNN_446 CPNN_652) resistor r=10
    rCPNN_80 (CPNN_512 CPNN_656) resistor r=10.0997
    rCPNN_79 (CPNN_514 CPNN_656) resistor r=10.0997
    rCPNN_78 (CPNN_526 CPNN_527) resistor r=83.9818
    rCPNN_77 (CPNN_526 CPNN_548) resistor r=9.29775
    rCPNN_76 (CPNN_527 CPNN_656) resistor r=0.877078
    rCPNN_75 (CPNN_570 CPNN_631) resistor r=4.38767
    rCPNN_74 (CPNN_584 CPNN_636) resistor r=9.29775
    rCPNN_73 (CPNN_597 CPNN_640) resistor r=4.38767
    rCPNN_72 (CPNN_630 CPNN_631) resistor r=3.71511
    rCPNN_71 (CPNN_630 CPNN_646) resistor r=14.9
    rCPNN_70 (CPNN_639 CPNN_640) resistor r=3.71511
    rCPNN_69 (CPNN_639 CPNN_652) resistor r=5.41818
    rCP_93 (CP_22 CP_28) resistor r=58.3583
    rCP_92 (CP_22 CP_28) resistor r=4.16253
    rCP_91 (CP_22 CP_28) resistor r=58.3583
    rCP_90 (CP_22 CP_28) resistor r=4.16253
    rCP_89 (CP_25 CP_28) resistor r=58.3583
    rCP_88 (CP_25 CP_28) resistor r=6.30933
    rCP_87 (CP_25 CP_28) resistor r=58.3583
    rCP_86 (CP_25 CP_28) resistor r=6.30933
    rCP_85 (CP_28 CP_30) resistor r=14.9
    rCP_84 (CP_28 CP_53) resistor r=24.8333
    rCP_83 (CP_28 CP_50) resistor r=24.8333
    rCP_82 (CP_28 CP_61) resistor r=24.8333
    rCP_81 (CP_28 CP_58) resistor r=24.8333
    rCP_80 (CP_28 CP_82) resistor r=58.3583
    rCP_79 (CP_28 CP_85) resistor r=58.3583
    rCP_78 (CP_28 CP_53) resistor r=4.16253
    rCP_77 (CP_28 CP_30) resistor r=6.30933
    rCP_76 (CP_28 CP_61) resistor r=1.63969
    rCP_75 (CP_28 CP_50) resistor r=4.16253
    rCP_74 (CP_28 CP_82) resistor r=4.16253
    rCP_73 (CP_28 CP_58) resistor r=4.16253
    rCP_72 (CP_28 CP_85) resistor r=4.16253
    rCP_71 (CP_28 CP_30) resistor r=14.9
    rCP_70 (CP_28 CP_161) resistor r=40.975
    rCP_69 (CP_28 CP_53) resistor r=24.8333
    rCP_68 (CP_28 CP_50) resistor r=24.8333
    rCP_67 (CP_28 CP_61) resistor r=24.8333
    rCP_66 (CP_28 CP_58) resistor r=24.8333
    rCP_65 (CP_28 CP_82) resistor r=58.3583
    rCP_64 (CP_28 MM29_ELT_g) resistor r=7.45
    rCP_63 (CP_28 CP_53) resistor r=4.16253
    rCP_62 (CP_28 CP_30) resistor r=6.30933
    rCP_61 (CP_28 CP_61) resistor r=1.63969
    rCP_60 (CP_28 CP_50) resistor r=4.16253
    rCP_59 (CP_28 CP_82) resistor r=4.16253
    rCP_58 (CP_28 CP_58) resistor r=4.16253
    rCP_57 (CP_28 CP_85) resistor r=4.16253
    rCP_56 (CP_36 CP_39) resistor r=14.9
    rCP_55 (CP_36 CP_39) resistor r=6.30933
    rCP_54 (CP_36 CP_39) resistor r=14.9
    rCP_53 (CP_36 CP_39) resistor r=6.30933
    rCP_52 (CP_39 CP_42) resistor r=202.392
    rCP_51 (CP_39 CP_45) resistor r=202.392
    rCP_50 (CP_39 CP_69) resistor r=24.8333
    rCP_49 (CP_39 CP_66) resistor r=24.8333
    rCP_48 (CP_39 CP_77) resistor r=24.8333
    rCP_47 (CP_39 CP_74) resistor r=24.8333
    rCP_46 (CP_39 CP_90) resistor r=202.392
    rCP_45 (CP_39 CP_93) resistor r=202.392
    rCP_44 (CP_39 CP_42) resistor r=6.30933
    rCP_43 (CP_39 CP_69) resistor r=1.63969
    rCP_42 (CP_39 CP_77) resistor r=4.16253
    rCP_41 (CP_39 CP_45) resistor r=4.16253
    rCP_40 (CP_39 CP_66) resistor r=4.16253
    rCP_39 (CP_39 CP_90) resistor r=4.16253
    rCP_38 (CP_39 CP_74) resistor r=4.16253
    rCP_37 (CP_39 CP_93) resistor r=4.16253
    rCP_36 (CP_39 CP_163) resistor r=40.975
    rCP_35 (CP_39 CP_42) resistor r=202.392
    rCP_34 (CP_39 CP_45) resistor r=202.392
    rCP_33 (CP_39 CP_69) resistor r=24.8333
    rCP_32 (CP_39 CP_66) resistor r=24.8333
    rCP_31 (CP_39 CP_77) resistor r=24.8333
    rCP_30 (CP_39 CP_74) resistor r=24.8333
    rCP_29 (CP_39 CP_90) resistor r=202.392
    rCP_28 (CP_39 MM28_ELT_g) resistor r=7.45
    rCP_27 (CP_39 CP_42) resistor r=6.30933
    rCP_26 (CP_39 CP_69) resistor r=1.63969
    rCP_25 (CP_39 CP_77) resistor r=4.16253
    rCP_24 (CP_39 CP_45) resistor r=4.16253
    rCP_23 (CP_39 CP_66) resistor r=4.16253
    rCP_22 (CP_39 CP_90) resistor r=4.16253
    rCP_21 (CP_39 CP_74) resistor r=4.16253
    rCP_20 (CP_39 CP_93) resistor r=4.16253
    rCP_19 (CP_85 MM29_ELT_g) resistor r=50.9083
    rCP_18 (CP_93 MM28_ELT_g) resistor r=194.942
    rCP_17 (CP_133 CP) resistor r=10
    rCP_16 (CP_133 CP_201) resistor r=0.677273
    rCP_15 (CP_161 CP_201) resistor r=5.23411
    rCP_14 (CP_163 CP_201) resistor r=5.23411
ends DFCNQD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DEL0D1_LVT_ELT
// View name: calibre
subckt DEL0D1_LVT_ELT I VDD VSS Z
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM19_ELT (MM19_ELT_d MM19_ELT_g MM19_ELT_s MM19_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=6.8675e-13 pd=1.34e-06 \
        ps=5.73e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.93575e-13 pd=3.66e-06 \
        ps=7.295e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.93575e-13 pd=3.66e-06 \
        ps=7.295e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.0485e-13 pd=1.34e-06 \
        ps=4.77e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM20_ELT (MM20_ELT_d MM20_ELT_g MM20_ELT_s MM20_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet33_7 (net33_4 VSS) capacitor c=5.08287e-18
    cinet33_6 (net33_6 VSS) capacitor c=1.64973e-18
    cinet33_5 (net33_9 VSS) capacitor c=1.06831e-17
    cinet33_4 (MM20_ELT_s VSS) capacitor c=1.30542e-17
    cinet33_3 (net33_13 VSS) capacitor c=1.8247e-17
    cinet33_2 (net33_15 VSS) capacitor c=4.3347e-18
    cinet33_1 (net33_18 VSS) capacitor c=1.71175e-18
    cinet33_0 (net33_20 VSS) capacitor c=6.74688e-18
    ciZ_8 (Z_3 VSS) capacitor c=4.47361e-17
    ciZ_7 (Z_4 VSS) capacitor c=1.11643e-16
    ciZ_6 (Z_8 VSS) capacitor c=1.75756e-16
    ciZ_5 (Z_9 VSS) capacitor c=3.29382e-16
    ciZ_4 (Z_17 VSS) capacitor c=2.27488e-17
    ciZ_3 (Z_18 VSS) capacitor c=1.4946e-17
    ciZ_2 (Z_19 VSS) capacitor c=2.12404e-17
    ciZ_1 (Z_20 VSS) capacitor c=6.39079e-18
    ciZ_0 (Z VSS) capacitor c=7.0183e-17
    ciU_29 (U_22 VSS) capacitor c=4.28147e-18
    ciU_28 (U_28 VSS) capacitor c=1.94374e-16
    ciU_27 (U_39 VSS) capacitor c=5.68131e-16
    ciU_26 (U_45 VSS) capacitor c=5.13601e-18
    ciU_25 (U_50 VSS) capacitor c=2.23559e-17
    ciU_24 (U_58 VSS) capacitor c=1.51948e-17
    ciU_23 (U_66 VSS) capacitor c=1.88601e-17
    ciU_22 (U_74 VSS) capacitor c=9.56216e-18
    ciU_21 (U_82 VSS) capacitor c=2.11871e-18
    ciU_20 (U_85 VSS) capacitor c=2.742e-18
    ciU_19 (U_90 VSS) capacitor c=2.43312e-19
    ciU_18 (U_93 VSS) capacitor c=2.22299e-18
    ciU_17 (U_133 VSS) capacitor c=6.78347e-17
    ciU_16 (U_134 VSS) capacitor c=1.12229e-16
    ciU_15 (U_136 VSS) capacitor c=1.32713e-16
    ciU_14 (U_137 VSS) capacitor c=1.46749e-17
    ciU_13 (U_140 VSS) capacitor c=3.31446e-17
    ciU_12 (U_141 VSS) capacitor c=1.36256e-16
    ciU_11 (U_143 VSS) capacitor c=8.04918e-17
    ciU_10 (U_144 VSS) capacitor c=8.04402e-18
    ciU_9 (U_146 VSS) capacitor c=1.05249e-16
    ciU_8 (U_148 VSS) capacitor c=1.82677e-16
    ciU_7 (U_149 VSS) capacitor c=7.63537e-17
    ciU_6 (U_150 VSS) capacitor c=1.64437e-17
    ciU_5 (U_151 VSS) capacitor c=1.87535e-17
    ciU_4 (U_152 VSS) capacitor c=6.63083e-18
    ciU_3 (U_155 VSS) capacitor c=1.37167e-17
    ciU_2 (U_157 VSS) capacitor c=2.13352e-17
    ciU_1 (U_217 VSS) capacitor c=2.86857e-17
    ciU_0 (U_218 VSS) capacitor c=1.65925e-17
    ciVDD_30 (VDD_4 VSS) capacitor c=4.25294e-17
    ciVDD_29 (VDD_7 VSS) capacitor c=6.27536e-17
    ciVDD_28 (VDD_8 VSS) capacitor c=2.63453e-17
    ciVDD_27 (VDD_17 VSS) capacitor c=5.52703e-17
    ciVDD_26 (VDD_18 VSS) capacitor c=1.17049e-16
    ciVDD_25 (VDD_20 VSS) capacitor c=6.71484e-17
    ciVDD_24 (VDD_27 VSS) capacitor c=6.89183e-17
    ciVDD_23 (VDD_28 VSS) capacitor c=8.85214e-17
    ciVDD_22 (VDD_30 VSS) capacitor c=1.09493e-16
    ciVDD_21 (VDD_40 VSS) capacitor c=2.37765e-16
    ciVDD_20 (VDD_48 VSS) capacitor c=3.64916e-16
    ciVDD_19 (VDD_51 VSS) capacitor c=7.2346e-17
    ciVDD_18 (VDD_58 VSS) capacitor c=3.58509e-18
    ciVDD_17 (VDD_60 VSS) capacitor c=3.58509e-18
    ciVDD_16 (VDD_62 VSS) capacitor c=3.58509e-18
    ciVDD_15 (VDD_68 VSS) capacitor c=1.71175e-18
    ciVDD_14 (VDD_69 VSS) capacitor c=5.39305e-18
    ciVDD_13 (VDD_70 VSS) capacitor c=1.64973e-18
    ciVDD_12 (VDD_73 VSS) capacitor c=9.22812e-18
    ciVDD_11 (VDD_74 VSS) capacitor c=1.5701e-17
    ciVDD_10 (VDD_78 VSS) capacitor c=1.71175e-18
    ciVDD_9 (VDD_80 VSS) capacitor c=9.73151e-18
    ciVDD_8 (MM17_ELT_s VSS) capacitor c=4.95818e-17
    ciVDD_7 (VDD_85 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_87 VSS) capacitor c=7.99435e-18
    ciVDD_5 (VDD_91 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_92 VSS) capacitor c=8.79289e-18
    ciVDD_3 (VDD_93 VSS) capacitor c=1.07074e-18
    ciVDD_2 (VDD_96 VSS) capacitor c=2.18215e-17
    ciVDD_1 (VDD_97 VSS) capacitor c=7.25634e-17
    ciVDD_0 (VDD_101 VSS) capacitor c=1.23038e-17
    ciVSS_24 (VSS_4 VSS) capacitor c=4.93988e-17
    ciVSS_23 (VSS_10 VSS) capacitor c=4.57303e-17
    ciVSS_22 (VSS_11 VSS) capacitor c=2.63635e-17
    ciVSS_21 (VSS_17 VSS) capacitor c=8.20901e-17
    ciVSS_20 (VSS_18 VSS) capacitor c=7.92333e-19
    ciVSS_19 (VSS_23 VSS) capacitor c=8.66552e-17
    ciVSS_18 (VSS_30 VSS) capacitor c=5.45629e-17
    ciVSS_17 (VSS_31 VSS) capacitor c=9.44517e-17
    ciVSS_16 (VSS_33 VSS) capacitor c=1.01258e-16
    ciVSS_15 (VSS_43 VSS) capacitor c=9.82778e-17
    ciVSS_14 (VSS_47 VSS) capacitor c=1.36362e-16
    ciVSS_13 (VSS_51 VSS) capacitor c=7.05673e-17
    ciVSS_12 (VSS_59 VSS) capacitor c=3.58509e-18
    ciVSS_11 (VSS_62 VSS) capacitor c=3.58509e-18
    ciVSS_10 (VSS_64 VSS) capacitor c=3.58509e-18
    ciVSS_9 (MM1_ELT_s VSS) capacitor c=7.22449e-18
    ciVSS_8 (VSS_82 VSS) capacitor c=7.64858e-18
    ciVSS_7 (MM3_ELT_s VSS) capacitor c=1.112e-18
    ciVSS_6 (VSS_88 VSS) capacitor c=2.05562e-17
    ciVSS_5 (VSS_89 VSS) capacitor c=2.65044e-18
    ciVSS_4 (MM19_ELT_s VSS) capacitor c=6.15703e-18
    ciVSS_3 (VSS_101 VSS) capacitor c=7.39733e-18
    ciVSS_2 (VSS_105 VSS) capacitor c=6.23788e-18
    ciVSS_1 (VSS_116 VSS) capacitor c=7.02138e-17
    ciVSS_0 (VSS_118 VSS) capacitor c=7.1846e-17
    cinet32_7 (net32_3 VSS) capacitor c=5.38897e-17
    cinet32_6 (net32_4 VSS) capacitor c=1.12713e-16
    cinet32_5 (net32_6 VSS) capacitor c=7.71524e-17
    cinet32_4 (net32_7 VSS) capacitor c=1.6068e-17
    cinet32_3 (net32_10 VSS) capacitor c=1.58268e-16
    cinet32_2 (net32_16 VSS) capacitor c=1.03368e-18
    cinet32_1 (net32_21 VSS) capacitor c=4.91402e-18
    cinet32_0 (net32_22 VSS) capacitor c=7.73492e-17
    cinet015_25 (net015_12 VSS) capacitor c=5.7174e-18
    cinet015_24 (net015_15 VSS) capacitor c=3.23582e-18
    cinet015_23 (net015_18 VSS) capacitor c=2.04666e-16
    cinet015_22 (net015_20 VSS) capacitor c=2.33089e-17
    cinet015_21 (net015_28 VSS) capacitor c=2.24535e-17
    cinet015_20 (net015_36 VSS) capacitor c=4.22457e-18
    cinet015_19 (net015_66 VSS) capacitor c=5.62229e-17
    cinet015_18 (net015_67 VSS) capacitor c=1.18372e-17
    cinet015_17 (net015_70 VSS) capacitor c=8.39955e-17
    cinet015_16 (net015_71 VSS) capacitor c=3.64583e-16
    cinet015_15 (net015_75 VSS) capacitor c=9.98483e-17
    cinet015_14 (net015_83 VSS) capacitor c=7.53255e-17
    cinet015_13 (net015_84 VSS) capacitor c=1.1169e-16
    cinet015_12 (net015_88 VSS) capacitor c=8.05599e-18
    cinet015_11 (net015_91 VSS) capacitor c=9.8181e-18
    cinet015_10 (net015_92 VSS) capacitor c=3.70017e-17
    cinet015_9 (net015_99 VSS) capacitor c=5.68408e-17
    cinet015_8 (net015_100 VSS) capacitor c=1.96691e-16
    cinet015_7 (net015_102 VSS) capacitor c=4.42839e-17
    cinet015_6 (net015_106 VSS) capacitor c=9.40793e-18
    cinet015_5 (net015_107 VSS) capacitor c=4.39374e-17
    cinet015_4 (net015_111 VSS) capacitor c=5.57351e-18
    cinet015_3 (net015_112 VSS) capacitor c=1.51507e-17
    cinet015_2 (net015_146 VSS) capacitor c=2.37806e-17
    cinet015_1 (net015_147 VSS) capacitor c=3.33723e-17
    cinet015_0 (net015_150 VSS) capacitor c=1.23423e-16
    ciY_30 (Y_22 VSS) capacitor c=4.15066e-18
    ciY_29 (Y_28 VSS) capacitor c=1.95637e-16
    ciY_28 (Y_36 VSS) capacitor c=2.24195e-17
    ciY_27 (Y_44 VSS) capacitor c=2.12383e-17
    ciY_26 (Y_52 VSS) capacitor c=2.96645e-18
    ciY_25 (Y_55 VSS) capacitor c=6.49523e-18
    ciY_24 (Y_60 VSS) capacitor c=4.11737e-18
    ciY_23 (Y_63 VSS) capacitor c=3.2371e-18
    ciY_22 (Y_66 VSS) capacitor c=1.90514e-16
    ciY_21 (Y_68 VSS) capacitor c=1.98618e-17
    ciY_20 (Y_76 VSS) capacitor c=2.2351e-17
    ciY_19 (Y_87 VSS) capacitor c=3.36897e-18
    ciY_18 (Y_131 VSS) capacitor c=4.63615e-17
    ciY_17 (Y_133 VSS) capacitor c=1.7109e-17
    ciY_16 (Y_134 VSS) capacitor c=1.20565e-17
    ciY_15 (Y_137 VSS) capacitor c=4.24225e-17
    ciY_14 (Y_138 VSS) capacitor c=1.20475e-16
    ciY_13 (Y_140 VSS) capacitor c=2.52933e-17
    ciY_12 (Y_141 VSS) capacitor c=3.86514e-17
    ciY_11 (Y_142 VSS) capacitor c=1.69271e-16
    ciY_10 (Y_148 VSS) capacitor c=5.16483e-17
    ciY_9 (Y_149 VSS) capacitor c=5.30803e-17
    ciY_8 (Y_154 VSS) capacitor c=1.19747e-16
    ciY_7 (Y_156 VSS) capacitor c=7.98882e-18
    ciY_6 (Y_158 VSS) capacitor c=5.32085e-17
    ciY_5 (Y_159 VSS) capacitor c=2.20236e-17
    ciY_4 (Y_161 VSS) capacitor c=8.60668e-17
    ciY_3 (Y_162 VSS) capacitor c=4.01155e-17
    ciY_2 (Y_166 VSS) capacitor c=2.71285e-17
    ciY_1 (Y_192 VSS) capacitor c=1.42884e-17
    ciY_0 (Y_221 VSS) capacitor c=9.80409e-18
    cinet34_10 (net34_3 VSS) capacitor c=7.46182e-17
    cinet34_9 (net34_8 VSS) capacitor c=3.95474e-17
    cinet34_8 (net34_9 VSS) capacitor c=1.37938e-16
    cinet34_7 (net34_11 VSS) capacitor c=7.42713e-17
    cinet34_6 (net34_12 VSS) capacitor c=1.01625e-17
    cinet34_5 (net34_13 VSS) capacitor c=3.98506e-17
    cinet34_4 (net34_14 VSS) capacitor c=1.52233e-17
    cinet34_3 (net34_16 VSS) capacitor c=6.54312e-17
    cinet34_2 (net34_22 VSS) capacitor c=2.56664e-18
    cinet34_1 (net34_25 VSS) capacitor c=6.99478e-18
    cinet34_0 (net34_26 VSS) capacitor c=8.49508e-17
    ciX_63 (X_64 VSS) capacitor c=1.40626e-18
    ciX_62 (X_67 VSS) capacitor c=2.83193e-18
    ciX_61 (X_70 VSS) capacitor c=1.24712e-16
    ciX_60 (X_72 VSS) capacitor c=3.00043e-18
    ciX_59 (X_75 VSS) capacitor c=2.05848e-18
    ciX_58 (X_78 VSS) capacitor c=2.18977e-16
    ciX_57 (X_80 VSS) capacitor c=1.57744e-17
    ciX_56 (X_88 VSS) capacitor c=2.17037e-17
    ciX_55 (X_96 VSS) capacitor c=2.23559e-17
    ciX_54 (X_104 VSS) capacitor c=1.3333e-17
    ciX_53 (X_118 VSS) capacitor c=1.33888e-17
    ciX_52 (X_126 VSS) capacitor c=6.30765e-18
    ciX_51 (X_132 VSS) capacitor c=2.15019e-16
    ciX_50 (X_149 VSS) capacitor c=9.04267e-19
    ciX_49 (X_154 VSS) capacitor c=2.28822e-17
    ciX_48 (X_162 VSS) capacitor c=1.91176e-17
    ciX_47 (X_170 VSS) capacitor c=4.04637e-18
    ciX_46 (X_173 VSS) capacitor c=3.64811e-18
    ciX_45 (X_178 VSS) capacitor c=5.25251e-18
    ciX_44 (X_181 VSS) capacitor c=1.84681e-18
    ciX_43 (X_186 VSS) capacitor c=3.66088e-19
    ciX_42 (X_189 VSS) capacitor c=2.49805e-18
    ciX_41 (X_192 VSS) capacitor c=1.3819e-16
    ciX_40 (X_194 VSS) capacitor c=1.91506e-17
    ciX_39 (X_202 VSS) capacitor c=2.2416e-17
    ciX_38 (X_219 VSS) capacitor c=3.84532e-18
    ciX_37 (X_224 VSS) capacitor c=2.05757e-18
    ciX_36 (X_230 VSS) capacitor c=2.12886e-16
    ciX_35 (X_241 VSS) capacitor c=6.65029e-16
    ciX_34 (X_247 VSS) capacitor c=3.49893e-18
    ciX_33 (X_252 VSS) capacitor c=2.24068e-17
    ciX_32 (X_260 VSS) capacitor c=1.5897e-17
    ciX_31 (X_268 VSS) capacitor c=1.11225e-17
    ciX_30 (X_276 VSS) capacitor c=1.53036e-17
    ciX_29 (X_284 VSS) capacitor c=3.00043e-18
    ciX_28 (X_287 VSS) capacitor c=2.44574e-18
    ciX_27 (X_292 VSS) capacitor c=5.15427e-18
    ciX_26 (X_295 VSS) capacitor c=3.85496e-18
    ciX_25 (X_412 VSS) capacitor c=4.07334e-17
    ciX_24 (X_413 VSS) capacitor c=1.1351e-16
    ciX_23 (X_417 VSS) capacitor c=4.26588e-17
    ciX_22 (X_418 VSS) capacitor c=1.25817e-16
    ciX_21 (X_422 VSS) capacitor c=2.31545e-17
    ciX_20 (X_423 VSS) capacitor c=1.35045e-17
    ciX_19 (X_424 VSS) capacitor c=2.08465e-17
    ciX_18 (X_425 VSS) capacitor c=1.33309e-17
    ciX_17 (X_427 VSS) capacitor c=2.29609e-17
    ciX_16 (X_429 VSS) capacitor c=2.03456e-17
    ciX_15 (X_433 VSS) capacitor c=3.5204e-17
    ciX_14 (X_436 VSS) capacitor c=3.05602e-17
    ciX_13 (X_442 VSS) capacitor c=1.15392e-16
    ciX_12 (X_446 VSS) capacitor c=1.24991e-17
    ciX_11 (X_447 VSS) capacitor c=1.54829e-16
    ciX_10 (X_448 VSS) capacitor c=8.26239e-18
    ciX_9 (X_451 VSS) capacitor c=9.15544e-17
    ciX_8 (X_454 VSS) capacitor c=1.97134e-16
    ciX_7 (X_455 VSS) capacitor c=6.62775e-17
    ciX_6 (X_635 VSS) capacitor c=1.9338e-17
    ciX_5 (X_636 VSS) capacitor c=2.99604e-17
    ciX_4 (X_639 VSS) capacitor c=2.40061e-17
    ciX_3 (X_640 VSS) capacitor c=1.47505e-17
    ciX_2 (X_649 VSS) capacitor c=4.32706e-17
    ciX_1 (X_662 VSS) capacitor c=9.88636e-17
    ciX_0 (X_680 VSS) capacitor c=3.84676e-17
    ciI_23 (I_35 VSS) capacitor c=1.64447e-16
    ciI_22 (I_46 VSS) capacitor c=3.00043e-18
    ciI_21 (I_49 VSS) capacitor c=2.05848e-18
    ciI_20 (I_52 VSS) capacitor c=2.14679e-16
    ciI_19 (I_57 VSS) capacitor c=2.0493e-16
    ciI_18 (I_63 VSS) capacitor c=3.77327e-18
    ciI_17 (I_68 VSS) capacitor c=2.0509e-17
    ciI_16 (I_76 VSS) capacitor c=1.60332e-17
    ciI_15 (I_84 VSS) capacitor c=2.23559e-17
    ciI_14 (I_92 VSS) capacitor c=1.94138e-17
    ciI_13 (I_100 VSS) capacitor c=1.93821e-17
    ciI_12 (I_108 VSS) capacitor c=2.23559e-17
    ciI_11 (I_116 VSS) capacitor c=2.64564e-18
    ciI_10 (I_119 VSS) capacitor c=2.20867e-18
    ciI_9 (I_124 VSS) capacitor c=3.24866e-18
    ciI_8 (I_138 VSS) capacitor c=4.60628e-18
    ciI_7 (I_141 VSS) capacitor c=4.11871e-18
    ciI_6 (I VSS) capacitor c=2.85348e-17
    ciI_5 (I_248 VSS) capacitor c=1.50909e-17
    ciI_4 (I_249 VSS) capacitor c=3.0178e-17
    ciI_3 (I_262 VSS) capacitor c=6.68016e-17
    ciI_2 (I_263 VSS) capacitor c=6.61928e-18
    ciI_1 (I_289 VSS) capacitor c=1.48185e-16
    ciI_0 (I_301 VSS) capacitor c=5.57635e-17
    rnet33_36 (net33_1 net33_4) resistor r=20.2547
    rnet33_35 (net33_1 net33_5) resistor r=9.04595
    rnet33_34 (net33_2 net33_4) resistor r=20.2547
    rnet33_33 (net33_2 net33_8) resistor r=9.04062
    rnet33_32 (MM9_ELT_d net33_4) resistor r=4.36821
    rnet33_31 (MM9_ELT_d net33_6) resistor r=12.3172
    rnet33_30 (MM9_ELT_d net33_6) resistor r=1.62887
    rnet33_29 (MM9_ELT_d net33_9) resistor r=2.55965
    rnet33_28 (MM9_ELT_d net33_13) resistor r=4.04518
    rnet33_27 (MM9_ELT_d net33_20) resistor r=10.2363
    rnet33_26 (net33_5 net33_6) resistor r=12.3172
    rnet33_25 (net33_7 net33_9) resistor r=14.4784
    rnet33_24 (net33_7 net33) resistor r=10.5593
    rnet33_23 (net33_8 net33_9) resistor r=14.4784
    rnet33_22 (net33_10 net33_13) resistor r=4.04518
    rnet33_21 (net33_10 net33_20) resistor r=0.549089
    rnet33_20 (net33_11 net33_13) resistor r=4.04518
    rnet33_19 (net33_11 net33) resistor r=0.730683
    rnet33_18 (MM20_ELT_s net33_13) resistor r=4.04518
    rnet33_17 (MM20_ELT_s net33_15) resistor r=12.3172
    rnet33_16 (MM20_ELT_s net33_15) resistor r=1.62887
    rnet33_15 (MM20_ELT_s net33_18) resistor r=2.55965
    rnet33_14 (MM20_ELT_s net33_19) resistor r=17.3029
    rnet33_13 (net33_14 net33_15) resistor r=12.3172
    rnet33_12 (net33_14 net33_20) resistor r=10.2363
    rnet33_11 (net33_16 net33_18) resistor r=14.4784
    rnet33_10 (net33_16 net33_19) resistor r=9.04062
    rnet33_9 (net33_17 net33_18) resistor r=14.4784
    rnet33_8 (net33_17 net33) resistor r=10.5593
    rZ_28 (Z_1 Z_3) resistor r=0.303814
    rZ_27 (Z_1 Z_18) resistor r=0.0961065
    rZ_26 (Z_3 Z_4) resistor r=13
    rZ_25 (Z_4 MM4_ELT_d) resistor r=8.44
    rZ_24 (Z_6 Z_8) resistor r=0.341125
    rZ_23 (Z_6 Z_20) resistor r=0.0961065
    rZ_22 (Z_8 Z_9) resistor r=8.66667
    rZ_21 (Z_8 Z_11) resistor r=0.639609
    rZ_20 (Z_9 MM7_ELT_d) resistor r=32.3614
    rZ_19 (Z_11 Z_12) resistor r=8.66667
    rZ_18 (Z_11 Z_14) resistor r=0.426406
    rZ_17 (Z_12 MM7_ELT_d) resistor r=16.1807
    rZ_16 (Z_12 Z_15) resistor r=32.3614
    rZ_15 (Z_14 Z_15) resistor r=26
    rZ_14 (Z_17 Z_18) resistor r=0.136653
    rZ_13 (Z_17 Z_21) resistor r=0.0961065
    rZ_12 (Z_19 Z_20) resistor r=0.136653
    rZ_11 (Z_19 Z_22) resistor r=0.0961065
    rZ_10 (Z_21 Z) resistor r=0.156175
    rZ_9 (Z_22 Z) resistor r=0.536344
    rU_132 (MM8_ELT_d U) resistor r=0.01
    rU_131 (U_22 U_28) resistor r=58.3583
    rU_130 (U_22 U_28) resistor r=4.16253
    rU_129 (U_22 U_28) resistor r=58.3583
    rU_128 (U_22 U_28) resistor r=4.16253
    rU_127 (U_25 U_28) resistor r=58.3583
    rU_126 (U_25 U_28) resistor r=5.53947
    rU_125 (U_25 U_28) resistor r=58.3583
    rU_124 (U_25 U_28) resistor r=5.53947
    rU_123 (U_28 U_30) resistor r=11.175
    rU_122 (U_28 U_53) resistor r=24.8333
    rU_121 (U_28 U_50) resistor r=24.8333
    rU_120 (U_28 U_69) resistor r=22.35
    rU_119 (U_28 U_66) resistor r=22.35
    rU_118 (U_28 U_82) resistor r=58.3583
    rU_117 (U_28 U_85) resistor r=58.3583
    rU_116 (U_28 U_53) resistor r=4.16253
    rU_115 (U_28 U_30) resistor r=5.53947
    rU_114 (U_28 U_69) resistor r=2.32428
    rU_113 (U_28 U_50) resistor r=4.16253
    rU_112 (U_28 U_82) resistor r=4.16253
    rU_111 (U_28 U_66) resistor r=4.16253
    rU_110 (U_28 U_85) resistor r=4.16253
    rU_109 (U_28 U_30) resistor r=11.175
    rU_108 (U_28 U_183) resistor r=29.8
    rU_107 (U_28 U_53) resistor r=24.8333
    rU_106 (U_28 U_50) resistor r=24.8333
    rU_105 (U_28 U_69) resistor r=22.35
    rU_104 (U_28 U_66) resistor r=22.35
    rU_103 (U_28 U_82) resistor r=58.3583
    rU_102 (U_28 MM4_ELT_g) resistor r=7.45
    rU_101 (U_28 U_53) resistor r=4.16253
    rU_100 (U_28 U_30) resistor r=5.53947
    rU_99 (U_28 U_69) resistor r=2.32428
    rU_98 (U_28 U_50) resistor r=4.16253
    rU_97 (U_28 U_82) resistor r=4.16253
    rU_96 (U_28 U_66) resistor r=4.16253
    rU_95 (U_28 U_85) resistor r=4.16253
    rU_94 (U_36 U_39) resistor r=11.175
    rU_93 (U_36 U_39) resistor r=5.53947
    rU_92 (U_36 U_39) resistor r=11.175
    rU_91 (U_36 U_39) resistor r=5.53947
    rU_90 (U_39 U_42) resistor r=202.392
    rU_89 (U_39 U_45) resistor r=202.392
    rU_88 (U_39 U_61) resistor r=24.8333
    rU_87 (U_39 U_58) resistor r=24.8333
    rU_86 (U_39 U_77) resistor r=22.35
    rU_85 (U_39 U_74) resistor r=22.35
    rU_84 (U_39 U_90) resistor r=202.392
    rU_83 (U_39 U_93) resistor r=202.392
    rU_82 (U_39 U_42) resistor r=5.53947
    rU_81 (U_39 U_77) resistor r=2.32428
    rU_80 (U_39 U_61) resistor r=4.16253
    rU_79 (U_39 U_45) resistor r=4.16253
    rU_78 (U_39 U_74) resistor r=4.16253
    rU_77 (U_39 U_90) resistor r=4.16253
    rU_76 (U_39 U_58) resistor r=4.16253
    rU_75 (U_39 U_93) resistor r=4.16253
    rU_74 (U_39 U_185) resistor r=31.6625
    rU_73 (U_39 U_42) resistor r=202.392
    rU_72 (U_39 U_45) resistor r=202.392
    rU_71 (U_39 U_61) resistor r=24.8333
    rU_70 (U_39 U_58) resistor r=24.8333
    rU_69 (U_39 U_77) resistor r=22.35
    rU_68 (U_39 U_74) resistor r=22.35
    rU_67 (U_39 U_90) resistor r=202.392
    rU_66 (U_39 MM7_ELT_g) resistor r=7.45
    rU_65 (U_39 U_42) resistor r=5.53947
    rU_64 (U_39 U_77) resistor r=2.32428
    rU_63 (U_39 U_61) resistor r=4.16253
    rU_62 (U_39 U_45) resistor r=4.16253
    rU_61 (U_39 U_74) resistor r=4.16253
    rU_60 (U_39 U_90) resistor r=4.16253
    rU_59 (U_39 U_58) resistor r=4.16253
    rU_58 (U_39 U_93) resistor r=4.16253
    rU_57 (U_85 MM4_ELT_g) resistor r=50.9083
    rU_56 (U_93 MM7_ELT_g) resistor r=194.942
    rU_55 (U_131 U_133) resistor r=0.451595
    rU_54 (U_131 U_137) resistor r=0.0973619
    rU_53 (U_133 U_134) resistor r=13
    rU_52 (U_134 MM5_ELT_d) resistor r=8.44
    rU_51 (U_136 U_137) resistor r=1.40941
    rU_50 (U_136 U_155) resistor r=0.0189289
    rU_49 (U_138 U_140) resistor r=0.207873
    rU_48 (U_138 U_144) resistor r=0.0961065
    rU_47 (U_140 U_141) resistor r=13
    rU_46 (U_141 U) resistor r=8.09035
    rU_45 (U_143 U_144) resistor r=0.694916
    rU_44 (U_143 U_148) resistor r=0.0961065
    rU_43 (U_145 U_146) resistor r=0.745455
    rU_42 (U_145 U_150) resistor r=0.0961065
    rU_41 (U_146 U_155) resistor r=0.0728365
    rU_40 (U_147 U_148) resistor r=1.43895
    rU_39 (U_147 U_155) resistor r=0.0728365
    rU_38 (U_149 U_150) resistor r=0.538024
    rU_37 (U_149 U_152) resistor r=0.0961065
    rU_36 (U_151 U_152) resistor r=0.0976093
    rU_35 (U_151 U_157) resistor r=0.0709044
    rU_34 (U_157 U_158) resistor r=10
    rU_33 (U_158 U_217) resistor r=7.45
    rU_32 (U_183 U_218) resistor r=3.725
    rU_31 (U_185 U_218) resistor r=3.725
    rU_30 (U_217 U_218) resistor r=3.725
    rVDD_139 (MM11_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_138 (MM9_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_137 (MM20_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_136 (MM8_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_135 (MM17_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_134 (MM7_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_133 (MM10_ELT_b VDD_60) resistor r=8.66667
    rVDD_132 (MM10_ELT_b VDD_24) resistor r=67.52
    rVDD_131 (MM10_ELT_b VDD_34) resistor r=67.52
    rVDD_130 (VDD_2 VDD_4) resistor r=0.511687
    rVDD_129 (VDD_2 VDD_57) resistor r=0.119189
    rVDD_128 (VDD_4 VDD_5) resistor r=8.66667
    rVDD_127 (VDD_5 MM11_ELT_s) resistor r=2.78649
    rVDD_126 (VDD_5 VDD_97) resistor r=11.6377
    rVDD_125 (VDD_7 VDD_13) resistor r=0.0652185
    rVDD_124 (VDD_7 VDD_58) resistor r=0.0221531
    rVDD_123 (VDD_8 VDD_10) resistor r=0.0335974
    rVDD_122 (VDD_8 VDD_57) resistor r=0.0177869
    rVDD_121 (VDD_10 VDD_11) resistor r=8.66667
    rVDD_120 (VDD_10 VDD_13) resistor r=0.237158
    rVDD_119 (VDD_11 VDD_14) resistor r=67.52
    rVDD_118 (VDD_13 VDD_14) resistor r=8.66667
    rVDD_117 (VDD_14 VDD_24) resistor r=67.52
    rVDD_116 (VDD_15 VDD_17) resistor r=0.641401
    rVDD_115 (VDD_15 VDD_58) resistor r=0.0882522
    rVDD_114 (VDD_17 VDD_18) resistor r=13
    rVDD_113 (VDD_18 MM9_ELT_s) resistor r=8.09035
    rVDD_112 (VDD_20 VDD_23) resistor r=0.221347
    rVDD_111 (VDD_20 VDD_60) resistor r=0.0221531
    rVDD_110 (VDD_21 VDD_23) resistor r=0.136366
    rVDD_109 (VDD_21 VDD_58) resistor r=0.0221531
    rVDD_108 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_107 (VDD_25 VDD_27) resistor r=0.511687
    rVDD_106 (VDD_25 VDD_60) resistor r=0.0882522
    rVDD_105 (VDD_27 VDD_28) resistor r=8.66667
    rVDD_104 (VDD_28 VDD_99) resistor r=16.4995
    rVDD_103 (VDD_28 VDD_98) resistor r=16.4995
    rVDD_102 (VDD_28 MM8_ELT_s) resistor r=3.29107
    rVDD_101 (VDD_30 VDD_36) resistor r=0.0415027
    rVDD_100 (VDD_30 VDD_62) resistor r=0.0221531
    rVDD_99 (VDD_31 VDD_33) resistor r=0.217395
    rVDD_98 (VDD_31 VDD_60) resistor r=0.0221531
    rVDD_97 (VDD_33 VDD_34) resistor r=8.66667
    rVDD_96 (VDD_33 VDD_36) resistor r=0.237158
    rVDD_95 (VDD_34 VDD_37) resistor r=67.52
    rVDD_94 (VDD_36 VDD_37) resistor r=8.66667
    rVDD_93 (VDD_37 VDD_52) resistor r=67.52
    rVDD_92 (VDD_38 VDD_47) resistor r=0.538371
    rVDD_91 (VDD_38 VDD_62) resistor r=0.0882522
    rVDD_90 (VDD_40 VDD_48) resistor r=8.66667
    rVDD_89 (VDD_40 VDD_44) resistor r=0.720654
    rVDD_88 (VDD_44 VDD_48) resistor r=8.66667
    rVDD_87 (VDD_44 VDD_47) resistor r=0.468149
    rVDD_86 (VDD_47 VDD_48) resistor r=13
    rVDD_85 (VDD_48 MM7_ELT_s) resistor r=4.04518
    rVDD_84 (VDD_48 VDD_102) resistor r=4.04518
    rVDD_83 (VDD_48 MM17_ELT_s) resistor r=4.04518
    rVDD_82 (VDD_48 VDD_100) resistor r=4.04518
    rVDD_81 (VDD_49 VDD_51) resistor r=0.160082
    rVDD_80 (VDD_49 VDD_62) resistor r=0.0221531
    rVDD_79 (VDD_51 VDD_52) resistor r=8.66667
    rVDD_78 (VDD VDD_57) resistor r=0.0513842
    rVDD_77 (MM11_ELT_s VDD_68) resistor r=2.55965
    rVDD_76 (MM11_ELT_s VDD_70) resistor r=12.3172
    rVDD_75 (MM11_ELT_s VDD_70) resistor r=1.62887
    rVDD_74 (MM11_ELT_s VDD_73) resistor r=4.36821
    rVDD_73 (VDD_66 VDD_68) resistor r=14.4784
    rVDD_72 (VDD_66 VDD_72) resistor r=9.04062
    rVDD_71 (VDD_67 VDD_68) resistor r=14.4784
    rVDD_70 (VDD_67 VDD_97) resistor r=9.48555
    rVDD_69 (VDD_69 VDD_70) resistor r=12.3172
    rVDD_68 (VDD_69 VDD_71) resistor r=9.04595
    rVDD_67 (VDD_71 VDD_73) resistor r=20.2547
    rVDD_66 (VDD_72 VDD_73) resistor r=20.2547
    rVDD_65 (VDD_74 MM8_ELT_s) resistor r=13.564
    rVDD_64 (VDD_74 VDD_98) resistor r=9.39461
    rVDD_63 (MM8_ELT_s VDD_78) resistor r=2.55965
    rVDD_62 (MM8_ELT_s VDD_80) resistor r=18.4228
    rVDD_61 (MM8_ELT_s VDD_80) resistor r=3.88377
    rVDD_60 (VDD_76 VDD_78) resistor r=14.4784
    rVDD_59 (VDD_76 VDD_79) resistor r=9.04595
    rVDD_58 (VDD_77 VDD_78) resistor r=14.4784
    rVDD_57 (VDD_77 VDD_99) resistor r=9.48555
    rVDD_56 (VDD_79 VDD_80) resistor r=18.4228
    rVDD_55 (MM17_ELT_s VDD_82) resistor r=25.7298
    rVDD_54 (MM17_ELT_s VDD_85) resistor r=2.55965
    rVDD_53 (MM17_ELT_s VDD_87) resistor r=12.3172
    rVDD_52 (MM17_ELT_s VDD_87) resistor r=1.62887
    rVDD_51 (VDD_82 VDD_84) resistor r=9.04062
    rVDD_50 (VDD_83 VDD_85) resistor r=14.4784
    rVDD_49 (VDD_83 VDD_103) resistor r=10.5593
    rVDD_48 (VDD_84 VDD_85) resistor r=14.4784
    rVDD_47 (VDD_86 VDD_87) resistor r=12.3172
    rVDD_46 (VDD_86 VDD_101) resistor r=10.2363
    rVDD_45 (MM7_ELT_s VDD_91) resistor r=2.55965
    rVDD_44 (MM7_ELT_s VDD_93) resistor r=11.6604
    rVDD_43 (MM7_ELT_s VDD_93) resistor r=1.30988
    rVDD_42 (MM7_ELT_s VDD_96) resistor r=6.12113
    rVDD_41 (MM7_ELT_s VDD_101) resistor r=10.2363
    rVDD_40 (VDD_89 VDD_91) resistor r=14.4784
    rVDD_39 (VDD_89 VDD_95) resistor r=9.04062
    rVDD_38 (VDD_90 VDD_91) resistor r=14.4784
    rVDD_37 (VDD_90 VDD_103) resistor r=10.5593
    rVDD_36 (VDD_92 VDD_93) resistor r=11.6604
    rVDD_35 (VDD_92 VDD_94) resistor r=9.04595
    rVDD_34 (VDD_94 VDD_96) resistor r=31.2341
    rVDD_33 (VDD_95 VDD_96) resistor r=31.2341
    rVDD_32 (VDD_100 VDD_101) resistor r=0.549089
    rVDD_31 (VDD_102 VDD_103) resistor r=0.730683
    rVSS_153 (MM2_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_152 (MM6_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_151 (MM3_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_150 (MM5_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_149 (MM19_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_148 (MM4_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_147 (MM1_ELT_b VSS_62) resistor r=8.66667
    rVSS_146 (MM1_ELT_b VSS_27) resistor r=64.7228
    rVSS_145 (MM1_ELT_b VSS_37) resistor r=64.7228
    rVSS_144 (VSS_2 VSS_4) resistor r=0.405086
    rVSS_143 (VSS_2 VSS_57) resistor r=0.119189
    rVSS_142 (VSS_4 VSS_5) resistor r=8.66667
    rVSS_141 (VSS_4 VSS_7) resistor r=0.426406
    rVSS_140 (VSS_5 VSS_116) resistor r=17.2126
    rVSS_139 (VSS_5 VSS_106) resistor r=17.2126
    rVSS_138 (VSS_5 MM1_ELT_s) resistor r=3.43331
    rVSS_137 (VSS_7 VSS_8) resistor r=26
    rVSS_136 (VSS_8 VSS_69) resistor r=5.7452
    rVSS_135 (VSS_8 VSS_116) resistor r=4.05543
    rVSS_134 (VSS_10 VSS_13) resistor r=0.221347
    rVSS_133 (VSS_10 VSS_59) resistor r=0.0221531
    rVSS_132 (VSS_11 VSS_13) resistor r=0.0335974
    rVSS_131 (VSS_11 VSS_57) resistor r=0.0177869
    rVSS_130 (VSS_13 VSS_14) resistor r=8.66667
    rVSS_129 (VSS_14 VSS_60) resistor r=64.7228
    rVSS_128 (VSS_15 VSS_17) resistor r=0.405086
    rVSS_127 (VSS_15 VSS_59) resistor r=0.0882522
    rVSS_126 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_125 (VSS_17 VSS_20) resistor r=0.456281
    rVSS_124 (VSS_18 VSS_118) resistor r=17.2126
    rVSS_123 (VSS_18 VSS_107) resistor r=17.2126
    rVSS_122 (VSS_18 MM2_ELT_s) resistor r=3.43331
    rVSS_121 (VSS_20 VSS_21) resistor r=26
    rVSS_120 (VSS_21 VSS_76) resistor r=5.7452
    rVSS_119 (VSS_21 VSS_118) resistor r=4.05543
    rVSS_118 (VSS_23 VSS_26) resistor r=0.221347
    rVSS_117 (VSS_23 VSS_62) resistor r=0.0221531
    rVSS_116 (VSS_24 VSS_26) resistor r=0.217395
    rVSS_115 (VSS_24 VSS_59) resistor r=0.0221531
    rVSS_114 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_113 (VSS_27 VSS_60) resistor r=64.7228
    rVSS_112 (VSS_28 VSS_30) resistor r=0.399756
    rVSS_111 (VSS_28 VSS_62) resistor r=0.0882522
    rVSS_110 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_109 (VSS_31 VSS_109) resistor r=6.72074
    rVSS_108 (VSS_31 VSS_108) resistor r=6.72074
    rVSS_107 (VSS_31 MM3_ELT_s) resistor r=2.22558
    rVSS_106 (VSS_33 VSS_39) resistor r=0.0415027
    rVSS_105 (VSS_33 VSS_64) resistor r=0.0221531
    rVSS_104 (VSS_34 VSS_36) resistor r=0.217395
    rVSS_103 (VSS_34 VSS_62) resistor r=0.0221531
    rVSS_102 (VSS_36 VSS_37) resistor r=8.66667
    rVSS_101 (VSS_36 VSS_39) resistor r=0.237158
    rVSS_100 (VSS_37 VSS_40) resistor r=64.7228
    rVSS_99 (VSS_39 VSS_40) resistor r=8.66667
    rVSS_98 (VSS_40 VSS_52) resistor r=64.7228
    rVSS_97 (VSS_41 VSS_43) resistor r=0.502996
    rVSS_96 (VSS_41 VSS_64) resistor r=0.0882522
    rVSS_95 (VSS_43 VSS_44) resistor r=8.66667
    rVSS_94 (VSS_43 VSS_46) resistor r=0.53653
    rVSS_93 (VSS_44 MM4_ELT_s) resistor r=4.22001
    rVSS_92 (VSS_44 VSS_121) resistor r=4.22001
    rVSS_91 (VSS_44 MM19_ELT_s) resistor r=4.22001
    rVSS_90 (VSS_44 VSS_110) resistor r=4.22001
    rVSS_89 (VSS_46 VSS_47) resistor r=26
    rVSS_88 (VSS_47 MM4_ELT_s) resistor r=10.6787
    rVSS_87 (VSS_47 VSS_95) resistor r=10.6787
    rVSS_86 (VSS_47 VSS_121) resistor r=0.57282
    rVSS_85 (VSS_49 VSS_51) resistor r=0.160082
    rVSS_84 (VSS_49 VSS_64) resistor r=0.0221531
    rVSS_83 (VSS_51 VSS_52) resistor r=8.66667
    rVSS_82 (VSS VSS_57) resistor r=0.0494079
    rVSS_81 (VSS_59 VSS_60) resistor r=8.66667
    rVSS_80 (MM1_ELT_s VSS_68) resistor r=2.67027
    rVSS_79 (MM1_ELT_s VSS_70) resistor r=12.8495
    rVSS_78 (MM1_ELT_s VSS_70) resistor r=1.69926
    rVSS_77 (MM1_ELT_s VSS_71) resistor r=18.0507
    rVSS_76 (VSS_66 VSS_68) resistor r=15.1041
    rVSS_75 (VSS_66 VSS_71) resistor r=9.43134
    rVSS_74 (VSS_67 VSS_68) resistor r=15.1041
    rVSS_73 (VSS_67 VSS_106) resistor r=9.89549
    rVSS_72 (VSS_69 VSS_70) resistor r=12.8495
    rVSS_71 (MM2_ELT_s VSS_75) resistor r=2.67027
    rVSS_70 (MM2_ELT_s VSS_77) resistor r=7.63611
    rVSS_69 (MM2_ELT_s VSS_77) resistor r=1.46105
    rVSS_68 (MM2_ELT_s VSS_79) resistor r=7.63611
    rVSS_67 (MM2_ELT_s VSS_79) resistor r=1.46105
    rVSS_66 (MM2_ELT_s VSS_82) resistor r=4.557
    rVSS_65 (VSS_73 VSS_75) resistor r=15.1041
    rVSS_64 (VSS_73 VSS_80) resistor r=9.43134
    rVSS_63 (VSS_74 VSS_75) resistor r=15.1041
    rVSS_62 (VSS_74 VSS_107) resistor r=9.89549
    rVSS_61 (VSS_76 VSS_77) resistor r=7.63611
    rVSS_60 (VSS_78 VSS_79) resistor r=7.63611
    rVSS_59 (VSS_78 VSS_81) resistor r=9.4369
    rVSS_58 (VSS_80 VSS_82) resistor r=21.1301
    rVSS_57 (VSS_81 VSS_82) resistor r=21.1301
    rVSS_56 (MM3_ELT_s VSS_84) resistor r=18.0507
    rVSS_55 (MM3_ELT_s VSS_87) resistor r=2.67027
    rVSS_54 (MM3_ELT_s VSS_89) resistor r=12.8495
    rVSS_53 (MM3_ELT_s VSS_89) resistor r=1.69926
    rVSS_52 (VSS_84 VSS_86) resistor r=9.43134
    rVSS_51 (VSS_85 VSS_87) resistor r=15.1041
    rVSS_50 (VSS_85 VSS_108) resistor r=17.1506
    rVSS_49 (VSS_86 VSS_87) resistor r=15.1041
    rVSS_48 (VSS_88 VSS_89) resistor r=12.8495
    rVSS_47 (VSS_88 VSS_109) resistor r=16.8158
    rVSS_46 (MM19_ELT_s VSS_91) resistor r=18.0507
    rVSS_45 (MM19_ELT_s VSS_94) resistor r=2.67027
    rVSS_44 (MM19_ELT_s VSS_96) resistor r=12.8495
    rVSS_43 (MM19_ELT_s VSS_96) resistor r=1.69926
    rVSS_42 (VSS_91 VSS_93) resistor r=9.43134
    rVSS_41 (VSS_92 VSS_94) resistor r=15.1041
    rVSS_40 (VSS_92 VSS_111) resistor r=11.0157
    rVSS_39 (VSS_93 VSS_94) resistor r=15.1041
    rVSS_38 (VSS_95 VSS_96) resistor r=12.8495
    rVSS_37 (MM4_ELT_s VSS_100) resistor r=2.67027
    rVSS_36 (MM4_ELT_s VSS_102) resistor r=12.1643
    rVSS_35 (MM4_ELT_s VSS_102) resistor r=1.36649
    rVSS_34 (MM4_ELT_s VSS_105) resistor r=4.557
    rVSS_33 (VSS_98 VSS_100) resistor r=15.1041
    rVSS_32 (VSS_98 VSS_103) resistor r=9.43134
    rVSS_31 (VSS_99 VSS_100) resistor r=15.1041
    rVSS_30 (VSS_99 VSS_111) resistor r=11.0157
    rVSS_29 (VSS_101 VSS_102) resistor r=12.1643
    rVSS_28 (VSS_101 VSS_104) resistor r=9.4369
    rVSS_27 (VSS_103 VSS_105) resistor r=21.1301
    rVSS_26 (VSS_104 VSS_105) resistor r=21.1301
    rVSS_25 (VSS_110 VSS_111) resistor r=0.762262
    rnet32_30 (MM3_ELT_d net32) resistor r=0.01
    rnet32_29 (net32_1 net32_3) resistor r=0.410318
    rnet32_28 (net32_1 net32_7) resistor r=0.0961065
    rnet32_27 (net32_3 net32_4) resistor r=13
    rnet32_26 (net32_4 net32) resistor r=8.44
    rnet32_25 (net32_6 net32_7) resistor r=0.679293
    rnet32_24 (net32_6 net32_8) resistor r=0.0961065
    rnet32_23 (net32_8 net32_10) resistor r=0.856878
    rnet32_22 (net32_10 net32_11) resistor r=8.66667
    rnet32_21 (net32_11 MM5_ELT_s) resistor r=2.90692
    rnet32_20 (net32_11 net32_22) resistor r=12.1406
    rnet32_19 (net32_13 net32_16) resistor r=21.1301
    rnet32_18 (net32_13 net32_18) resistor r=9.43134
    rnet32_17 (net32_14 net32_16) resistor r=21.1301
    rnet32_16 (net32_14 net32_20) resistor r=9.4369
    rnet32_15 (MM5_ELT_s net32_16) resistor r=4.557
    rnet32_14 (MM5_ELT_s net32_19) resistor r=2.67027
    rnet32_13 (MM5_ELT_s net32_21) resistor r=12.8495
    rnet32_12 (MM5_ELT_s net32_21) resistor r=1.69926
    rnet32_11 (net32_17 net32_19) resistor r=15.1041
    rnet32_10 (net32_17 net32_22) resistor r=9.89549
    rnet32_9 (net32_18 net32_19) resistor r=15.1041
    rnet32_8 (net32_20 net32_21) resistor r=12.8495
    rnet015_100 (MM17_ELT_d net015) resistor r=0.01
    rnet015_99 (net015_12 net015_18) resistor r=58.3583
    rnet015_98 (net015_12 net015_18) resistor r=4.16253
    rnet015_97 (net015_12 net015_18) resistor r=58.3583
    rnet015_96 (net015_12 net015_18) resistor r=4.16253
    rnet015_95 (net015_15 net015_18) resistor r=58.3583
    rnet015_94 (net015_15 net015_18) resistor r=4.16253
    rnet015_93 (net015_15 net015_18) resistor r=58.3583
    rnet015_92 (net015_15 net015_18) resistor r=4.16253
    rnet015_91 (net015_18 net015_23) resistor r=24.8333
    rnet015_90 (net015_18 net015_20) resistor r=24.8333
    rnet015_89 (net015_18 net015_31) resistor r=24.8333
    rnet015_88 (net015_18 net015_28) resistor r=24.8333
    rnet015_87 (net015_18 net015_36) resistor r=58.3583
    rnet015_86 (net015_18 net015_39) resistor r=58.3583
    rnet015_85 (net015_18 net015_44) resistor r=14.9
    rnet015_84 (net015_18 net015_23) resistor r=4.16253
    rnet015_83 (net015_18 net015_31) resistor r=4.16253
    rnet015_82 (net015_18 net015_20) resistor r=4.16253
    rnet015_81 (net015_18 net015_36) resistor r=4.16253
    rnet015_80 (net015_18 net015_44) resistor r=6.30933
    rnet015_79 (net015_18 net015_39) resistor r=6.30933
    rnet015_78 (net015_18 net015_28) resistor r=1.63969
    rnet015_77 (net015_18 net015_23) resistor r=24.8333
    rnet015_76 (net015_18 net015_20) resistor r=24.8333
    rnet015_75 (net015_18 net015_31) resistor r=24.8333
    rnet015_74 (net015_18 net015_28) resistor r=24.8333
    rnet015_73 (net015_18 net015_36) resistor r=58.3583
    rnet015_72 (net015_18 MM5_ELT_g) resistor r=22.35
    rnet015_71 (net015_18 net015_44) resistor r=14.9
    rnet015_70 (net015_18 net015_138) resistor r=40.975
    rnet015_69 (net015_18 net015_23) resistor r=4.16253
    rnet015_68 (net015_18 net015_31) resistor r=4.16253
    rnet015_67 (net015_18 net015_20) resistor r=4.16253
    rnet015_66 (net015_18 net015_36) resistor r=4.16253
    rnet015_65 (net015_18 net015_44) resistor r=6.30933
    rnet015_64 (net015_18 net015_39) resistor r=6.30933
    rnet015_63 (net015_18 net015_28) resistor r=1.63969
    rnet015_62 (net015_39 MM5_ELT_g) resistor r=36.0083
    rnet015_61 (net015_66 net015_67) resistor r=0.431301
    rnet015_60 (net015_66 net015_86) resistor r=0.0667307
    rnet015_59 (net015_67 net015_81) resistor r=0.0959621
    rnet015_58 (net015_70 net015_71) resistor r=8.66667
    rnet015_57 (net015_70 net015_89) resistor r=0.224386
    rnet015_56 (net015_71 net015) resistor r=32.3614
    rnet015_55 (net015_75 net015_76) resistor r=8.66667
    rnet015_54 (net015_75 net015_91) resistor r=0.0841448
    rnet015_53 (net015_75 net015_78) resistor r=0.560966
    rnet015_52 (net015_76 net015) resistor r=16.1807
    rnet015_51 (net015_76 net015_79) resistor r=32.3614
    rnet015_50 (net015_78 net015_79) resistor r=26
    rnet015_49 (net015_81 net015_100) resistor r=1.00079
    rnet015_48 (net015_83 net015_84) resistor r=13
    rnet015_47 (net015_83 net015_86) resistor r=0.0700397
    rnet015_46 (net015_84 MM19_ELT_d) resistor r=8.44
    rnet015_45 (net015_88 net015_89) resistor r=0.0691494
    rnet015_44 (net015_88 net015_107) resistor r=0.0541553
    rnet015_43 (net015_90 net015_91) resistor r=0.0691494
    rnet015_42 (net015_90 net015_107) resistor r=0.324932
    rnet015_41 (net015_92 net015_94) resistor r=0.322979
    rnet015_40 (net015_92 net015_111) resistor r=0.0579442
    rnet015_39 (net015_94 net015_150) resistor r=0.75
    rnet015_38 (net015_97 net015_99) resistor r=0.482523
    rnet015_37 (net015_97 net015_111) resistor r=0.0150587
    rnet015_36 (net015_99 net015_100) resistor r=0.75
    rnet015_35 (net015_102 net015_103) resistor r=0.393023
    rnet015_34 (net015_102 net015_112) resistor r=0.0150587
    rnet015_33 (net015_103 net015_111) resistor r=0.0579442
    rnet015_32 (net015_104 net015_106) resistor r=0.0389132
    rnet015_31 (net015_104 net015_112) resistor r=0.0579442
    rnet015_30 (net015_106 net015_107) resistor r=0.75
    rnet015_29 (net015_138 net015_147) resistor r=4.38767
    rnet015_28 (net015_146 net015_147) resistor r=3.71511
    rnet015_27 (net015_146 net015_149) resistor r=6.09545
    rnet015_26 (net015_149 net015_150) resistor r=10
    rY_133 (MM20_ELT_d Y) resistor r=0.01
    rY_132 (Y_22 Y_28) resistor r=58.3583
    rY_131 (Y_22 Y_28) resistor r=4.16253
    rY_130 (Y_22 Y_28) resistor r=58.3583
    rY_129 (Y_22 Y_28) resistor r=4.16253
    rY_128 (Y_25 Y_28) resistor r=58.3583
    rY_127 (Y_25 Y_28) resistor r=6.30933
    rY_126 (Y_25 Y_28) resistor r=58.3583
    rY_125 (Y_25 Y_28) resistor r=6.30933
    rY_124 (Y_28 Y_30) resistor r=14.9
    rY_123 (Y_28 Y_39) resistor r=24.8333
    rY_122 (Y_28 Y_36) resistor r=24.8333
    rY_121 (Y_28 Y_47) resistor r=24.8333
    rY_120 (Y_28 Y_44) resistor r=24.8333
    rY_119 (Y_28 Y_52) resistor r=58.3583
    rY_118 (Y_28 Y_55) resistor r=58.3583
    rY_117 (Y_28 Y_39) resistor r=4.16253
    rY_116 (Y_28 Y_30) resistor r=6.30933
    rY_115 (Y_28 Y_47) resistor r=1.63969
    rY_114 (Y_28 Y_36) resistor r=4.16253
    rY_113 (Y_28 Y_52) resistor r=4.16253
    rY_112 (Y_28 Y_44) resistor r=4.16253
    rY_111 (Y_28 Y_55) resistor r=4.16253
    rY_110 (Y_28 Y_30) resistor r=14.9
    rY_109 (Y_28 Y_192) resistor r=39.7333
    rY_108 (Y_28 Y_39) resistor r=24.8333
    rY_107 (Y_28 Y_36) resistor r=24.8333
    rY_106 (Y_28 Y_47) resistor r=24.8333
    rY_105 (Y_28 Y_44) resistor r=24.8333
    rY_104 (Y_28 Y_52) resistor r=58.3583
    rY_103 (Y_28 MM3_ELT_g) resistor r=7.45
    rY_102 (Y_28 Y_39) resistor r=4.16253
    rY_101 (Y_28 Y_30) resistor r=6.30933
    rY_100 (Y_28 Y_47) resistor r=1.63969
    rY_99 (Y_28 Y_36) resistor r=4.16253
    rY_98 (Y_28 Y_52) resistor r=4.16253
    rY_97 (Y_28 Y_44) resistor r=4.16253
    rY_96 (Y_28 Y_55) resistor r=4.16253
    rY_95 (Y_55 MM3_ELT_g) resistor r=50.9083
    rY_94 (Y_60 Y_66) resistor r=58.3583
    rY_93 (Y_60 Y_66) resistor r=4.16253
    rY_92 (Y_60 Y_66) resistor r=58.3583
    rY_91 (Y_60 Y_66) resistor r=4.16253
    rY_90 (Y_63 Y_66) resistor r=58.3583
    rY_89 (Y_63 Y_66) resistor r=4.16253
    rY_88 (Y_63 Y_66) resistor r=58.3583
    rY_87 (Y_63 Y_66) resistor r=4.16253
    rY_86 (Y_66 Y_71) resistor r=24.8333
    rY_85 (Y_66 Y_68) resistor r=24.8333
    rY_84 (Y_66 Y_79) resistor r=24.8333
    rY_83 (Y_66 Y_76) resistor r=24.8333
    rY_82 (Y_66 Y_84) resistor r=55.875
    rY_81 (Y_66 Y_87) resistor r=55.875
    rY_80 (Y_66 Y_92) resistor r=11.175
    rY_79 (Y_66 Y_71) resistor r=4.16253
    rY_78 (Y_66 Y_79) resistor r=4.16253
    rY_77 (Y_66 Y_92) resistor r=5.53947
    rY_76 (Y_66 Y_68) resistor r=5.53947
    rY_75 (Y_66 Y_84) resistor r=2.32428
    rY_74 (Y_66 Y_76) resistor r=4.16253
    rY_73 (Y_66 Y_87) resistor r=4.16253
    rY_72 (Y_66 Y_71) resistor r=24.8333
    rY_71 (Y_66 Y_68) resistor r=24.8333
    rY_70 (Y_66 Y_79) resistor r=24.8333
    rY_69 (Y_66 Y_76) resistor r=24.8333
    rY_68 (Y_66 Y_84) resistor r=55.875
    rY_67 (Y_66 MM8_ELT_g) resistor r=4.96667
    rY_66 (Y_66 Y_92) resistor r=11.175
    rY_65 (Y_66 Y_221) resistor r=29.8
    rY_64 (Y_66 Y_71) resistor r=4.16253
    rY_63 (Y_66 Y_79) resistor r=4.16253
    rY_62 (Y_66 Y_92) resistor r=5.53947
    rY_61 (Y_66 Y_68) resistor r=5.53947
    rY_60 (Y_66 Y_84) resistor r=2.32428
    rY_59 (Y_66 Y_76) resistor r=4.16253
    rY_58 (Y_66 Y_87) resistor r=4.16253
    rY_57 (Y_87 MM8_ELT_g) resistor r=50.9083
    rY_56 (Y_131 Y_132) resistor r=0.303168
    rY_55 (Y_131 Y_141) resistor r=0.0961065
    rY_54 (Y_132 Y_153) resistor r=0.0507648
    rY_53 (Y_133 Y_134) resistor r=0.212065
    rY_52 (Y_133 Y_156) resistor r=0.0728365
    rY_51 (Y_134 Y_166) resistor r=0.0964532
    rY_50 (Y_135 Y_137) resistor r=0.294883
    rY_49 (Y_135 Y_156) resistor r=0.0189289
    rY_48 (Y_137 Y_138) resistor r=13
    rY_47 (Y_138 Y) resistor r=8.09035
    rY_46 (Y_140 Y_141) resistor r=0.363879
    rY_45 (Y_140 Y_158) resistor r=0.0724925
    rY_44 (Y_142 Y_143) resistor r=1.88112
    rY_43 (Y_142 Y_146) resistor r=0.0961065
    rY_42 (Y_143 Y_156) resistor r=0.0728365
    rY_41 (Y_146 Y_148) resistor r=0.103003
    rY_40 (Y_148 Y_149) resistor r=10
    rY_39 (Y_149 Y_221) resistor r=4.6552
    rY_38 (Y_153 Y_154) resistor r=13
    rY_37 (Y_153 Y_162) resistor r=0.0456197
    rY_36 (Y_154 MM6_ELT_d) resistor r=8.44
    rY_35 (Y_158 Y_159) resistor r=10
    rY_34 (Y_159 Y_192) resistor r=5.39869
    rY_33 (Y_161 Y_162) resistor r=0.75
    rY_32 (Y_161 Y_165) resistor r=0.716002
    rY_31 (Y_165 Y_166) resistor r=0.75
    rnet34_37 (MM2_ELT_d net34) resistor r=0.01
    rnet34_36 (net34_1 net34_3) resistor r=0.309144
    rnet34_35 (net34_1 net34_12) resistor r=0.0961065
    rnet34_34 (net34_3 net34_4) resistor r=8.66667
    rnet34_33 (net34_4 MM6_ELT_s) resistor r=2.90692
    rnet34_32 (net34_4 net34_26) resistor r=12.1406
    rnet34_31 (net34_6 net34_8) resistor r=0.303814
    rnet34_30 (net34_6 net34_14) resistor r=0.0961065
    rnet34_29 (net34_8 net34_9) resistor r=13
    rnet34_28 (net34_9 net34) resistor r=8.44
    rnet34_27 (net34_11 net34_12) resistor r=0.541306
    rnet34_26 (net34_11 net34_16) resistor r=0.0961065
    rnet34_25 (net34_13 net34_14) resistor r=0.26418
    rnet34_24 (net34_13 net34_15) resistor r=0.0961065
    rnet34_23 (net34_15 net34_16) resistor r=0.793889
    rnet34_22 (MM6_ELT_s net34_20) resistor r=2.67027
    rnet34_21 (MM6_ELT_s net34_22) resistor r=12.8495
    rnet34_20 (MM6_ELT_s net34_22) resistor r=1.69926
    rnet34_19 (MM6_ELT_s net34_25) resistor r=4.557
    rnet34_18 (net34_18 net34_20) resistor r=15.1041
    rnet34_17 (net34_18 net34_23) resistor r=9.43134
    rnet34_16 (net34_19 net34_20) resistor r=15.1041
    rnet34_15 (net34_19 net34_26) resistor r=9.89549
    rnet34_14 (net34_21 net34_22) resistor r=12.8495
    rnet34_13 (net34_21 net34_24) resistor r=9.4369
    rnet34_12 (net34_23 net34_25) resistor r=21.1301
    rnet34_11 (net34_24 net34_25) resistor r=21.1301
    rX_354 (MM10_ELT_s X) resistor r=0.01
    rX_353 (X_64 X_70) resistor r=58.3583
    rX_352 (X_64 X_70) resistor r=4.16253
    rX_351 (X_64 X_70) resistor r=58.3583
    rX_350 (X_64 X_70) resistor r=4.16253
    rX_349 (X_67 X_70) resistor r=58.3583
    rX_348 (X_67 X_70) resistor r=4.16253
    rX_347 (X_67 X_70) resistor r=58.3583
    rX_346 (X_67 X_70) resistor r=4.16253
    rX_345 (X_70 X_83) resistor r=24.8333
    rX_344 (X_70 X_80) resistor r=24.8333
    rX_343 (X_70 X_91) resistor r=24.8333
    rX_342 (X_70 X_88) resistor r=24.8333
    rX_341 (X_70 X_140) resistor r=14.9
    rX_340 (X_70 X_146) resistor r=58.3583
    rX_339 (X_70 X_149) resistor r=58.3583
    rX_338 (X_70 X_83) resistor r=4.16253
    rX_337 (X_70 X_91) resistor r=4.16253
    rX_336 (X_70 X_146) resistor r=6.30933
    rX_335 (X_70 X_140) resistor r=6.30933
    rX_334 (X_70 X_80) resistor r=1.63969
    rX_333 (X_70 X_88) resistor r=4.16253
    rX_332 (X_70 X_149) resistor r=4.16253
    rX_331 (X_70 X_83) resistor r=24.8333
    rX_330 (X_70 X_80) resistor r=24.8333
    rX_329 (X_70 X_91) resistor r=24.8333
    rX_328 (X_70 X_88) resistor r=24.8333
    rX_327 (X_70 X_551) resistor r=54.6333
    rX_326 (X_70 X_140) resistor r=14.9
    rX_325 (X_70 X_146) resistor r=58.3583
    rX_324 (X_70 MM9_ELT_g) resistor r=7.45
    rX_323 (X_70 X_83) resistor r=4.16253
    rX_322 (X_70 X_91) resistor r=4.16253
    rX_321 (X_70 X_146) resistor r=6.30933
    rX_320 (X_70 X_140) resistor r=6.30933
    rX_319 (X_70 X_80) resistor r=1.63969
    rX_318 (X_70 X_88) resistor r=4.16253
    rX_317 (X_70 X_149) resistor r=4.16253
    rX_316 (X_72 X_78) resistor r=58.3583
    rX_315 (X_72 X_78) resistor r=4.16253
    rX_314 (X_72 X_78) resistor r=58.3583
    rX_313 (X_72 X_78) resistor r=4.16253
    rX_312 (X_75 X_78) resistor r=58.3583
    rX_311 (X_75 X_78) resistor r=4.16253
    rX_310 (X_75 X_78) resistor r=58.3583
    rX_309 (X_75 X_78) resistor r=4.16253
    rX_308 (X_78 X_99) resistor r=24.8333
    rX_307 (X_78 X_96) resistor r=24.8333
    rX_306 (X_78 X_107) resistor r=8.69167
    rX_305 (X_78 X_104) resistor r=8.69167
    rX_304 (X_78 X_112) resistor r=14.9
    rX_303 (X_78 X_121) resistor r=8.69167
    rX_302 (X_78 X_118) resistor r=8.69167
    rX_301 (X_78 X_170) resistor r=58.3583
    rX_300 (X_78 X_173) resistor r=58.3583
    rX_299 (X_78 X_99) resistor r=4.16253
    rX_298 (X_78 X_107) resistor r=4.16253
    rX_297 (X_78 X_121) resistor r=6.30933
    rX_296 (X_78 X_104) resistor r=6.30933
    rX_295 (X_78 X_112) resistor r=1.63969
    rX_294 (X_78 X_96) resistor r=4.16253
    rX_293 (X_78 X_170) resistor r=4.16253
    rX_292 (X_78 X_118) resistor r=4.16253
    rX_291 (X_78 X_173) resistor r=4.16253
    rX_290 (X_78 X_99) resistor r=24.8333
    rX_289 (X_78 X_96) resistor r=24.8333
    rX_288 (X_78 X_107) resistor r=8.69167
    rX_287 (X_78 X_104) resistor r=8.69167
    rX_286 (X_78 X_112) resistor r=14.9
    rX_285 (X_78 X_538) resistor r=39.7333
    rX_284 (X_78 X_121) resistor r=8.69167
    rX_283 (X_78 X_118) resistor r=8.69167
    rX_282 (X_78 X_170) resistor r=58.3583
    rX_281 (X_78 MM2_ELT_g) resistor r=7.45
    rX_280 (X_78 X_99) resistor r=4.16253
    rX_279 (X_78 X_107) resistor r=4.16253
    rX_278 (X_78 X_121) resistor r=6.30933
    rX_277 (X_78 X_104) resistor r=6.30933
    rX_276 (X_78 X_112) resistor r=1.63969
    rX_275 (X_78 X_96) resistor r=4.16253
    rX_274 (X_78 X_170) resistor r=4.16253
    rX_273 (X_78 X_118) resistor r=4.16253
    rX_272 (X_78 X_173) resistor r=4.16253
    rX_271 (X_126 X_132) resistor r=58.3583
    rX_270 (X_126 X_132) resistor r=4.16253
    rX_269 (X_126 X_132) resistor r=58.3583
    rX_268 (X_126 X_132) resistor r=4.16253
    rX_267 (X_129 X_132) resistor r=58.3583
    rX_266 (X_129 X_132) resistor r=6.30933
    rX_265 (X_129 X_132) resistor r=58.3583
    rX_264 (X_129 X_132) resistor r=6.30933
    rX_263 (X_132 X_134) resistor r=14.9
    rX_262 (X_132 X_157) resistor r=24.8333
    rX_261 (X_132 X_154) resistor r=24.8333
    rX_260 (X_132 X_165) resistor r=24.8333
    rX_259 (X_132 X_162) resistor r=24.8333
    rX_258 (X_132 X_178) resistor r=58.3583
    rX_257 (X_132 X_181) resistor r=58.3583
    rX_256 (X_132 X_157) resistor r=4.16253
    rX_255 (X_132 X_134) resistor r=6.30933
    rX_254 (X_132 X_165) resistor r=1.63969
    rX_253 (X_132 X_154) resistor r=4.16253
    rX_252 (X_132 X_178) resistor r=4.16253
    rX_251 (X_132 X_162) resistor r=4.16253
    rX_250 (X_132 X_181) resistor r=4.16253
    rX_249 (X_132 X_134) resistor r=14.9
    rX_248 (X_132 X_549) resistor r=40.975
    rX_247 (X_132 X_157) resistor r=24.8333
    rX_246 (X_132 X_154) resistor r=24.8333
    rX_245 (X_132 X_165) resistor r=24.8333
    rX_244 (X_132 X_162) resistor r=24.8333
    rX_243 (X_132 X_178) resistor r=58.3583
    rX_242 (X_132 MM6_ELT_g) resistor r=7.45
    rX_241 (X_132 X_157) resistor r=4.16253
    rX_240 (X_132 X_134) resistor r=6.30933
    rX_239 (X_132 X_165) resistor r=1.63969
    rX_238 (X_132 X_154) resistor r=4.16253
    rX_237 (X_132 X_178) resistor r=4.16253
    rX_236 (X_132 X_162) resistor r=4.16253
    rX_235 (X_132 X_181) resistor r=4.16253
    rX_234 (X_149 MM9_ELT_g) resistor r=50.9083
    rX_233 (X_173 MM2_ELT_g) resistor r=50.9083
    rX_232 (X_181 MM6_ELT_g) resistor r=50.9083
    rX_231 (X_186 X_192) resistor r=58.3583
    rX_230 (X_186 X_192) resistor r=4.16253
    rX_229 (X_186 X_192) resistor r=58.3583
    rX_228 (X_186 X_192) resistor r=4.16253
    rX_227 (X_189 X_192) resistor r=58.3583
    rX_226 (X_189 X_192) resistor r=4.16253
    rX_225 (X_189 X_192) resistor r=58.3583
    rX_224 (X_189 X_192) resistor r=4.16253
    rX_223 (X_192 X_197) resistor r=24.8333
    rX_222 (X_192 X_194) resistor r=24.8333
    rX_221 (X_192 X_205) resistor r=24.8333
    rX_220 (X_192 X_202) resistor r=24.8333
    rX_219 (X_192 X_210) resistor r=14.9
    rX_218 (X_192 X_216) resistor r=58.3583
    rX_217 (X_192 X_219) resistor r=58.3583
    rX_216 (X_192 X_197) resistor r=4.16253
    rX_215 (X_192 X_205) resistor r=4.16253
    rX_214 (X_192 X_216) resistor r=6.30933
    rX_213 (X_192 X_210) resistor r=6.30933
    rX_212 (X_192 X_194) resistor r=1.63969
    rX_211 (X_192 X_202) resistor r=4.16253
    rX_210 (X_192 X_219) resistor r=4.16253
    rX_209 (X_192 X_197) resistor r=24.8333
    rX_208 (X_192 X_194) resistor r=24.8333
    rX_207 (X_192 X_205) resistor r=24.8333
    rX_206 (X_192 X_202) resistor r=24.8333
    rX_205 (X_192 X_586) resistor r=54.6333
    rX_204 (X_192 X_210) resistor r=14.9
    rX_203 (X_192 X_216) resistor r=58.3583
    rX_202 (X_192 MM20_ELT_g) resistor r=7.45
    rX_201 (X_192 X_197) resistor r=4.16253
    rX_200 (X_192 X_205) resistor r=4.16253
    rX_199 (X_192 X_216) resistor r=6.30933
    rX_198 (X_192 X_210) resistor r=6.30933
    rX_197 (X_192 X_194) resistor r=1.63969
    rX_196 (X_192 X_202) resistor r=4.16253
    rX_195 (X_192 X_219) resistor r=4.16253
    rX_194 (X_219 MM20_ELT_g) resistor r=50.9083
    rX_193 (X_224 X_230) resistor r=58.3583
    rX_192 (X_224 X_230) resistor r=4.16253
    rX_191 (X_224 X_230) resistor r=58.3583
    rX_190 (X_224 X_230) resistor r=4.16253
    rX_189 (X_227 X_230) resistor r=58.3583
    rX_188 (X_227 X_230) resistor r=6.30933
    rX_187 (X_227 X_230) resistor r=58.3583
    rX_186 (X_227 X_230) resistor r=6.30933
    rX_185 (X_230 X_232) resistor r=14.9
    rX_184 (X_230 X_255) resistor r=24.8333
    rX_183 (X_230 X_252) resistor r=24.8333
    rX_182 (X_230 X_263) resistor r=24.8333
    rX_181 (X_230 X_260) resistor r=24.8333
    rX_180 (X_230 X_284) resistor r=58.3583
    rX_179 (X_230 X_287) resistor r=58.3583
    rX_178 (X_230 X_255) resistor r=4.16253
    rX_177 (X_230 X_232) resistor r=6.30933
    rX_176 (X_230 X_263) resistor r=1.63969
    rX_175 (X_230 X_252) resistor r=4.16253
    rX_174 (X_230 X_284) resistor r=4.16253
    rX_173 (X_230 X_260) resistor r=4.16253
    rX_172 (X_230 X_287) resistor r=4.16253
    rX_171 (X_230 X_232) resistor r=14.9
    rX_170 (X_230 X_598) resistor r=39.7333
    rX_169 (X_230 X_255) resistor r=24.8333
    rX_168 (X_230 X_252) resistor r=24.8333
    rX_167 (X_230 X_263) resistor r=24.8333
    rX_166 (X_230 X_260) resistor r=24.8333
    rX_165 (X_230 X_284) resistor r=58.3583
    rX_164 (X_230 MM19_ELT_g) resistor r=7.45
    rX_163 (X_230 X_255) resistor r=4.16253
    rX_162 (X_230 X_232) resistor r=6.30933
    rX_161 (X_230 X_263) resistor r=1.63969
    rX_160 (X_230 X_252) resistor r=4.16253
    rX_159 (X_230 X_284) resistor r=4.16253
    rX_158 (X_230 X_260) resistor r=4.16253
    rX_157 (X_230 X_287) resistor r=4.16253
    rX_156 (X_238 X_241) resistor r=14.9
    rX_155 (X_238 X_241) resistor r=6.30933
    rX_154 (X_238 X_241) resistor r=14.9
    rX_153 (X_238 X_241) resistor r=6.30933
    rX_152 (X_241 X_244) resistor r=202.392
    rX_151 (X_241 X_247) resistor r=202.392
    rX_150 (X_241 X_271) resistor r=24.8333
    rX_149 (X_241 X_268) resistor r=24.8333
    rX_148 (X_241 X_279) resistor r=24.8333
    rX_147 (X_241 X_276) resistor r=24.8333
    rX_146 (X_241 X_292) resistor r=202.392
    rX_145 (X_241 X_295) resistor r=202.392
    rX_144 (X_241 X_244) resistor r=6.30933
    rX_143 (X_241 X_271) resistor r=1.63969
    rX_142 (X_241 X_279) resistor r=4.16253
    rX_141 (X_241 X_247) resistor r=4.16253
    rX_140 (X_241 X_268) resistor r=4.16253
    rX_139 (X_241 X_292) resistor r=4.16253
    rX_138 (X_241 X_276) resistor r=4.16253
    rX_137 (X_241 X_295) resistor r=4.16253
    rX_136 (X_241 X_600) resistor r=42.2167
    rX_135 (X_241 X_244) resistor r=202.392
    rX_134 (X_241 X_247) resistor r=202.392
    rX_133 (X_241 X_271) resistor r=24.8333
    rX_132 (X_241 X_268) resistor r=24.8333
    rX_131 (X_241 X_279) resistor r=24.8333
    rX_130 (X_241 X_276) resistor r=24.8333
    rX_129 (X_241 X_292) resistor r=202.392
    rX_128 (X_241 MM17_ELT_g) resistor r=7.45
    rX_127 (X_241 X_244) resistor r=6.30933
    rX_126 (X_241 X_271) resistor r=1.63969
    rX_125 (X_241 X_279) resistor r=4.16253
    rX_124 (X_241 X_247) resistor r=4.16253
    rX_123 (X_241 X_268) resistor r=4.16253
    rX_122 (X_241 X_292) resistor r=4.16253
    rX_121 (X_241 X_276) resistor r=4.16253
    rX_120 (X_241 X_295) resistor r=4.16253
    rX_119 (X_287 MM19_ELT_g) resistor r=50.9083
    rX_118 (X_295 MM17_ELT_g) resistor r=194.942
    rX_117 (X_410 X_412) resistor r=0.303814
    rX_116 (X_410 X_423) resistor r=0.0961065
    rX_115 (X_412 X_413) resistor r=13
    rX_114 (X_413 MM1_ELT_d) resistor r=8.44
    rX_113 (X_415 X_417) resistor r=0.0906113
    rX_112 (X_415 X_425) resistor r=0.0961065
    rX_111 (X_417 X_418) resistor r=13
    rX_110 (X_418 MM11_ELT_d) resistor r=8.09035
    rX_109 (X_422 X_423) resistor r=0.112251
    rX_108 (X_422 X_426) resistor r=0.0961065
    rX_107 (X_424 X_425) resistor r=0.112251
    rX_106 (X_424 X_436) resistor r=0.0961065
    rX_105 (X_426 X_427) resistor r=0.249718
    rX_104 (X_427 X_446) resistor r=0.0794387
    rX_103 (X_428 X_429) resistor r=0.258259
    rX_102 (X_428 X_446) resistor r=0.0794387
    rX_101 (X_429 X_447) resistor r=0.0728365
    rX_100 (X_430 X_433) resistor r=0.399756
    rX_99 (X_430 X_447) resistor r=0.0728365
    rX_98 (X_431 X_433) resistor r=0.325135
    rX_97 (X_431 X_448) resistor r=0.0728365
    rX_96 (X_433 X_434) resistor r=8.66667
    rX_95 (X_434 X_667) resistor r=16.4995
    rX_94 (X_434 X) resistor r=3.29107
    rX_93 (X_435 X_436) resistor r=0.302589
    rX_92 (X_435 X_448) resistor r=0.0728365
    rX_91 (X_437 X_439) resistor r=0.476088
    rX_90 (X_437 X_448) resistor r=0.0189289
    rX_89 (X_439 X_440) resistor r=10
    rX_88 (X_439 X_442) resistor r=0.705757
    rX_87 (X_440 X_639) resistor r=12.8682
    rX_86 (X_442 X_443) resistor r=10
    rX_85 (X_443 X_649) resistor r=18.9636
    rX_84 (X_445 X_446) resistor r=0.0135403
    rX_83 (X_445 X_451) resistor r=0.594074
    rX_82 (X_450 X_451) resistor r=0.75
    rX_81 (X_450 X_454) resistor r=1.48648
    rX_80 (X_451 X_669) resistor r=10
    rX_79 (X_454 X_455) resistor r=0.75
    rX_78 (X_455 X_677) resistor r=10
    rX_77 (X_538 X_636) resistor r=4.38767
    rX_76 (X_549 X_640) resistor r=3.725
    rX_75 (X_551 X_640) resistor r=3.725
    rX_74 (X_586 X_649) resistor r=9.29775
    rX_73 (X_598 X_680) resistor r=5.23411
    rX_72 (X_600 X_680) resistor r=5.23411
    rX_71 (X_635 X_636) resistor r=3.71511
    rX_70 (X_635 X_669) resistor r=4.74091
    rX_69 (X_639 X_640) resistor r=3.725
    rX_68 (MM10_ELT_d X_661) resistor r=17.3029
    rX_67 (X_661 X_663) resistor r=9.04062
    rX_66 (X_662 X_663) resistor r=45.0246
    rX_65 (X_662 X_667) resistor r=9.48555
    rX_64 (X_677 X_680) resistor r=7.45
    rI_151 (I_32 I_35) resistor r=14.9
    rI_150 (I_32 I_35) resistor r=6.30933
    rI_149 (I_32 I_35) resistor r=14.9
    rI_148 (I_32 I_35) resistor r=6.30933
    rI_147 (I_35 I_38) resistor r=58.3583
    rI_146 (I_35 I_41) resistor r=58.3583
    rI_145 (I_35 I_71) resistor r=24.8333
    rI_144 (I_35 I_68) resistor r=24.8333
    rI_143 (I_35 I_79) resistor r=24.8333
    rI_142 (I_35 I_76) resistor r=24.8333
    rI_141 (I_35 I_116) resistor r=58.3583
    rI_140 (I_35 I_119) resistor r=58.3583
    rI_139 (I_35 I_38) resistor r=6.30933
    rI_138 (I_35 I_71) resistor r=1.63969
    rI_137 (I_35 I_79) resistor r=4.16253
    rI_136 (I_35 I_41) resistor r=4.16253
    rI_135 (I_35 I_68) resistor r=4.16253
    rI_134 (I_35 I_116) resistor r=4.16253
    rI_133 (I_35 I_76) resistor r=4.16253
    rI_132 (I_35 I_119) resistor r=4.16253
    rI_131 (I_35 I_233) resistor r=39.7333
    rI_130 (I_35 I_38) resistor r=58.3583
    rI_129 (I_35 I_41) resistor r=58.3583
    rI_128 (I_35 I_71) resistor r=24.8333
    rI_127 (I_35 I_68) resistor r=24.8333
    rI_126 (I_35 I_79) resistor r=24.8333
    rI_125 (I_35 I_76) resistor r=24.8333
    rI_124 (I_35 I_116) resistor r=58.3583
    rI_123 (I_35 MM10_ELT_g) resistor r=7.45
    rI_122 (I_35 I_38) resistor r=6.30933
    rI_121 (I_35 I_71) resistor r=1.63969
    rI_120 (I_35 I_79) resistor r=4.16253
    rI_119 (I_35 I_41) resistor r=4.16253
    rI_118 (I_35 I_68) resistor r=4.16253
    rI_117 (I_35 I_116) resistor r=4.16253
    rI_116 (I_35 I_76) resistor r=4.16253
    rI_115 (I_35 I_119) resistor r=4.16253
    rI_114 (I_46 I_52) resistor r=58.3583
    rI_113 (I_46 I_52) resistor r=4.16253
    rI_112 (I_46 I_52) resistor r=58.3583
    rI_111 (I_46 I_52) resistor r=4.16253
    rI_110 (I_49 I_52) resistor r=58.3583
    rI_109 (I_49 I_52) resistor r=4.16253
    rI_108 (I_49 I_52) resistor r=58.3583
    rI_107 (I_49 I_52) resistor r=4.16253
    rI_106 (I_52 I_87) resistor r=24.8333
    rI_105 (I_52 I_84) resistor r=24.8333
    rI_104 (I_52 I_95) resistor r=24.8333
    rI_103 (I_52 I_92) resistor r=24.8333
    rI_102 (I_52 I_124) resistor r=58.3583
    rI_101 (I_52 I_127) resistor r=58.3583
    rI_100 (I_52 I_132) resistor r=14.9
    rI_99 (I_52 I_87) resistor r=4.16253
    rI_98 (I_52 I_95) resistor r=4.16253
    rI_97 (I_52 I_84) resistor r=4.16253
    rI_96 (I_52 I_124) resistor r=4.16253
    rI_95 (I_52 I_132) resistor r=6.30933
    rI_94 (I_52 I_127) resistor r=6.30933
    rI_93 (I_52 I_92) resistor r=1.63969
    rI_92 (I_52 I_87) resistor r=24.8333
    rI_91 (I_52 I_84) resistor r=24.8333
    rI_90 (I_52 I_95) resistor r=24.8333
    rI_89 (I_52 I_92) resistor r=24.8333
    rI_88 (I_52 I_124) resistor r=58.3583
    rI_87 (I_52 MM1_ELT_g) resistor r=22.35
    rI_86 (I_52 I_132) resistor r=14.9
    rI_85 (I_52 I_281) resistor r=40.975
    rI_84 (I_52 I_87) resistor r=4.16253
    rI_83 (I_52 I_95) resistor r=4.16253
    rI_82 (I_52 I_84) resistor r=4.16253
    rI_81 (I_52 I_124) resistor r=4.16253
    rI_80 (I_52 I_132) resistor r=6.30933
    rI_79 (I_52 I_127) resistor r=6.30933
    rI_78 (I_52 I_92) resistor r=1.63969
    rI_77 (I_54 I_57) resistor r=14.9
    rI_76 (I_54 I_57) resistor r=6.30933
    rI_75 (I_54 I_57) resistor r=14.9
    rI_74 (I_54 I_57) resistor r=6.30933
    rI_73 (I_57 I_60) resistor r=58.3583
    rI_72 (I_57 I_63) resistor r=58.3583
    rI_71 (I_57 I_103) resistor r=24.8333
    rI_70 (I_57 I_100) resistor r=24.8333
    rI_69 (I_57 I_111) resistor r=24.8333
    rI_68 (I_57 I_108) resistor r=24.8333
    rI_67 (I_57 I_138) resistor r=58.3583
    rI_66 (I_57 I_141) resistor r=58.3583
    rI_65 (I_57 I_60) resistor r=6.30933
    rI_64 (I_57 I_103) resistor r=1.63969
    rI_63 (I_57 I_111) resistor r=4.16253
    rI_62 (I_57 I_63) resistor r=4.16253
    rI_61 (I_57 I_100) resistor r=4.16253
    rI_60 (I_57 I_138) resistor r=4.16253
    rI_59 (I_57 I_108) resistor r=4.16253
    rI_58 (I_57 I_141) resistor r=4.16253
    rI_57 (I_57 I_242) resistor r=39.7333
    rI_56 (I_57 I_60) resistor r=58.3583
    rI_55 (I_57 I_63) resistor r=58.3583
    rI_54 (I_57 I_103) resistor r=24.8333
    rI_53 (I_57 I_100) resistor r=24.8333
    rI_52 (I_57 I_111) resistor r=24.8333
    rI_51 (I_57 I_108) resistor r=24.8333
    rI_50 (I_57 I_138) resistor r=58.3583
    rI_49 (I_57 MM11_ELT_g) resistor r=7.45
    rI_48 (I_57 I_60) resistor r=6.30933
    rI_47 (I_57 I_103) resistor r=1.63969
    rI_46 (I_57 I_111) resistor r=4.16253
    rI_45 (I_57 I_63) resistor r=4.16253
    rI_44 (I_57 I_100) resistor r=4.16253
    rI_43 (I_57 I_138) resistor r=4.16253
    rI_42 (I_57 I_108) resistor r=4.16253
    rI_41 (I_57 I_141) resistor r=4.16253
    rI_40 (I_119 MM10_ELT_g) resistor r=50.9083
    rI_39 (I_127 MM1_ELT_g) resistor r=36.0083
    rI_38 (I_141 MM11_ELT_g) resistor r=50.9083
    rI_37 (I_197 I_198) resistor r=10
    rI_36 (I_197 I) resistor r=0.0864378
    rI_35 (I_198 I_307) resistor r=7.88824
    rI_34 (I_233 I_307) resistor r=8.45489
    rI_33 (I_242 I_263) resistor r=9.29775
    rI_32 (I_248 I_249) resistor r=22.35
    rI_31 (I_248 I_300) resistor r=2.62941
    rI_30 (I_249 I_307) resistor r=2.62941
    rI_29 (I_262 I_263) resistor r=57.5682
    rI_28 (I_262 I_289) resistor r=9.29775
    rI_27 (I_281 I_300) resistor r=8.45489
    rI_26 (I_288 I_289) resistor r=247.092
    rI_25 (I_288 I_301) resistor r=8.45489
    rI_24 (I_300 I_301) resistor r=19.7206
ends DEL0D1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DDFCNQD1UBC_LVT_ELT
// View name: calibre
subckt DDFCNQD1UBC_LVT_ELT CDN CP D Q VDD VSS
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM19_ELT (MM19_ELT_d MM19_ELT_g MM19_ELT_s MM19_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM18_ELT (MM18_ELT_d MM18_ELT_g MM18_ELT_s MM18_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.93575e-13 pd=3.66e-06 \
        ps=7.295e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=4.93575e-13 pd=3.66e-06 \
        ps=7.295e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.0485e-13 pd=1.34e-06 \
        ps=4.77e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM20_ELT (MM20_ELT_d MM20_ELT_g MM20_ELT_s MM20_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet031_8 (net031_4 VSS) capacitor c=1.02159e-17
    cinet031_7 (net031_5 VSS) capacitor c=1.63273e-18
    cinet031_6 (net031_6 VSS) capacitor c=1.64973e-18
    cinet031_5 (net031_9 VSS) capacitor c=1.06831e-17
    cinet031_4 (MM20_ELT_s VSS) capacitor c=1.51415e-17
    cinet031_3 (net031_13 VSS) capacitor c=2.49285e-17
    cinet031_2 (net031_15 VSS) capacitor c=4.33274e-18
    cinet031_1 (net031_18 VSS) capacitor c=1.71175e-18
    cinet031_0 (net031_20 VSS) capacitor c=7.66866e-18
    ciQ_8 (Q_3 VSS) capacitor c=4.6394e-17
    ciQ_7 (Q_4 VSS) capacitor c=1.11643e-16
    ciQ_6 (Q_8 VSS) capacitor c=1.74524e-16
    ciQ_5 (Q_9 VSS) capacitor c=3.29382e-16
    ciQ_4 (Q_17 VSS) capacitor c=2.27486e-17
    ciQ_3 (Q_18 VSS) capacitor c=1.51823e-17
    ciQ_2 (Q_19 VSS) capacitor c=2.12404e-17
    ciQ_1 (Q_20 VSS) capacitor c=6.39014e-18
    ciQ_0 (Q VSS) capacitor c=7.0617e-17
    ciU_29 (U_22 VSS) capacitor c=4.28147e-18
    ciU_28 (U_28 VSS) capacitor c=1.94119e-16
    ciU_27 (U_39 VSS) capacitor c=5.68633e-16
    ciU_26 (U_45 VSS) capacitor c=5.13601e-18
    ciU_25 (U_50 VSS) capacitor c=2.23559e-17
    ciU_24 (U_58 VSS) capacitor c=1.51948e-17
    ciU_23 (U_66 VSS) capacitor c=1.88601e-17
    ciU_22 (U_74 VSS) capacitor c=9.56216e-18
    ciU_21 (U_82 VSS) capacitor c=2.11871e-18
    ciU_20 (U_85 VSS) capacitor c=2.742e-18
    ciU_19 (U_90 VSS) capacitor c=2.43312e-19
    ciU_18 (U_93 VSS) capacitor c=2.22299e-18
    ciU_17 (U_133 VSS) capacitor c=1.13119e-16
    ciU_16 (U_134 VSS) capacitor c=1.15884e-16
    ciU_15 (U_136 VSS) capacitor c=1.23258e-16
    ciU_14 (U_137 VSS) capacitor c=1.91781e-17
    ciU_13 (U_140 VSS) capacitor c=3.35873e-17
    ciU_12 (U_141 VSS) capacitor c=1.36256e-16
    ciU_11 (U_143 VSS) capacitor c=7.98482e-17
    ciU_10 (U_144 VSS) capacitor c=8.08456e-18
    ciU_9 (U_146 VSS) capacitor c=1.11976e-16
    ciU_8 (U_148 VSS) capacitor c=1.75165e-16
    ciU_7 (U_149 VSS) capacitor c=7.75494e-17
    ciU_6 (U_150 VSS) capacitor c=1.90484e-17
    ciU_5 (U_151 VSS) capacitor c=1.71292e-17
    ciU_4 (U_152 VSS) capacitor c=7.3222e-18
    ciU_3 (U_155 VSS) capacitor c=1.35224e-17
    ciU_2 (U_157 VSS) capacitor c=2.13311e-17
    ciU_1 (U_217 VSS) capacitor c=2.95293e-17
    ciU_0 (U_218 VSS) capacitor c=1.65792e-17
    ciVDD_30 (VDD_4 VSS) capacitor c=4.87874e-17
    ciVDD_29 (VDD_7 VSS) capacitor c=6.37443e-17
    ciVDD_28 (VDD_8 VSS) capacitor c=2.63453e-17
    ciVDD_27 (VDD_17 VSS) capacitor c=6.4505e-17
    ciVDD_26 (VDD_18 VSS) capacitor c=1.21446e-16
    ciVDD_25 (VDD_20 VSS) capacitor c=7.45149e-17
    ciVDD_24 (VDD_27 VSS) capacitor c=8.80493e-17
    ciVDD_23 (VDD_28 VSS) capacitor c=9.3734e-17
    ciVDD_22 (VDD_30 VSS) capacitor c=1.07795e-16
    ciVDD_21 (VDD_40 VSS) capacitor c=2.4079e-16
    ciVDD_20 (VDD_48 VSS) capacitor c=3.64928e-16
    ciVDD_19 (VDD_51 VSS) capacitor c=7.23454e-17
    ciVDD_18 (VDD_58 VSS) capacitor c=3.58509e-18
    ciVDD_17 (VDD_60 VSS) capacitor c=3.58509e-18
    ciVDD_16 (VDD_62 VSS) capacitor c=3.58509e-18
    ciVDD_15 (VDD_68 VSS) capacitor c=1.71175e-18
    ciVDD_14 (VDD_69 VSS) capacitor c=5.38469e-18
    ciVDD_13 (VDD_70 VSS) capacitor c=1.64973e-18
    ciVDD_12 (VDD_73 VSS) capacitor c=9.2188e-18
    ciVDD_11 (VDD_74 VSS) capacitor c=1.66627e-17
    ciVDD_10 (VDD_78 VSS) capacitor c=1.71175e-18
    ciVDD_9 (VDD_80 VSS) capacitor c=9.73151e-18
    ciVDD_8 (MM17_ELT_s VSS) capacitor c=5.37432e-17
    ciVDD_7 (VDD_85 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_87 VSS) capacitor c=8.10776e-18
    ciVDD_5 (VDD_91 VSS) capacitor c=1.11099e-18
    ciVDD_4 (VDD_92 VSS) capacitor c=8.79289e-18
    ciVDD_3 (VDD_93 VSS) capacitor c=1.07074e-18
    ciVDD_2 (VDD_96 VSS) capacitor c=2.18215e-17
    ciVDD_1 (VDD_97 VSS) capacitor c=7.61352e-17
    ciVDD_0 (VDD_101 VSS) capacitor c=1.23039e-17
    ciVSS_30 (VSS_4 VSS) capacitor c=5.29953e-17
    ciVSS_29 (VSS_10 VSS) capacitor c=4.60938e-17
    ciVSS_28 (VSS_11 VSS) capacitor c=2.63635e-17
    ciVSS_27 (VSS_17 VSS) capacitor c=7.94461e-17
    ciVSS_26 (VSS_18 VSS) capacitor c=7.92333e-19
    ciVSS_25 (VSS_23 VSS) capacitor c=8.8162e-17
    ciVSS_24 (VSS_30 VSS) capacitor c=9.55659e-17
    ciVSS_23 (VSS_31 VSS) capacitor c=1.25484e-16
    ciVSS_22 (VSS_33 VSS) capacitor c=1.01894e-16
    ciVSS_21 (VSS_43 VSS) capacitor c=1.00927e-16
    ciVSS_20 (VSS_47 VSS) capacitor c=1.36362e-16
    ciVSS_19 (VSS_51 VSS) capacitor c=7.05655e-17
    ciVSS_18 (VSS_59 VSS) capacitor c=3.58509e-18
    ciVSS_17 (VSS_62 VSS) capacitor c=3.58509e-18
    ciVSS_16 (VSS_64 VSS) capacitor c=3.58509e-18
    ciVSS_15 (MM1_ELT_s VSS) capacitor c=5.08702e-18
    ciVSS_14 (VSS_70 VSS) capacitor c=7.18432e-18
    ciVSS_13 (VSS_78 VSS) capacitor c=1.27885e-18
    ciVSS_12 (VSS_79 VSS) capacitor c=9.00521e-19
    ciVSS_11 (VSS_82 VSS) capacitor c=9.63361e-18
    ciVSS_10 (MM3_ELT_s VSS) capacitor c=3.18658e-18
    ciVSS_9 (VSS_89 VSS) capacitor c=2.91606e-18
    ciVSS_8 (VSS_94 VSS) capacitor c=3.05113e-18
    ciVSS_7 (VSS_95 VSS) capacitor c=3.58595e-18
    ciVSS_6 (VSS_98 VSS) capacitor c=7.71031e-18
    ciVSS_5 (MM19_ELT_s VSS) capacitor c=2.49855e-18
    ciVSS_4 (VSS_110 VSS) capacitor c=7.41651e-18
    ciVSS_3 (VSS_114 VSS) capacitor c=6.23788e-18
    ciVSS_2 (VSS_120 VSS) capacitor c=3.59239e-18
    ciVSS_1 (VSS_127 VSS) capacitor c=7.02138e-17
    ciVSS_0 (VSS_129 VSS) capacitor c=7.18053e-17
    ciCDN_13 (CDN_22 VSS) capacitor c=3.47556e-18
    ciCDN_12 (CDN_28 VSS) capacitor c=2.16149e-16
    ciCDN_11 (CDN_39 VSS) capacitor c=6.60007e-16
    ciCDN_10 (CDN_45 VSS) capacitor c=3.49893e-18
    ciCDN_9 (CDN_50 VSS) capacitor c=2.20514e-17
    ciCDN_8 (CDN_58 VSS) capacitor c=1.57254e-17
    ciCDN_7 (CDN_66 VSS) capacitor c=1.12515e-17
    ciCDN_6 (CDN_74 VSS) capacitor c=1.51948e-17
    ciCDN_5 (CDN_82 VSS) capacitor c=3.00043e-18
    ciCDN_4 (CDN_85 VSS) capacitor c=2.4816e-18
    ciCDN_3 (CDN_90 VSS) capacitor c=5.15427e-18
    ciCDN_2 (CDN_93 VSS) capacitor c=3.85496e-18
    ciCDN_1 (CDN VSS) capacitor c=6.0042e-17
    ciCDN_0 (CDN_203 VSS) capacitor c=4.06785e-17
    cinet027_13 (net027_3 VSS) capacitor c=6.76806e-17
    cinet027_12 (net027_4 VSS) capacitor c=1.14369e-16
    cinet027_11 (net027_6 VSS) capacitor c=1.6082e-16
    cinet027_10 (net027_7 VSS) capacitor c=1.63787e-17
    cinet027_9 (net027_10 VSS) capacitor c=6.81705e-17
    cinet027_8 (net027_13 VSS) capacitor c=4.97622e-17
    cinet027_7 (net027_14 VSS) capacitor c=1.13317e-17
    cinet027_6 (net027_16 VSS) capacitor c=5.23243e-17
    cinet027_5 (net027_20 VSS) capacitor c=1.48334e-17
    cinet027_4 (net027_22 VSS) capacitor c=1.47573e-18
    cinet027_3 (net027_23 VSS) capacitor c=7.65531e-18
    cinet027_2 (net027_24 VSS) capacitor c=4.84428e-18
    cinet027_1 (net027_25 VSS) capacitor c=3.46955e-18
    cinet027_0 (net027_26 VSS) capacitor c=1.11523e-16
    ciCDNN_41 (CDNN_22 VSS) capacitor c=4.09792e-18
    ciCDNN_40 (CDNN_25 VSS) capacitor c=5.80296e-18
    ciCDNN_39 (CDNN_28 VSS) capacitor c=1.80707e-16
    ciCDNN_38 (CDNN_30 VSS) capacitor c=1.9207e-17
    ciCDNN_37 (CDNN_38 VSS) capacitor c=2.2395e-17
    ciCDNN_36 (CDNN_55 VSS) capacitor c=3.77138e-18
    ciCDNN_35 (CDNN_60 VSS) capacitor c=2.96436e-18
    ciCDNN_34 (CDNN_66 VSS) capacitor c=2.18891e-16
    ciCDNN_33 (CDNN_74 VSS) capacitor c=2.20514e-17
    ciCDNN_32 (CDNN_82 VSS) capacitor c=1.99129e-17
    ciCDNN_31 (CDNN_90 VSS) capacitor c=3.48049e-18
    ciCDNN_30 (CDNN_93 VSS) capacitor c=5.65999e-18
    ciCDNN_29 (CDNN_131 VSS) capacitor c=6.13785e-17
    ciCDNN_28 (CDNN_139 VSS) capacitor c=8.31063e-18
    ciCDNN_27 (CDNN_140 VSS) capacitor c=4.87083e-17
    ciCDNN_26 (CDNN_141 VSS) capacitor c=2.09105e-17
    ciCDNN_25 (CDNN_143 VSS) capacitor c=1.18001e-17
    ciCDNN_24 (CDNN_144 VSS) capacitor c=1.54616e-17
    ciCDNN_23 (CDNN_146 VSS) capacitor c=5.75563e-17
    ciCDNN_22 (CDNN_147 VSS) capacitor c=4.27194e-17
    ciCDNN_21 (CDNN_153 VSS) capacitor c=1.57635e-16
    ciCDNN_20 (CDNN_159 VSS) capacitor c=8.39757e-18
    ciCDNN_19 (CDNN_160 VSS) capacitor c=7.11474e-17
    ciCDNN_18 (CDNN_162 VSS) capacitor c=8.51599e-18
    ciCDNN_17 (CDNN_166 VSS) capacitor c=1.05687e-17
    ciCDNN_16 (CDNN_169 VSS) capacitor c=5.38286e-17
    ciCDNN_15 (CDNN_172 VSS) capacitor c=9.39297e-17
    ciCDNN_14 (CDNN_173 VSS) capacitor c=3.00501e-17
    ciCDNN_13 (CDNN_174 VSS) capacitor c=1.07909e-17
    ciCDNN_12 (CDNN_175 VSS) capacitor c=3.69533e-17
    ciCDNN_11 (CDNN_179 VSS) capacitor c=9.63813e-18
    ciCDNN_10 (CDNN_180 VSS) capacitor c=7.93597e-17
    ciCDNN_9 (CDNN_187 VSS) capacitor c=2.68394e-17
    ciCDNN_8 (CDNN_188 VSS) capacitor c=4.54539e-17
    ciCDNN_7 (CDNN_189 VSS) capacitor c=5.54143e-18
    ciCDNN_6 (CDNN_190 VSS) capacitor c=1.17397e-17
    ciCDNN_5 (CDNN_192 VSS) capacitor c=2.53969e-17
    ciCDNN_4 (CDNN_193 VSS) capacitor c=7.90441e-17
    ciCDNN_3 (CDNN_235 VSS) capacitor c=1.45816e-17
    ciCDNN_2 (CDNN_252 VSS) capacitor c=5.34489e-17
    ciCDNN_1 (CDNN_263 VSS) capacitor c=1.07921e-16
    ciCDNN_0 (CDNN_270 VSS) capacitor c=3.70223e-16
    ciY_36 (Y_22 VSS) capacitor c=4.06555e-18
    ciY_35 (Y_28 VSS) capacitor c=2.00912e-16
    ciY_34 (Y_36 VSS) capacitor c=2.23438e-17
    ciY_33 (Y_44 VSS) capacitor c=2.17311e-17
    ciY_32 (Y_52 VSS) capacitor c=2.96436e-18
    ciY_31 (Y_55 VSS) capacitor c=8.13032e-18
    ciY_30 (Y_60 VSS) capacitor c=4.21118e-18
    ciY_29 (Y_63 VSS) capacitor c=3.2371e-18
    ciY_28 (Y_66 VSS) capacitor c=1.90514e-16
    ciY_27 (Y_68 VSS) capacitor c=1.98618e-17
    ciY_26 (Y_76 VSS) capacitor c=2.2351e-17
    ciY_25 (Y_87 VSS) capacitor c=3.36897e-18
    ciY_24 (Y_131 VSS) capacitor c=4.71609e-17
    ciY_23 (Y_133 VSS) capacitor c=1.03226e-17
    ciY_22 (Y_134 VSS) capacitor c=1.32868e-17
    ciY_21 (Y_137 VSS) capacitor c=5.33065e-17
    ciY_20 (Y_138 VSS) capacitor c=1.22065e-16
    ciY_19 (Y_140 VSS) capacitor c=1.91794e-17
    ciY_18 (Y_141 VSS) capacitor c=5.35348e-17
    ciY_17 (Y_142 VSS) capacitor c=1.80716e-16
    ciY_16 (Y_148 VSS) capacitor c=5.31562e-17
    ciY_15 (Y_149 VSS) capacitor c=5.28663e-17
    ciY_14 (Y_154 VSS) capacitor c=1.21756e-16
    ciY_13 (Y_156 VSS) capacitor c=8.06386e-18
    ciY_12 (Y_158 VSS) capacitor c=5.24527e-17
    ciY_11 (Y_159 VSS) capacitor c=2.83734e-17
    ciY_10 (Y_162 VSS) capacitor c=1.86053e-16
    ciY_9 (Y_163 VSS) capacitor c=4.32148e-17
    ciY_8 (Y_166 VSS) capacitor c=3.22836e-17
    ciY_7 (Y_168 VSS) capacitor c=6.66044e-17
    ciY_6 (Y_169 VSS) capacitor c=9.91609e-18
    ciY_5 (Y_172 VSS) capacitor c=9.44285e-18
    ciY_4 (Y_173 VSS) capacitor c=9.62357e-17
    ciY_3 (Y_177 VSS) capacitor c=2.39782e-17
    ciY_2 (Y_202 VSS) capacitor c=1.41708e-17
    ciY_1 (Y_231 VSS) capacitor c=8.1431e-18
    ciY_0 (Y_252 VSS) capacitor c=1.11366e-16
    cinet026_11 (net026_3 VSS) capacitor c=1.1171e-16
    cinet026_10 (net026_8 VSS) capacitor c=4.24412e-17
    cinet026_9 (net026_9 VSS) capacitor c=1.37932e-16
    cinet026_8 (net026_11 VSS) capacitor c=7.82598e-17
    cinet026_7 (net026_12 VSS) capacitor c=1.40423e-17
    cinet026_6 (net026_13 VSS) capacitor c=4.88642e-17
    cinet026_5 (net026_14 VSS) capacitor c=1.54195e-17
    cinet026_4 (net026_16 VSS) capacitor c=6.49753e-17
    cinet026_3 (net026_20 VSS) capacitor c=6.52499e-19
    cinet026_2 (net026_22 VSS) capacitor c=2.36596e-18
    cinet026_1 (net026_25 VSS) capacitor c=7.30039e-18
    cinet026_0 (net026_26 VSS) capacitor c=8.85041e-17
    ciX_20 (X_14 VSS) capacitor c=3.00043e-18
    ciX_19 (X_17 VSS) capacitor c=2.05848e-18
    ciX_18 (X_20 VSS) capacitor c=2.2337e-16
    ciX_17 (X_22 VSS) capacitor c=2.23559e-17
    ciX_16 (X_30 VSS) capacitor c=1.3338e-17
    ciX_15 (X_44 VSS) capacitor c=1.34086e-17
    ciX_14 (X_52 VSS) capacitor c=4.04637e-18
    ciX_13 (X_55 VSS) capacitor c=3.95367e-18
    ciX_12 (X_82 VSS) capacitor c=5.44789e-17
    ciX_11 (X_83 VSS) capacitor c=1.24359e-16
    ciX_10 (X_87 VSS) capacitor c=4.13186e-17
    ciX_9 (X_88 VSS) capacitor c=1.13426e-16
    ciX_8 (X_90 VSS) capacitor c=2.67323e-17
    ciX_7 (X_91 VSS) capacitor c=1.54882e-17
    ciX_6 (X_93 VSS) capacitor c=4.85816e-17
    ciX_5 (X_95 VSS) capacitor c=4.52626e-17
    ciX_4 (X_98 VSS) capacitor c=1.18929e-16
    ciX_3 (X_103 VSS) capacitor c=2.92607e-17
    ciX_2 (X_105 VSS) capacitor c=1.1744e-17
    ciX_1 (X_143 VSS) capacitor c=2.01281e-17
    ciX_0 (X_144 VSS) capacitor c=4.06295e-17
    cinet29_10 (net29_3 VSS) capacitor c=4.49009e-17
    cinet29_9 (net29_4 VSS) capacitor c=1.26373e-16
    cinet29_8 (net29_6 VSS) capacitor c=2.26661e-17
    cinet29_7 (net29_7 VSS) capacitor c=1.48555e-17
    cinet29_6 (net29_10 VSS) capacitor c=1.50274e-16
    cinet29_5 (net29_11 VSS) capacitor c=5.71583e-18
    cinet29_4 (MM10_ELT_s VSS) capacitor c=3.97088e-18
    cinet29_3 (net29_15 VSS) capacitor c=1.1046e-16
    cinet29_2 (net29_17 VSS) capacitor c=1.71175e-18
    cinet29_1 (net29_18 VSS) capacitor c=2.96186e-18
    cinet29_0 (net29_19 VSS) capacitor c=7.54204e-18
    ciCP_44 (CP_45 VSS) capacitor c=1.71401e-16
    ciCP_43 (CP_51 VSS) capacitor c=3.55739e-18
    ciCP_42 (CP_56 VSS) capacitor c=2.49885e-17
    ciCP_41 (CP_64 VSS) capacitor c=2.76145e-17
    ciCP_40 (CP_72 VSS) capacitor c=9.00885e-18
    ciCP_39 (CP_75 VSS) capacitor c=5.8276e-18
    ciCP_38 (CP_80 VSS) capacitor c=1.78348e-18
    ciCP_37 (CP_83 VSS) capacitor c=2.79328e-18
    ciCP_36 (CP_86 VSS) capacitor c=1.5978e-16
    ciCP_35 (CP_88 VSS) capacitor c=1.57718e-17
    ciCP_34 (CP_96 VSS) capacitor c=2.17037e-17
    ciCP_33 (CP_104 VSS) capacitor c=9.83896e-18
    ciCP_32 (CP_110 VSS) capacitor c=2.06938e-16
    ciCP_31 (CP_127 VSS) capacitor c=4.26554e-18
    ciCP_30 (CP_132 VSS) capacitor c=3.21652e-17
    ciCP_29 (CP_140 VSS) capacitor c=1.9725e-17
    ciCP_28 (CP_148 VSS) capacitor c=4.09251e-18
    ciCP_27 (CP_151 VSS) capacitor c=1.7885e-18
    ciCP_26 (CP_156 VSS) capacitor c=1.02225e-17
    ciCP_25 (CP_159 VSS) capacitor c=4.39198e-18
    ciCP_24 (CP_162 VSS) capacitor c=2.24246e-16
    ciCP_23 (CP_164 VSS) capacitor c=3.01078e-17
    ciCP_22 (CP_172 VSS) capacitor c=2.28928e-17
    ciCP_21 (CP_180 VSS) capacitor c=3.07359e-17
    ciCP_20 (CP_261 VSS) capacitor c=4.68928e-17
    ciCP_19 (CP_268 VSS) capacitor c=1.08973e-17
    ciCP_18 (CP_270 VSS) capacitor c=4.81879e-17
    ciCP_17 (CP_277 VSS) capacitor c=1.2887e-17
    ciCP_16 (CP_278 VSS) capacitor c=2.01711e-17
    ciCP_15 (CP_280 VSS) capacitor c=4.25065e-17
    ciCP_14 (CP_281 VSS) capacitor c=7.24219e-18
    ciCP_13 (CP_282 VSS) capacitor c=9.76661e-18
    ciCP_12 (CP_283 VSS) capacitor c=1.27382e-16
    ciCP_11 (CP_284 VSS) capacitor c=9.53366e-17
    ciCP_10 (CP_285 VSS) capacitor c=1.12041e-17
    ciCP_9 (CP_286 VSS) capacitor c=5.56131e-18
    ciCP_8 (CP_287 VSS) capacitor c=6.82633e-17
    ciCP_7 (CP_292 VSS) capacitor c=1.61109e-16
    ciCP_6 (CP_294 VSS) capacitor c=2.23335e-17
    ciCP_5 (CP_416 VSS) capacitor c=2.36158e-17
    ciCP_4 (CP_417 VSS) capacitor c=2.29644e-17
    ciCP_3 (CP_426 VSS) capacitor c=2.38263e-17
    ciCP_2 (CP_427 VSS) capacitor c=3.40575e-17
    ciCP_1 (CP_432 VSS) capacitor c=1.27629e-16
    ciCP_0 (CP_436 VSS) capacitor c=5.49577e-17
    ciD_18 (D_22 VSS) capacitor c=2.9802e-18
    ciD_17 (D_25 VSS) capacitor c=5.03564e-18
    ciD_16 (D_28 VSS) capacitor c=2.19709e-16
    ciD_15 (D_33 VSS) capacitor c=2.05342e-16
    ciD_14 (D_39 VSS) capacitor c=3.77327e-18
    ciD_13 (D_44 VSS) capacitor c=2.23446e-17
    ciD_12 (D_52 VSS) capacitor c=2.63575e-17
    ciD_11 (D_60 VSS) capacitor c=1.92953e-17
    ciD_10 (D_68 VSS) capacitor c=2.23559e-17
    ciD_9 (D_76 VSS) capacitor c=3.24866e-18
    ciD_8 (D_90 VSS) capacitor c=4.2875e-18
    ciD_7 (D_93 VSS) capacitor c=4.11871e-18
    ciD_6 (D VSS) capacitor c=4.02059e-17
    ciD_5 (D_173 VSS) capacitor c=7.02654e-17
    ciD_4 (D_194 VSS) capacitor c=3.11323e-17
    ciD_3 (D_195 VSS) capacitor c=1.05112e-17
    ciD_2 (D_197 VSS) capacitor c=1.93089e-16
    ciD_1 (D_200 VSS) capacitor c=2.43222e-17
    ciD_0 (D_201 VSS) capacitor c=4.44047e-18
    rnet031_37 (net031_1 net031_4) resistor r=20.2547
    rnet031_36 (net031_1 net031_5) resistor r=9.04595
    rnet031_35 (net031_2 net031_4) resistor r=20.2547
    rnet031_34 (net031_2 net031_8) resistor r=9.04062
    rnet031_33 (MM9_ELT_d net031_4) resistor r=4.36821
    rnet031_32 (MM9_ELT_d net031_6) resistor r=12.3172
    rnet031_31 (MM9_ELT_d net031_6) resistor r=1.62887
    rnet031_30 (MM9_ELT_d net031_9) resistor r=2.55965
    rnet031_29 (MM9_ELT_d net031_13) resistor r=4.04518
    rnet031_28 (MM9_ELT_d net031_20) resistor r=10.2363
    rnet031_27 (net031_5 net031_6) resistor r=12.3172
    rnet031_26 (net031_7 net031_9) resistor r=14.4784
    rnet031_25 (net031_7 net031) resistor r=10.5593
    rnet031_24 (net031_8 net031_9) resistor r=14.4784
    rnet031_23 (net031_10 net031_13) resistor r=4.04518
    rnet031_22 (net031_10 net031_20) resistor r=0.549089
    rnet031_21 (net031_11 net031_13) resistor r=4.04518
    rnet031_20 (net031_11 net031) resistor r=0.730683
    rnet031_19 (MM20_ELT_s net031_13) resistor r=4.04518
    rnet031_18 (MM20_ELT_s net031_15) resistor r=12.3172
    rnet031_17 (MM20_ELT_s net031_15) resistor r=1.62887
    rnet031_16 (MM20_ELT_s net031_18) resistor r=2.55965
    rnet031_15 (MM20_ELT_s net031_19) resistor r=17.3029
    rnet031_14 (net031_14 net031_15) resistor r=12.3172
    rnet031_13 (net031_14 net031_20) resistor r=10.2363
    rnet031_12 (net031_16 net031_18) resistor r=14.4784
    rnet031_11 (net031_16 net031_19) resistor r=9.04062
    rnet031_10 (net031_17 net031_18) resistor r=14.4784
    rnet031_9 (net031_17 net031) resistor r=10.5593
    rQ_28 (Q_1 Q_3) resistor r=0.303819
    rQ_27 (Q_1 Q_18) resistor r=0.0961082
    rQ_26 (Q_3 Q_4) resistor r=13
    rQ_25 (Q_4 MM4_ELT_d) resistor r=8.44
    rQ_24 (Q_6 Q_8) resistor r=0.341131
    rQ_23 (Q_6 Q_20) resistor r=0.0961082
    rQ_22 (Q_8 Q_9) resistor r=8.66667
    rQ_21 (Q_8 Q_11) resistor r=0.63962
    rQ_20 (Q_9 MM7_ELT_d) resistor r=32.3614
    rQ_19 (Q_11 Q_12) resistor r=8.66667
    rQ_18 (Q_11 Q_14) resistor r=0.426413
    rQ_17 (Q_12 MM7_ELT_d) resistor r=16.1807
    rQ_16 (Q_12 Q_15) resistor r=32.3614
    rQ_15 (Q_14 Q_15) resistor r=26
    rQ_14 (Q_17 Q_18) resistor r=0.136655
    rQ_13 (Q_17 Q_21) resistor r=0.0961082
    rQ_12 (Q_19 Q_20) resistor r=0.136655
    rQ_11 (Q_19 Q_22) resistor r=0.0961082
    rQ_10 (Q_21 Q) resistor r=0.156178
    rQ_9 (Q_22 Q) resistor r=0.536353
    rU_132 (MM8_ELT_d U) resistor r=0.01
    rU_131 (U_22 U_28) resistor r=58.3583
    rU_130 (U_22 U_28) resistor r=4.16253
    rU_129 (U_22 U_28) resistor r=58.3583
    rU_128 (U_22 U_28) resistor r=4.16253
    rU_127 (U_25 U_28) resistor r=58.3583
    rU_126 (U_25 U_28) resistor r=5.53947
    rU_125 (U_25 U_28) resistor r=58.3583
    rU_124 (U_25 U_28) resistor r=5.53947
    rU_123 (U_28 U_30) resistor r=11.175
    rU_122 (U_28 U_53) resistor r=24.8333
    rU_121 (U_28 U_50) resistor r=24.8333
    rU_120 (U_28 U_69) resistor r=22.35
    rU_119 (U_28 U_66) resistor r=22.35
    rU_118 (U_28 U_82) resistor r=58.3583
    rU_117 (U_28 U_85) resistor r=58.3583
    rU_116 (U_28 U_53) resistor r=4.16253
    rU_115 (U_28 U_30) resistor r=5.53947
    rU_114 (U_28 U_69) resistor r=2.32428
    rU_113 (U_28 U_50) resistor r=4.16253
    rU_112 (U_28 U_82) resistor r=4.16253
    rU_111 (U_28 U_66) resistor r=4.16253
    rU_110 (U_28 U_85) resistor r=4.16253
    rU_109 (U_28 U_30) resistor r=11.175
    rU_108 (U_28 U_183) resistor r=29.8
    rU_107 (U_28 U_53) resistor r=24.8333
    rU_106 (U_28 U_50) resistor r=24.8333
    rU_105 (U_28 U_69) resistor r=22.35
    rU_104 (U_28 U_66) resistor r=22.35
    rU_103 (U_28 U_82) resistor r=58.3583
    rU_102 (U_28 MM4_ELT_g) resistor r=7.45
    rU_101 (U_28 U_53) resistor r=4.16253
    rU_100 (U_28 U_30) resistor r=5.53947
    rU_99 (U_28 U_69) resistor r=2.32428
    rU_98 (U_28 U_50) resistor r=4.16253
    rU_97 (U_28 U_82) resistor r=4.16253
    rU_96 (U_28 U_66) resistor r=4.16253
    rU_95 (U_28 U_85) resistor r=4.16253
    rU_94 (U_36 U_39) resistor r=11.175
    rU_93 (U_36 U_39) resistor r=5.53947
    rU_92 (U_36 U_39) resistor r=11.175
    rU_91 (U_36 U_39) resistor r=5.53947
    rU_90 (U_39 U_42) resistor r=202.392
    rU_89 (U_39 U_45) resistor r=202.392
    rU_88 (U_39 U_61) resistor r=24.8333
    rU_87 (U_39 U_58) resistor r=24.8333
    rU_86 (U_39 U_77) resistor r=22.35
    rU_85 (U_39 U_74) resistor r=22.35
    rU_84 (U_39 U_90) resistor r=202.392
    rU_83 (U_39 U_93) resistor r=202.392
    rU_82 (U_39 U_42) resistor r=5.53947
    rU_81 (U_39 U_77) resistor r=2.32428
    rU_80 (U_39 U_61) resistor r=4.16253
    rU_79 (U_39 U_45) resistor r=4.16253
    rU_78 (U_39 U_74) resistor r=4.16253
    rU_77 (U_39 U_90) resistor r=4.16253
    rU_76 (U_39 U_58) resistor r=4.16253
    rU_75 (U_39 U_93) resistor r=4.16253
    rU_74 (U_39 U_185) resistor r=31.6625
    rU_73 (U_39 U_42) resistor r=202.392
    rU_72 (U_39 U_45) resistor r=202.392
    rU_71 (U_39 U_61) resistor r=24.8333
    rU_70 (U_39 U_58) resistor r=24.8333
    rU_69 (U_39 U_77) resistor r=22.35
    rU_68 (U_39 U_74) resistor r=22.35
    rU_67 (U_39 U_90) resistor r=202.392
    rU_66 (U_39 MM7_ELT_g) resistor r=7.45
    rU_65 (U_39 U_42) resistor r=5.53947
    rU_64 (U_39 U_77) resistor r=2.32428
    rU_63 (U_39 U_61) resistor r=4.16253
    rU_62 (U_39 U_45) resistor r=4.16253
    rU_61 (U_39 U_74) resistor r=4.16253
    rU_60 (U_39 U_90) resistor r=4.16253
    rU_59 (U_39 U_58) resistor r=4.16253
    rU_58 (U_39 U_93) resistor r=4.16253
    rU_57 (U_85 MM4_ELT_g) resistor r=50.9083
    rU_56 (U_93 MM7_ELT_g) resistor r=194.942
    rU_55 (U_131 U_133) resistor r=0.560161
    rU_54 (U_131 U_137) resistor r=0.0973635
    rU_53 (U_133 U_134) resistor r=13
    rU_52 (U_134 MM5_ELT_d) resistor r=8.44
    rU_51 (U_136 U_137) resistor r=1.40944
    rU_50 (U_136 U_155) resistor r=0.0189293
    rU_49 (U_138 U_140) resistor r=0.207876
    rU_48 (U_138 U_144) resistor r=0.0961082
    rU_47 (U_140 U_141) resistor r=13
    rU_46 (U_141 U) resistor r=8.09035
    rU_45 (U_143 U_144) resistor r=0.694928
    rU_44 (U_143 U_148) resistor r=0.0961082
    rU_43 (U_145 U_146) resistor r=0.767453
    rU_42 (U_145 U_150) resistor r=0.0961082
    rU_41 (U_146 U_155) resistor r=0.0728377
    rU_40 (U_147 U_148) resistor r=1.43897
    rU_39 (U_147 U_155) resistor r=0.0728377
    rU_38 (U_149 U_150) resistor r=0.575601
    rU_37 (U_149 U_152) resistor r=0.0961082
    rU_36 (U_151 U_152) resistor r=0.102568
    rU_35 (U_151 U_157) resistor r=0.0709056
    rU_34 (U_157 U_158) resistor r=10
    rU_33 (U_158 U_217) resistor r=7.45
    rU_32 (U_183 U_218) resistor r=3.725
    rU_31 (U_185 U_218) resistor r=3.725
    rU_30 (U_217 U_218) resistor r=3.725
    rVDD_139 (MM11_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_138 (MM9_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_137 (MM20_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_136 (MM8_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_135 (MM17_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_134 (MM7_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_133 (MM10_ELT_b VDD_60) resistor r=8.66667
    rVDD_132 (MM10_ELT_b VDD_24) resistor r=67.52
    rVDD_131 (MM10_ELT_b VDD_34) resistor r=67.52
    rVDD_130 (VDD_2 VDD_4) resistor r=0.511696
    rVDD_129 (VDD_2 VDD_57) resistor r=0.119235
    rVDD_128 (VDD_4 VDD_5) resistor r=8.66667
    rVDD_127 (VDD_5 MM11_ELT_s) resistor r=2.78649
    rVDD_126 (VDD_5 VDD_97) resistor r=11.6377
    rVDD_125 (VDD_7 VDD_13) resistor r=0.0652437
    rVDD_124 (VDD_7 VDD_58) resistor r=0.0221617
    rVDD_123 (VDD_8 VDD_10) resistor r=0.0336104
    rVDD_122 (VDD_8 VDD_57) resistor r=0.0177937
    rVDD_121 (VDD_10 VDD_11) resistor r=8.66667
    rVDD_120 (VDD_10 VDD_13) resistor r=0.23725
    rVDD_119 (VDD_11 VDD_14) resistor r=67.52
    rVDD_118 (VDD_13 VDD_14) resistor r=8.66667
    rVDD_117 (VDD_14 VDD_24) resistor r=67.52
    rVDD_116 (VDD_15 VDD_17) resistor r=0.641412
    rVDD_115 (VDD_15 VDD_58) resistor r=0.0882496
    rVDD_114 (VDD_17 VDD_18) resistor r=13
    rVDD_113 (VDD_18 MM9_ELT_s) resistor r=8.09035
    rVDD_112 (VDD_20 VDD_23) resistor r=0.221433
    rVDD_111 (VDD_20 VDD_60) resistor r=0.0221617
    rVDD_110 (VDD_21 VDD_23) resistor r=0.136419
    rVDD_109 (VDD_21 VDD_58) resistor r=0.0221617
    rVDD_108 (VDD_23 VDD_24) resistor r=8.66667
    rVDD_107 (VDD_25 VDD_27) resistor r=0.511696
    rVDD_106 (VDD_25 VDD_60) resistor r=0.0882496
    rVDD_105 (VDD_27 VDD_28) resistor r=8.66667
    rVDD_104 (VDD_28 VDD_99) resistor r=16.4995
    rVDD_103 (VDD_28 VDD_98) resistor r=16.4995
    rVDD_102 (VDD_28 MM8_ELT_s) resistor r=3.29107
    rVDD_101 (VDD_30 VDD_36) resistor r=0.0415187
    rVDD_100 (VDD_30 VDD_62) resistor r=0.0221617
    rVDD_99 (VDD_31 VDD_33) resistor r=0.217479
    rVDD_98 (VDD_31 VDD_60) resistor r=0.0221617
    rVDD_97 (VDD_33 VDD_34) resistor r=8.66667
    rVDD_96 (VDD_33 VDD_36) resistor r=0.23725
    rVDD_95 (VDD_34 VDD_37) resistor r=67.52
    rVDD_94 (VDD_36 VDD_37) resistor r=8.66667
    rVDD_93 (VDD_37 VDD_52) resistor r=67.52
    rVDD_92 (VDD_38 VDD_47) resistor r=0.53838
    rVDD_91 (VDD_38 VDD_62) resistor r=0.0882496
    rVDD_90 (VDD_40 VDD_48) resistor r=8.66667
    rVDD_89 (VDD_40 VDD_44) resistor r=0.720666
    rVDD_88 (VDD_44 VDD_48) resistor r=8.66667
    rVDD_87 (VDD_44 VDD_47) resistor r=0.468157
    rVDD_86 (VDD_47 VDD_48) resistor r=13
    rVDD_85 (VDD_48 MM7_ELT_s) resistor r=4.04518
    rVDD_84 (VDD_48 VDD_102) resistor r=4.04518
    rVDD_83 (VDD_48 MM17_ELT_s) resistor r=4.04518
    rVDD_82 (VDD_48 VDD_100) resistor r=4.04518
    rVDD_81 (VDD_49 VDD_51) resistor r=0.160144
    rVDD_80 (VDD_49 VDD_62) resistor r=0.0221617
    rVDD_79 (VDD_51 VDD_52) resistor r=8.66667
    rVDD_78 (VDD VDD_57) resistor r=0.0514041
    rVDD_77 (MM11_ELT_s VDD_68) resistor r=2.55965
    rVDD_76 (MM11_ELT_s VDD_70) resistor r=12.3172
    rVDD_75 (MM11_ELT_s VDD_70) resistor r=1.62887
    rVDD_74 (MM11_ELT_s VDD_73) resistor r=4.36821
    rVDD_73 (VDD_66 VDD_68) resistor r=14.4784
    rVDD_72 (VDD_66 VDD_72) resistor r=9.04062
    rVDD_71 (VDD_67 VDD_68) resistor r=14.4784
    rVDD_70 (VDD_67 VDD_97) resistor r=9.48555
    rVDD_69 (VDD_69 VDD_70) resistor r=12.3172
    rVDD_68 (VDD_69 VDD_71) resistor r=9.04595
    rVDD_67 (VDD_71 VDD_73) resistor r=20.2547
    rVDD_66 (VDD_72 VDD_73) resistor r=20.2547
    rVDD_65 (VDD_74 MM8_ELT_s) resistor r=13.564
    rVDD_64 (VDD_74 VDD_98) resistor r=9.39461
    rVDD_63 (MM8_ELT_s VDD_78) resistor r=2.55965
    rVDD_62 (MM8_ELT_s VDD_80) resistor r=18.4228
    rVDD_61 (MM8_ELT_s VDD_80) resistor r=3.88377
    rVDD_60 (VDD_76 VDD_78) resistor r=14.4784
    rVDD_59 (VDD_76 VDD_79) resistor r=9.04595
    rVDD_58 (VDD_77 VDD_78) resistor r=14.4784
    rVDD_57 (VDD_77 VDD_99) resistor r=9.48555
    rVDD_56 (VDD_79 VDD_80) resistor r=18.4228
    rVDD_55 (MM17_ELT_s VDD_82) resistor r=25.7298
    rVDD_54 (MM17_ELT_s VDD_85) resistor r=2.55965
    rVDD_53 (MM17_ELT_s VDD_87) resistor r=12.3172
    rVDD_52 (MM17_ELT_s VDD_87) resistor r=1.62887
    rVDD_51 (VDD_82 VDD_84) resistor r=9.04062
    rVDD_50 (VDD_83 VDD_85) resistor r=14.4784
    rVDD_49 (VDD_83 VDD_103) resistor r=10.5593
    rVDD_48 (VDD_84 VDD_85) resistor r=14.4784
    rVDD_47 (VDD_86 VDD_87) resistor r=12.3172
    rVDD_46 (VDD_86 VDD_101) resistor r=10.2363
    rVDD_45 (MM7_ELT_s VDD_91) resistor r=2.55965
    rVDD_44 (MM7_ELT_s VDD_93) resistor r=11.6604
    rVDD_43 (MM7_ELT_s VDD_93) resistor r=1.30988
    rVDD_42 (MM7_ELT_s VDD_96) resistor r=6.12113
    rVDD_41 (MM7_ELT_s VDD_101) resistor r=10.2363
    rVDD_40 (VDD_89 VDD_91) resistor r=14.4784
    rVDD_39 (VDD_89 VDD_95) resistor r=9.04062
    rVDD_38 (VDD_90 VDD_91) resistor r=14.4784
    rVDD_37 (VDD_90 VDD_103) resistor r=10.5593
    rVDD_36 (VDD_92 VDD_93) resistor r=11.6604
    rVDD_35 (VDD_92 VDD_94) resistor r=9.04595
    rVDD_34 (VDD_94 VDD_96) resistor r=31.2341
    rVDD_33 (VDD_95 VDD_96) resistor r=31.2341
    rVDD_32 (VDD_100 VDD_101) resistor r=0.549089
    rVDD_31 (VDD_102 VDD_103) resistor r=0.730683
    rVSS_176 (MM2_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_175 (MM6_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_174 (MM3_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_173 (MM5_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_172 (MM18_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_171 (MM19_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_170 (MM4_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_169 (MM1_ELT_b VSS_62) resistor r=8.66667
    rVSS_168 (MM1_ELT_b VSS_27) resistor r=64.7228
    rVSS_167 (MM1_ELT_b VSS_37) resistor r=64.7228
    rVSS_166 (VSS_2 VSS_4) resistor r=0.405093
    rVSS_165 (VSS_2 VSS_57) resistor r=0.119235
    rVSS_164 (VSS_4 VSS_5) resistor r=8.66667
    rVSS_163 (VSS_4 VSS_7) resistor r=0.426413
    rVSS_162 (VSS_5 VSS_127) resistor r=17.2126
    rVSS_161 (VSS_5 VSS_115) resistor r=17.2126
    rVSS_160 (VSS_5 MM1_ELT_s) resistor r=3.43331
    rVSS_159 (VSS_7 VSS_8) resistor r=26
    rVSS_158 (VSS_8 VSS_69) resistor r=5.7452
    rVSS_157 (VSS_8 VSS_127) resistor r=4.05543
    rVSS_156 (VSS_10 VSS_13) resistor r=0.221433
    rVSS_155 (VSS_10 VSS_59) resistor r=0.0221617
    rVSS_154 (VSS_11 VSS_13) resistor r=0.0336104
    rVSS_153 (VSS_11 VSS_57) resistor r=0.0177937
    rVSS_152 (VSS_13 VSS_14) resistor r=8.66667
    rVSS_151 (VSS_14 VSS_60) resistor r=64.7228
    rVSS_150 (VSS_15 VSS_17) resistor r=0.405093
    rVSS_149 (VSS_15 VSS_59) resistor r=0.0882496
    rVSS_148 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_147 (VSS_17 VSS_20) resistor r=0.43119
    rVSS_146 (VSS_18 VSS_129) resistor r=17.2126
    rVSS_145 (VSS_18 VSS_116) resistor r=17.2126
    rVSS_144 (VSS_18 MM2_ELT_s) resistor r=3.43331
    rVSS_143 (VSS_20 VSS_21) resistor r=26
    rVSS_142 (VSS_21 VSS_76) resistor r=5.7452
    rVSS_141 (VSS_21 VSS_129) resistor r=4.05543
    rVSS_140 (VSS_23 VSS_26) resistor r=0.221433
    rVSS_139 (VSS_23 VSS_62) resistor r=0.0221617
    rVSS_138 (VSS_24 VSS_26) resistor r=0.217479
    rVSS_137 (VSS_24 VSS_59) resistor r=0.0221617
    rVSS_136 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_135 (VSS_27 VSS_60) resistor r=64.7228
    rVSS_134 (VSS_28 VSS_30) resistor r=0.503005
    rVSS_133 (VSS_28 VSS_62) resistor r=0.0882496
    rVSS_132 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_131 (VSS_31 MM18_ELT_s) resistor r=4.22001
    rVSS_130 (VSS_31 VSS_119) resistor r=4.22001
    rVSS_129 (VSS_31 MM3_ELT_s) resistor r=4.22001
    rVSS_128 (VSS_31 VSS_117) resistor r=4.22001
    rVSS_127 (VSS_33 VSS_39) resistor r=0.0415187
    rVSS_126 (VSS_33 VSS_64) resistor r=0.0221617
    rVSS_125 (VSS_34 VSS_36) resistor r=0.217479
    rVSS_124 (VSS_34 VSS_62) resistor r=0.0221617
    rVSS_123 (VSS_36 VSS_37) resistor r=8.66667
    rVSS_122 (VSS_36 VSS_39) resistor r=0.23725
    rVSS_121 (VSS_37 VSS_40) resistor r=64.7228
    rVSS_120 (VSS_39 VSS_40) resistor r=8.66667
    rVSS_119 (VSS_40 VSS_52) resistor r=64.7228
    rVSS_118 (VSS_41 VSS_43) resistor r=0.503005
    rVSS_117 (VSS_41 VSS_64) resistor r=0.0882496
    rVSS_116 (VSS_43 VSS_44) resistor r=8.66667
    rVSS_115 (VSS_43 VSS_46) resistor r=0.536539
    rVSS_114 (VSS_44 MM4_ELT_s) resistor r=4.22001
    rVSS_113 (VSS_44 VSS_132) resistor r=4.22001
    rVSS_112 (VSS_44 MM19_ELT_s) resistor r=4.22001
    rVSS_111 (VSS_44 VSS_121) resistor r=4.22001
    rVSS_110 (VSS_46 VSS_47) resistor r=26
    rVSS_109 (VSS_47 MM4_ELT_s) resistor r=10.6787
    rVSS_108 (VSS_47 VSS_104) resistor r=10.6787
    rVSS_107 (VSS_47 VSS_132) resistor r=0.57282
    rVSS_106 (VSS_49 VSS_51) resistor r=0.160144
    rVSS_105 (VSS_49 VSS_64) resistor r=0.0221617
    rVSS_104 (VSS_51 VSS_52) resistor r=8.66667
    rVSS_103 (VSS VSS_57) resistor r=0.0494271
    rVSS_102 (VSS_59 VSS_60) resistor r=8.66667
    rVSS_101 (MM1_ELT_s VSS_68) resistor r=2.67027
    rVSS_100 (MM1_ELT_s VSS_70) resistor r=12.8495
    rVSS_99 (MM1_ELT_s VSS_70) resistor r=1.69926
    rVSS_98 (MM1_ELT_s VSS_71) resistor r=18.0507
    rVSS_97 (VSS_66 VSS_68) resistor r=15.1041
    rVSS_96 (VSS_66 VSS_71) resistor r=9.43134
    rVSS_95 (VSS_67 VSS_68) resistor r=15.1041
    rVSS_94 (VSS_67 VSS_115) resistor r=9.89549
    rVSS_93 (VSS_69 VSS_70) resistor r=12.8495
    rVSS_92 (MM2_ELT_s VSS_75) resistor r=2.67027
    rVSS_91 (MM2_ELT_s VSS_77) resistor r=7.63611
    rVSS_90 (MM2_ELT_s VSS_77) resistor r=1.46105
    rVSS_89 (MM2_ELT_s VSS_79) resistor r=7.63611
    rVSS_88 (MM2_ELT_s VSS_79) resistor r=1.46105
    rVSS_87 (MM2_ELT_s VSS_82) resistor r=4.557
    rVSS_86 (VSS_73 VSS_75) resistor r=15.1041
    rVSS_85 (VSS_73 VSS_80) resistor r=9.43134
    rVSS_84 (VSS_74 VSS_75) resistor r=15.1041
    rVSS_83 (VSS_74 VSS_116) resistor r=9.89549
    rVSS_82 (VSS_76 VSS_77) resistor r=7.63611
    rVSS_81 (VSS_78 VSS_79) resistor r=7.63611
    rVSS_80 (VSS_78 VSS_81) resistor r=9.4369
    rVSS_79 (VSS_80 VSS_82) resistor r=21.1301
    rVSS_78 (VSS_81 VSS_82) resistor r=21.1301
    rVSS_77 (MM3_ELT_s VSS_84) resistor r=18.0507
    rVSS_76 (MM3_ELT_s VSS_87) resistor r=2.67027
    rVSS_75 (MM3_ELT_s VSS_89) resistor r=12.8495
    rVSS_74 (MM3_ELT_s VSS_89) resistor r=1.69926
    rVSS_73 (VSS_84 VSS_86) resistor r=9.43134
    rVSS_72 (VSS_85 VSS_87) resistor r=15.1041
    rVSS_71 (VSS_85 VSS_118) resistor r=11.0157
    rVSS_70 (VSS_86 VSS_87) resistor r=15.1041
    rVSS_69 (VSS_88 VSS_89) resistor r=12.8495
    rVSS_68 (VSS_88 VSS_120) resistor r=10.6787
    rVSS_67 (MM18_ELT_s VSS_93) resistor r=2.67027
    rVSS_66 (MM18_ELT_s VSS_95) resistor r=12.8495
    rVSS_65 (MM18_ELT_s VSS_95) resistor r=1.69926
    rVSS_64 (MM18_ELT_s VSS_98) resistor r=4.557
    rVSS_63 (MM18_ELT_s VSS_120) resistor r=10.6787
    rVSS_62 (VSS_91 VSS_93) resistor r=15.1041
    rVSS_61 (VSS_91 VSS_96) resistor r=9.43134
    rVSS_60 (VSS_92 VSS_93) resistor r=15.1041
    rVSS_59 (VSS_92 VSS_118) resistor r=11.0157
    rVSS_58 (VSS_94 VSS_95) resistor r=12.8495
    rVSS_57 (VSS_94 VSS_97) resistor r=9.4369
    rVSS_56 (VSS_96 VSS_98) resistor r=21.1301
    rVSS_55 (VSS_97 VSS_98) resistor r=21.1301
    rVSS_54 (MM19_ELT_s VSS_100) resistor r=18.0507
    rVSS_53 (MM19_ELT_s VSS_103) resistor r=2.67027
    rVSS_52 (MM19_ELT_s VSS_105) resistor r=12.8495
    rVSS_51 (MM19_ELT_s VSS_105) resistor r=1.69926
    rVSS_50 (VSS_100 VSS_102) resistor r=9.43134
    rVSS_49 (VSS_101 VSS_103) resistor r=15.1041
    rVSS_48 (VSS_101 VSS_122) resistor r=11.0157
    rVSS_47 (VSS_102 VSS_103) resistor r=15.1041
    rVSS_46 (VSS_104 VSS_105) resistor r=12.8495
    rVSS_45 (MM4_ELT_s VSS_109) resistor r=2.67027
    rVSS_44 (MM4_ELT_s VSS_111) resistor r=12.1643
    rVSS_43 (MM4_ELT_s VSS_111) resistor r=1.36649
    rVSS_42 (MM4_ELT_s VSS_114) resistor r=4.557
    rVSS_41 (VSS_107 VSS_109) resistor r=15.1041
    rVSS_40 (VSS_107 VSS_112) resistor r=9.43134
    rVSS_39 (VSS_108 VSS_109) resistor r=15.1041
    rVSS_38 (VSS_108 VSS_122) resistor r=11.0157
    rVSS_37 (VSS_110 VSS_111) resistor r=12.1643
    rVSS_36 (VSS_110 VSS_113) resistor r=9.4369
    rVSS_35 (VSS_112 VSS_114) resistor r=21.1301
    rVSS_34 (VSS_113 VSS_114) resistor r=21.1301
    rVSS_33 (VSS_117 VSS_118) resistor r=0.762262
    rVSS_32 (VSS_119 VSS_120) resistor r=0.57282
    rVSS_31 (VSS_121 VSS_122) resistor r=0.762262
    rCDN_93 (CDN_22 CDN_28) resistor r=58.3583
    rCDN_92 (CDN_22 CDN_28) resistor r=4.16253
    rCDN_91 (CDN_22 CDN_28) resistor r=58.3583
    rCDN_90 (CDN_22 CDN_28) resistor r=4.16253
    rCDN_89 (CDN_25 CDN_28) resistor r=58.3583
    rCDN_88 (CDN_25 CDN_28) resistor r=6.30933
    rCDN_87 (CDN_25 CDN_28) resistor r=58.3583
    rCDN_86 (CDN_25 CDN_28) resistor r=6.30933
    rCDN_85 (CDN_28 CDN_30) resistor r=14.9
    rCDN_84 (CDN_28 CDN_53) resistor r=24.8333
    rCDN_83 (CDN_28 CDN_50) resistor r=24.8333
    rCDN_82 (CDN_28 CDN_61) resistor r=24.8333
    rCDN_81 (CDN_28 CDN_58) resistor r=24.8333
    rCDN_80 (CDN_28 CDN_82) resistor r=58.3583
    rCDN_79 (CDN_28 CDN_85) resistor r=58.3583
    rCDN_78 (CDN_28 CDN_53) resistor r=4.16253
    rCDN_77 (CDN_28 CDN_30) resistor r=6.30933
    rCDN_76 (CDN_28 CDN_61) resistor r=1.63969
    rCDN_75 (CDN_28 CDN_50) resistor r=4.16253
    rCDN_74 (CDN_28 CDN_82) resistor r=4.16253
    rCDN_73 (CDN_28 CDN_58) resistor r=4.16253
    rCDN_72 (CDN_28 CDN_85) resistor r=4.16253
    rCDN_71 (CDN_28 CDN_30) resistor r=14.9
    rCDN_70 (CDN_28 CDN_161) resistor r=39.7333
    rCDN_69 (CDN_28 CDN_53) resistor r=24.8333
    rCDN_68 (CDN_28 CDN_50) resistor r=24.8333
    rCDN_67 (CDN_28 CDN_61) resistor r=24.8333
    rCDN_66 (CDN_28 CDN_58) resistor r=24.8333
    rCDN_65 (CDN_28 CDN_82) resistor r=58.3583
    rCDN_64 (CDN_28 MM19_ELT_g) resistor r=7.45
    rCDN_63 (CDN_28 CDN_53) resistor r=4.16253
    rCDN_62 (CDN_28 CDN_30) resistor r=6.30933
    rCDN_61 (CDN_28 CDN_61) resistor r=1.63969
    rCDN_60 (CDN_28 CDN_50) resistor r=4.16253
    rCDN_59 (CDN_28 CDN_82) resistor r=4.16253
    rCDN_58 (CDN_28 CDN_58) resistor r=4.16253
    rCDN_57 (CDN_28 CDN_85) resistor r=4.16253
    rCDN_56 (CDN_36 CDN_39) resistor r=14.9
    rCDN_55 (CDN_36 CDN_39) resistor r=6.30933
    rCDN_54 (CDN_36 CDN_39) resistor r=14.9
    rCDN_53 (CDN_36 CDN_39) resistor r=6.30933
    rCDN_52 (CDN_39 CDN_42) resistor r=202.392
    rCDN_51 (CDN_39 CDN_45) resistor r=202.392
    rCDN_50 (CDN_39 CDN_69) resistor r=24.8333
    rCDN_49 (CDN_39 CDN_66) resistor r=24.8333
    rCDN_48 (CDN_39 CDN_77) resistor r=24.8333
    rCDN_47 (CDN_39 CDN_74) resistor r=24.8333
    rCDN_46 (CDN_39 CDN_90) resistor r=202.392
    rCDN_45 (CDN_39 CDN_93) resistor r=202.392
    rCDN_44 (CDN_39 CDN_42) resistor r=6.30933
    rCDN_43 (CDN_39 CDN_69) resistor r=1.63969
    rCDN_42 (CDN_39 CDN_77) resistor r=4.16253
    rCDN_41 (CDN_39 CDN_45) resistor r=4.16253
    rCDN_40 (CDN_39 CDN_66) resistor r=4.16253
    rCDN_39 (CDN_39 CDN_90) resistor r=4.16253
    rCDN_38 (CDN_39 CDN_74) resistor r=4.16253
    rCDN_37 (CDN_39 CDN_93) resistor r=4.16253
    rCDN_36 (CDN_39 CDN_163) resistor r=42.2167
    rCDN_35 (CDN_39 CDN_42) resistor r=202.392
    rCDN_34 (CDN_39 CDN_45) resistor r=202.392
    rCDN_33 (CDN_39 CDN_69) resistor r=24.8333
    rCDN_32 (CDN_39 CDN_66) resistor r=24.8333
    rCDN_31 (CDN_39 CDN_77) resistor r=24.8333
    rCDN_30 (CDN_39 CDN_74) resistor r=24.8333
    rCDN_29 (CDN_39 CDN_90) resistor r=202.392
    rCDN_28 (CDN_39 MM17_ELT_g) resistor r=7.45
    rCDN_27 (CDN_39 CDN_42) resistor r=6.30933
    rCDN_26 (CDN_39 CDN_69) resistor r=1.63969
    rCDN_25 (CDN_39 CDN_77) resistor r=4.16253
    rCDN_24 (CDN_39 CDN_45) resistor r=4.16253
    rCDN_23 (CDN_39 CDN_66) resistor r=4.16253
    rCDN_22 (CDN_39 CDN_90) resistor r=4.16253
    rCDN_21 (CDN_39 CDN_74) resistor r=4.16253
    rCDN_20 (CDN_39 CDN_93) resistor r=4.16253
    rCDN_19 (CDN_85 MM19_ELT_g) resistor r=50.9083
    rCDN_18 (CDN_93 MM17_ELT_g) resistor r=194.942
    rCDN_17 (CDN CDN_135) resistor r=10
    rCDN_16 (CDN_135 CDN_203) resistor r=7.45
    rCDN_15 (CDN_161 CDN_203) resistor r=5.23411
    rCDN_14 (CDN_163 CDN_203) resistor r=5.23411
    rnet027_40 (MM3_ELT_d net027) resistor r=0.01
    rnet027_39 (net027_1 net027_3) resistor r=0.410325
    rnet027_38 (net027_1 net027_7) resistor r=0.0961082
    rnet027_37 (net027_3 net027_4) resistor r=13
    rnet027_36 (net027_4 net027) resistor r=8.44
    rnet027_35 (net027_6 net027_7) resistor r=1.29765
    rnet027_34 (net027_6 net027_15) resistor r=0.0961082
    rnet027_33 (net027_8 net027_10) resistor r=0.218323
    rnet027_32 (net027_8 net027_14) resistor r=0.0961082
    rnet027_31 (net027_10 net027_11) resistor r=8.66667
    rnet027_30 (net027_11 MM5_ELT_s) resistor r=2.90692
    rnet027_29 (net027_11 net027_26) resistor r=12.1406
    rnet027_28 (net027_13 net027_14) resistor r=0.289482
    rnet027_27 (net027_13 net027_16) resistor r=0.0961082
    rnet027_26 (net027_15 net027_16) resistor r=0.539027
    rnet027_25 (net027_17 net027_20) resistor r=21.1301
    rnet027_24 (net027_17 net027_22) resistor r=9.43134
    rnet027_23 (net027_18 net027_20) resistor r=21.1301
    rnet027_22 (net027_18 net027_24) resistor r=9.4369
    rnet027_21 (MM5_ELT_s net027_20) resistor r=4.557
    rnet027_20 (MM5_ELT_s net027_23) resistor r=2.67027
    rnet027_19 (MM5_ELT_s net027_25) resistor r=12.8495
    rnet027_18 (MM5_ELT_s net027_25) resistor r=1.69926
    rnet027_17 (net027_21 net027_23) resistor r=15.1041
    rnet027_16 (net027_21 net027_26) resistor r=9.89549
    rnet027_15 (net027_22 net027_23) resistor r=15.1041
    rnet027_14 (net027_24 net027_25) resistor r=12.8495
    rCDNN_165 (MM17_ELT_d CDNN) resistor r=0.01
    rCDNN_164 (CDNN_22 CDNN_28) resistor r=58.3583
    rCDNN_163 (CDNN_22 CDNN_28) resistor r=4.16253
    rCDNN_162 (CDNN_22 CDNN_28) resistor r=58.3583
    rCDNN_161 (CDNN_22 CDNN_28) resistor r=4.16253
    rCDNN_160 (CDNN_25 CDNN_28) resistor r=58.3583
    rCDNN_159 (CDNN_25 CDNN_28) resistor r=4.16253
    rCDNN_158 (CDNN_25 CDNN_28) resistor r=58.3583
    rCDNN_157 (CDNN_25 CDNN_28) resistor r=4.16253
    rCDNN_156 (CDNN_28 CDNN_33) resistor r=24.8333
    rCDNN_155 (CDNN_28 CDNN_30) resistor r=24.8333
    rCDNN_154 (CDNN_28 CDNN_41) resistor r=24.8333
    rCDNN_153 (CDNN_28 CDNN_38) resistor r=24.8333
    rCDNN_152 (CDNN_28 CDNN_46) resistor r=14.9
    rCDNN_151 (CDNN_28 CDNN_52) resistor r=58.3583
    rCDNN_150 (CDNN_28 CDNN_55) resistor r=58.3583
    rCDNN_149 (CDNN_28 CDNN_33) resistor r=4.16253
    rCDNN_148 (CDNN_28 CDNN_41) resistor r=4.16253
    rCDNN_147 (CDNN_28 CDNN_52) resistor r=6.30933
    rCDNN_146 (CDNN_28 CDNN_46) resistor r=6.30933
    rCDNN_145 (CDNN_28 CDNN_30) resistor r=1.63969
    rCDNN_144 (CDNN_28 CDNN_38) resistor r=4.16253
    rCDNN_143 (CDNN_28 CDNN_55) resistor r=4.16253
    rCDNN_142 (CDNN_28 CDNN_33) resistor r=24.8333
    rCDNN_141 (CDNN_28 CDNN_30) resistor r=24.8333
    rCDNN_140 (CDNN_28 CDNN_41) resistor r=24.8333
    rCDNN_139 (CDNN_28 CDNN_38) resistor r=24.8333
    rCDNN_138 (CDNN_28 CDNN_223) resistor r=54.6333
    rCDNN_137 (CDNN_28 CDNN_46) resistor r=14.9
    rCDNN_136 (CDNN_28 CDNN_52) resistor r=58.3583
    rCDNN_135 (CDNN_28 MM20_ELT_g) resistor r=7.45
    rCDNN_134 (CDNN_28 CDNN_33) resistor r=4.16253
    rCDNN_133 (CDNN_28 CDNN_41) resistor r=4.16253
    rCDNN_132 (CDNN_28 CDNN_52) resistor r=6.30933
    rCDNN_131 (CDNN_28 CDNN_46) resistor r=6.30933
    rCDNN_130 (CDNN_28 CDNN_30) resistor r=1.63969
    rCDNN_129 (CDNN_28 CDNN_38) resistor r=4.16253
    rCDNN_128 (CDNN_28 CDNN_55) resistor r=4.16253
    rCDNN_127 (CDNN_55 MM20_ELT_g) resistor r=50.9083
    rCDNN_126 (CDNN_60 CDNN_66) resistor r=58.3583
    rCDNN_125 (CDNN_60 CDNN_66) resistor r=4.16253
    rCDNN_124 (CDNN_60 CDNN_66) resistor r=58.3583
    rCDNN_123 (CDNN_60 CDNN_66) resistor r=4.16253
    rCDNN_122 (CDNN_63 CDNN_66) resistor r=58.3583
    rCDNN_121 (CDNN_63 CDNN_66) resistor r=6.30933
    rCDNN_120 (CDNN_63 CDNN_66) resistor r=58.3583
    rCDNN_119 (CDNN_63 CDNN_66) resistor r=6.30933
    rCDNN_118 (CDNN_66 CDNN_68) resistor r=14.9
    rCDNN_117 (CDNN_66 CDNN_77) resistor r=24.8333
    rCDNN_116 (CDNN_66 CDNN_74) resistor r=24.8333
    rCDNN_115 (CDNN_66 CDNN_85) resistor r=24.8333
    rCDNN_114 (CDNN_66 CDNN_82) resistor r=24.8333
    rCDNN_113 (CDNN_66 CDNN_90) resistor r=58.3583
    rCDNN_112 (CDNN_66 CDNN_93) resistor r=58.3583
    rCDNN_111 (CDNN_66 CDNN_77) resistor r=4.16253
    rCDNN_110 (CDNN_66 CDNN_68) resistor r=6.30933
    rCDNN_109 (CDNN_66 CDNN_85) resistor r=1.63969
    rCDNN_108 (CDNN_66 CDNN_74) resistor r=4.16253
    rCDNN_107 (CDNN_66 CDNN_90) resistor r=4.16253
    rCDNN_106 (CDNN_66 CDNN_82) resistor r=4.16253
    rCDNN_105 (CDNN_66 CDNN_93) resistor r=4.16253
    rCDNN_104 (CDNN_66 CDNN_68) resistor r=14.9
    rCDNN_103 (CDNN_66 CDNN_235) resistor r=39.7333
    rCDNN_102 (CDNN_66 CDNN_77) resistor r=24.8333
    rCDNN_101 (CDNN_66 CDNN_74) resistor r=24.8333
    rCDNN_100 (CDNN_66 CDNN_85) resistor r=24.8333
    rCDNN_99 (CDNN_66 CDNN_82) resistor r=24.8333
    rCDNN_98 (CDNN_66 CDNN_90) resistor r=58.3583
    rCDNN_97 (CDNN_66 MM18_ELT_g) resistor r=7.45
    rCDNN_96 (CDNN_66 CDNN_77) resistor r=4.16253
    rCDNN_95 (CDNN_66 CDNN_68) resistor r=6.30933
    rCDNN_94 (CDNN_66 CDNN_85) resistor r=1.63969
    rCDNN_93 (CDNN_66 CDNN_74) resistor r=4.16253
    rCDNN_92 (CDNN_66 CDNN_90) resistor r=4.16253
    rCDNN_91 (CDNN_66 CDNN_82) resistor r=4.16253
    rCDNN_90 (CDNN_66 CDNN_93) resistor r=4.16253
    rCDNN_89 (CDNN_93 MM18_ELT_g) resistor r=50.9083
    rCDNN_88 (CDNN_131 CDNN_133) resistor r=0.390951
    rCDNN_87 (CDNN_131 CDNN_139) resistor r=0.0961082
    rCDNN_86 (CDNN_133 CDNN_134) resistor r=10
    rCDNN_85 (CDNN_134 CDNN_252) resistor r=18.9636
    rCDNN_84 (CDNN_136 CDNN_160) resistor r=0.583505
    rCDNN_83 (CDNN_136 CDNN_141) resistor r=0.0961082
    rCDNN_82 (CDNN_139 CDNN_162) resistor r=0.128588
    rCDNN_81 (CDNN_140 CDNN_141) resistor r=0.30096
    rCDNN_80 (CDNN_140 CDNN_143) resistor r=0.0961082
    rCDNN_79 (CDNN_142 CDNN_143) resistor r=0.1333
    rCDNN_78 (CDNN_142 CDNN_144) resistor r=0.0961082
    rCDNN_77 (CDNN_144 CDNN_146) resistor r=0.0764668
    rCDNN_76 (CDNN_146 CDNN_147) resistor r=10
    rCDNN_75 (CDNN_147 CDNN_235) resistor r=5.6595
    rCDNN_74 (CDNN_153 CDNN_154) resistor r=8.66667
    rCDNN_73 (CDNN_153 CDNN_166) resistor r=0.560975
    rCDNN_72 (CDNN_153 CDNN_156) resistor r=0.560975
    rCDNN_71 (CDNN_154 CDNN) resistor r=16.1807
    rCDNN_70 (CDNN_154 CDNN_157) resistor r=32.3614
    rCDNN_69 (CDNN_156 CDNN_157) resistor r=26
    rCDNN_68 (CDNN_159 CDNN_160) resistor r=0.0614284
    rCDNN_67 (CDNN_159 CDNN_188) resistor r=0.0481895
    rCDNN_66 (CDNN_161 CDNN_162) resistor r=0.0614284
    rCDNN_65 (CDNN_161 CDNN_188) resistor r=0.289137
    rCDNN_64 (CDNN_165 CDNN_166) resistor r=0.0691879
    rCDNN_63 (CDNN_165 CDNN_193) resistor r=0.325112
    rCDNN_62 (CDNN_169 CDNN_170) resistor r=0.478781
    rCDNN_61 (CDNN_169 CDNN_189) resistor r=0.0579622
    rCDNN_60 (CDNN_170 CDNN_187) resistor r=0.0382401
    rCDNN_59 (CDNN_171 CDNN_172) resistor r=1.0629
    rCDNN_58 (CDNN_171 CDNN_174) resistor r=0.0764802
    rCDNN_57 (CDNN_172 CDNN_189) resistor r=0.0150634
    rCDNN_56 (CDNN_173 CDNN_174) resistor r=0.393145
    rCDNN_55 (CDNN_173 CDNN_190) resistor r=0.0150634
    rCDNN_54 (CDNN_175 CDNN_176) resistor r=0.393145
    rCDNN_53 (CDNN_175 CDNN_192) resistor r=0.0382401
    rCDNN_52 (CDNN_176 CDNN_189) resistor r=0.0579622
    rCDNN_51 (CDNN_177 CDNN_179) resistor r=0.0389253
    rCDNN_50 (CDNN_177 CDNN_190) resistor r=0.0579622
    rCDNN_49 (CDNN_179 CDNN_180) resistor r=0.75
    rCDNN_48 (CDNN_180 CDNN_263) resistor r=13
    rCDNN_47 (CDNN_187 CDNN_188) resistor r=0.75
    rCDNN_46 (CDNN_192 CDNN_193) resistor r=0.75
    rCDNN_45 (CDNN_193 CDNN_270) resistor r=8.66667
    rCDNN_44 (CDNN_223 CDNN_252) resistor r=9.29775
    rCDNN_43 (CDNN_263 MM19_ELT_d) resistor r=8.44
    rCDNN_42 (CDNN_270 CDNN) resistor r=32.3614
    rY_148 (MM20_ELT_d Y) resistor r=0.01
    rY_147 (Y_22 Y_28) resistor r=58.3583
    rY_146 (Y_22 Y_28) resistor r=4.16253
    rY_145 (Y_22 Y_28) resistor r=58.3583
    rY_144 (Y_22 Y_28) resistor r=4.16253
    rY_143 (Y_25 Y_28) resistor r=58.3583
    rY_142 (Y_25 Y_28) resistor r=6.30933
    rY_141 (Y_25 Y_28) resistor r=58.3583
    rY_140 (Y_25 Y_28) resistor r=6.30933
    rY_139 (Y_28 Y_30) resistor r=14.9
    rY_138 (Y_28 Y_39) resistor r=24.8333
    rY_137 (Y_28 Y_36) resistor r=24.8333
    rY_136 (Y_28 Y_47) resistor r=24.8333
    rY_135 (Y_28 Y_44) resistor r=24.8333
    rY_134 (Y_28 Y_52) resistor r=58.3583
    rY_133 (Y_28 Y_55) resistor r=58.3583
    rY_132 (Y_28 Y_39) resistor r=4.16253
    rY_131 (Y_28 Y_30) resistor r=6.30933
    rY_130 (Y_28 Y_47) resistor r=1.63969
    rY_129 (Y_28 Y_36) resistor r=4.16253
    rY_128 (Y_28 Y_52) resistor r=4.16253
    rY_127 (Y_28 Y_44) resistor r=4.16253
    rY_126 (Y_28 Y_55) resistor r=4.16253
    rY_125 (Y_28 Y_30) resistor r=14.9
    rY_124 (Y_28 Y_202) resistor r=39.7333
    rY_123 (Y_28 Y_39) resistor r=24.8333
    rY_122 (Y_28 Y_36) resistor r=24.8333
    rY_121 (Y_28 Y_47) resistor r=24.8333
    rY_120 (Y_28 Y_44) resistor r=24.8333
    rY_119 (Y_28 Y_52) resistor r=58.3583
    rY_118 (Y_28 MM3_ELT_g) resistor r=7.45
    rY_117 (Y_28 Y_39) resistor r=4.16253
    rY_116 (Y_28 Y_30) resistor r=6.30933
    rY_115 (Y_28 Y_47) resistor r=1.63969
    rY_114 (Y_28 Y_36) resistor r=4.16253
    rY_113 (Y_28 Y_52) resistor r=4.16253
    rY_112 (Y_28 Y_44) resistor r=4.16253
    rY_111 (Y_28 Y_55) resistor r=4.16253
    rY_110 (Y_55 MM3_ELT_g) resistor r=50.9083
    rY_109 (Y_60 Y_66) resistor r=58.3583
    rY_108 (Y_60 Y_66) resistor r=4.16253
    rY_107 (Y_60 Y_66) resistor r=58.3583
    rY_106 (Y_60 Y_66) resistor r=4.16253
    rY_105 (Y_63 Y_66) resistor r=58.3583
    rY_104 (Y_63 Y_66) resistor r=4.16253
    rY_103 (Y_63 Y_66) resistor r=58.3583
    rY_102 (Y_63 Y_66) resistor r=4.16253
    rY_101 (Y_66 Y_71) resistor r=24.8333
    rY_100 (Y_66 Y_68) resistor r=24.8333
    rY_99 (Y_66 Y_79) resistor r=24.8333
    rY_98 (Y_66 Y_76) resistor r=24.8333
    rY_97 (Y_66 Y_84) resistor r=55.875
    rY_96 (Y_66 Y_87) resistor r=55.875
    rY_95 (Y_66 Y_92) resistor r=11.175
    rY_94 (Y_66 Y_71) resistor r=4.16253
    rY_93 (Y_66 Y_79) resistor r=4.16253
    rY_92 (Y_66 Y_92) resistor r=5.53947
    rY_91 (Y_66 Y_68) resistor r=5.53947
    rY_90 (Y_66 Y_84) resistor r=2.32428
    rY_89 (Y_66 Y_76) resistor r=4.16253
    rY_88 (Y_66 Y_87) resistor r=4.16253
    rY_87 (Y_66 Y_71) resistor r=24.8333
    rY_86 (Y_66 Y_68) resistor r=24.8333
    rY_85 (Y_66 Y_79) resistor r=24.8333
    rY_84 (Y_66 Y_76) resistor r=24.8333
    rY_83 (Y_66 Y_84) resistor r=55.875
    rY_82 (Y_66 MM8_ELT_g) resistor r=4.96667
    rY_81 (Y_66 Y_92) resistor r=11.175
    rY_80 (Y_66 Y_231) resistor r=29.8
    rY_79 (Y_66 Y_71) resistor r=4.16253
    rY_78 (Y_66 Y_79) resistor r=4.16253
    rY_77 (Y_66 Y_92) resistor r=5.53947
    rY_76 (Y_66 Y_68) resistor r=5.53947
    rY_75 (Y_66 Y_84) resistor r=2.32428
    rY_74 (Y_66 Y_76) resistor r=4.16253
    rY_73 (Y_66 Y_87) resistor r=4.16253
    rY_72 (Y_87 MM8_ELT_g) resistor r=50.9083
    rY_71 (Y_131 Y_132) resistor r=0.303173
    rY_70 (Y_131 Y_141) resistor r=0.0961082
    rY_69 (Y_132 Y_153) resistor r=0.0507657
    rY_68 (Y_133 Y_134) resistor r=0.212068
    rY_67 (Y_133 Y_156) resistor r=0.0728377
    rY_66 (Y_134 Y_166) resistor r=0.0964549
    rY_65 (Y_135 Y_137) resistor r=0.294888
    rY_64 (Y_135 Y_156) resistor r=0.0189293
    rY_63 (Y_137 Y_138) resistor r=13
    rY_62 (Y_138 Y) resistor r=8.09035
    rY_61 (Y_140 Y_141) resistor r=0.502805
    rY_60 (Y_140 Y_158) resistor r=0.0724937
    rY_59 (Y_142 Y_143) resistor r=1.88115
    rY_58 (Y_142 Y_146) resistor r=0.0961082
    rY_57 (Y_143 Y_156) resistor r=0.0728377
    rY_56 (Y_146 Y_148) resistor r=0.103005
    rY_55 (Y_148 Y_149) resistor r=10
    rY_54 (Y_149 Y_231) resistor r=4.6552
    rY_53 (Y_153 Y_154) resistor r=13
    rY_52 (Y_153 Y_163) resistor r=0.0456451
    rY_51 (Y_154 MM6_ELT_d) resistor r=8.44
    rY_50 (Y_158 Y_159) resistor r=10
    rY_49 (Y_159 Y_202) resistor r=5.39869
    rY_48 (Y_160 Y_162) resistor r=0.751258
    rY_47 (Y_160 Y_169) resistor r=0.0764802
    rY_46 (Y_162 Y_163) resistor r=0.75
    rY_45 (Y_162 Y_165) resistor r=0.716225
    rY_44 (Y_165 Y_166) resistor r=0.75
    rY_43 (Y_168 Y_169) resistor r=0.70844
    rY_42 (Y_168 Y_177) resistor r=0.0150634
    rY_41 (Y_170 Y_172) resistor r=0.0389253
    rY_40 (Y_170 Y_177) resistor r=0.0579622
    rY_39 (Y_172 Y_173) resistor r=0.75
    rY_38 (Y_173 Y_252) resistor r=13
    rY_37 (Y_252 MM18_ELT_d) resistor r=8.44
    rnet026_38 (MM2_ELT_d net026) resistor r=0.01
    rnet026_37 (net026_1 net026_3) resistor r=0.372048
    rnet026_36 (net026_1 net026_12) resistor r=0.0961082
    rnet026_35 (net026_3 net026_4) resistor r=8.66667
    rnet026_34 (net026_4 MM6_ELT_s) resistor r=2.90692
    rnet026_33 (net026_4 net026_26) resistor r=12.1406
    rnet026_32 (net026_6 net026_8) resistor r=0.303819
    rnet026_31 (net026_6 net026_14) resistor r=0.0961082
    rnet026_30 (net026_8 net026_9) resistor r=13
    rnet026_29 (net026_9 net026) resistor r=8.44
    rnet026_28 (net026_11 net026_12) resistor r=0.541315
    rnet026_27 (net026_11 net026_16) resistor r=0.0961082
    rnet026_26 (net026_13 net026_14) resistor r=0.262327
    rnet026_25 (net026_13 net026_15) resistor r=0.0961082
    rnet026_24 (net026_15 net026_16) resistor r=0.793902
    rnet026_23 (MM6_ELT_s net026_20) resistor r=2.67027
    rnet026_22 (MM6_ELT_s net026_22) resistor r=12.8495
    rnet026_21 (MM6_ELT_s net026_22) resistor r=1.69926
    rnet026_20 (MM6_ELT_s net026_25) resistor r=4.557
    rnet026_19 (net026_18 net026_20) resistor r=15.1041
    rnet026_18 (net026_18 net026_23) resistor r=9.43134
    rnet026_17 (net026_19 net026_20) resistor r=15.1041
    rnet026_16 (net026_19 net026_26) resistor r=9.89549
    rnet026_15 (net026_21 net026_22) resistor r=12.8495
    rnet026_14 (net026_21 net026_24) resistor r=9.4369
    rnet026_13 (net026_23 net026_25) resistor r=21.1301
    rnet026_12 (net026_24 net026_25) resistor r=21.1301
    rX_89 (MM10_ELT_d X) resistor r=0.01
    rX_88 (X_14 X_20) resistor r=58.3583
    rX_87 (X_14 X_20) resistor r=4.16253
    rX_86 (X_14 X_20) resistor r=58.3583
    rX_85 (X_14 X_20) resistor r=4.16253
    rX_84 (X_17 X_20) resistor r=58.3583
    rX_83 (X_17 X_20) resistor r=4.16253
    rX_82 (X_17 X_20) resistor r=58.3583
    rX_81 (X_17 X_20) resistor r=4.16253
    rX_80 (X_20 X_25) resistor r=24.8333
    rX_79 (X_20 X_22) resistor r=24.8333
    rX_78 (X_20 X_33) resistor r=8.69167
    rX_77 (X_20 X_30) resistor r=8.69167
    rX_76 (X_20 X_38) resistor r=14.9
    rX_75 (X_20 X_47) resistor r=8.69167
    rX_74 (X_20 X_44) resistor r=8.69167
    rX_73 (X_20 X_52) resistor r=58.3583
    rX_72 (X_20 X_55) resistor r=58.3583
    rX_71 (X_20 X_25) resistor r=4.16253
    rX_70 (X_20 X_33) resistor r=4.16253
    rX_69 (X_20 X_47) resistor r=6.30933
    rX_68 (X_20 X_30) resistor r=6.30933
    rX_67 (X_20 X_38) resistor r=1.63969
    rX_66 (X_20 X_22) resistor r=4.16253
    rX_65 (X_20 X_52) resistor r=4.16253
    rX_64 (X_20 X_44) resistor r=4.16253
    rX_63 (X_20 X_55) resistor r=4.16253
    rX_62 (X_20 X_25) resistor r=24.8333
    rX_61 (X_20 X_22) resistor r=24.8333
    rX_60 (X_20 X_33) resistor r=8.69167
    rX_59 (X_20 X_30) resistor r=8.69167
    rX_58 (X_20 X_38) resistor r=14.9
    rX_57 (X_20 X_128) resistor r=39.7333
    rX_56 (X_20 X_47) resistor r=8.69167
    rX_55 (X_20 X_44) resistor r=8.69167
    rX_54 (X_20 X_52) resistor r=58.3583
    rX_53 (X_20 MM2_ELT_g) resistor r=7.45
    rX_52 (X_20 X_25) resistor r=4.16253
    rX_51 (X_20 X_33) resistor r=4.16253
    rX_50 (X_20 X_47) resistor r=6.30933
    rX_49 (X_20 X_30) resistor r=6.30933
    rX_48 (X_20 X_38) resistor r=1.63969
    rX_47 (X_20 X_22) resistor r=4.16253
    rX_46 (X_20 X_52) resistor r=4.16253
    rX_45 (X_20 X_44) resistor r=4.16253
    rX_44 (X_20 X_55) resistor r=4.16253
    rX_43 (X_55 MM2_ELT_g) resistor r=50.9083
    rX_42 (X_80 X_82) resistor r=0.159905
    rX_41 (X_80 X_91) resistor r=0.0961082
    rX_40 (X_82 X_83) resistor r=13
    rX_39 (X_83 X) resistor r=8.09035
    rX_38 (X_85 X_87) resistor r=0.303819
    rX_37 (X_85 X_101) resistor r=0.0101021
    rX_36 (X_87 X_88) resistor r=13
    rX_35 (X_88 MM1_ELT_d) resistor r=8.44
    rX_34 (X_90 X_91) resistor r=0.0927304
    rX_33 (X_90 X_95) resistor r=0.0961082
    rX_32 (X_92 X_93) resistor r=0.309911
    rX_31 (X_92 X_103) resistor r=0.0101021
    rX_30 (X_93 X_105) resistor r=0.0728377
    rX_29 (X_94 X_95) resistor r=0.321575
    rX_28 (X_94 X_105) resistor r=0.0728377
    rX_27 (X_96 X_98) resistor r=0.767213
    rX_26 (X_96 X_105) resistor r=0.0189293
    rX_25 (X_98 X_99) resistor r=10
    rX_24 (X_99 X_143) resistor r=4.74091
    rX_23 (X_101 X_103) resistor r=0.126894
    rX_22 (X_128 X_144) resistor r=4.38767
    rX_21 (X_143 X_144) resistor r=3.71511
    rnet29_32 (MM11_ELT_d net29) resistor r=0.01
    rnet29_31 (net29_1 net29_3) resistor r=0.0906128
    rnet29_30 (net29_1 net29_7) resistor r=0.0961082
    rnet29_29 (net29_3 net29_4) resistor r=13
    rnet29_28 (net29_4 net29) resistor r=8.09035
    rnet29_27 (net29_6 net29_7) resistor r=0.112253
    rnet29_26 (net29_6 net29_8) resistor r=0.0961082
    rnet29_25 (net29_8 net29_10) resistor r=0.90446
    rnet29_24 (net29_10 net29_11) resistor r=8.66667
    rnet29_23 (net29_11 net29_21) resistor r=16.4995
    rnet29_22 (net29_11 net29_20) resistor r=16.4995
    rnet29_21 (net29_11 MM10_ELT_s) resistor r=3.29107
    rnet29_20 (MM10_ELT_s net29_14) resistor r=17.3029
    rnet29_19 (MM10_ELT_s net29_17) resistor r=2.55965
    rnet29_18 (MM10_ELT_s net29_19) resistor r=12.3172
    rnet29_17 (MM10_ELT_s net29_19) resistor r=1.62887
    rnet29_16 (net29_14 net29_16) resistor r=9.04062
    rnet29_15 (net29_15 net29_17) resistor r=14.4784
    rnet29_14 (net29_15 net29_21) resistor r=9.48555
    rnet29_13 (net29_16 net29_17) resistor r=14.4784
    rnet29_12 (net29_18 net29_19) resistor r=12.3172
    rnet29_11 (net29_18 net29_20) resistor r=9.39461
    rCP_229 (CP_42 CP_45) resistor r=14.9
    rCP_228 (CP_42 CP_45) resistor r=6.30933
    rCP_227 (CP_42 CP_45) resistor r=14.9
    rCP_226 (CP_42 CP_45) resistor r=6.30933
    rCP_225 (CP_45 CP_48) resistor r=58.3583
    rCP_224 (CP_45 CP_51) resistor r=58.3583
    rCP_223 (CP_45 CP_59) resistor r=24.8333
    rCP_222 (CP_45 CP_56) resistor r=24.8333
    rCP_221 (CP_45 CP_67) resistor r=24.8333
    rCP_220 (CP_45 CP_64) resistor r=24.8333
    rCP_219 (CP_45 CP_72) resistor r=58.3583
    rCP_218 (CP_45 CP_75) resistor r=58.3583
    rCP_217 (CP_45 CP_48) resistor r=6.30933
    rCP_216 (CP_45 CP_59) resistor r=1.63969
    rCP_215 (CP_45 CP_67) resistor r=4.16253
    rCP_214 (CP_45 CP_51) resistor r=4.16253
    rCP_213 (CP_45 CP_56) resistor r=4.16253
    rCP_212 (CP_45 CP_72) resistor r=4.16253
    rCP_211 (CP_45 CP_64) resistor r=4.16253
    rCP_210 (CP_45 CP_75) resistor r=4.16253
    rCP_209 (CP_45 CP_336) resistor r=39.7333
    rCP_208 (CP_45 CP_48) resistor r=58.3583
    rCP_207 (CP_45 CP_51) resistor r=58.3583
    rCP_206 (CP_45 CP_59) resistor r=24.8333
    rCP_205 (CP_45 CP_56) resistor r=24.8333
    rCP_204 (CP_45 CP_67) resistor r=24.8333
    rCP_203 (CP_45 CP_64) resistor r=24.8333
    rCP_202 (CP_45 CP_72) resistor r=58.3583
    rCP_201 (CP_45 MM10_ELT_g) resistor r=7.45
    rCP_200 (CP_45 CP_48) resistor r=6.30933
    rCP_199 (CP_45 CP_59) resistor r=1.63969
    rCP_198 (CP_45 CP_67) resistor r=4.16253
    rCP_197 (CP_45 CP_51) resistor r=4.16253
    rCP_196 (CP_45 CP_56) resistor r=4.16253
    rCP_195 (CP_45 CP_72) resistor r=4.16253
    rCP_194 (CP_45 CP_64) resistor r=4.16253
    rCP_193 (CP_45 CP_75) resistor r=4.16253
    rCP_192 (CP_75 MM10_ELT_g) resistor r=50.9083
    rCP_191 (CP_80 CP_86) resistor r=58.3583
    rCP_190 (CP_80 CP_86) resistor r=4.16253
    rCP_189 (CP_80 CP_86) resistor r=58.3583
    rCP_188 (CP_80 CP_86) resistor r=4.16253
    rCP_187 (CP_83 CP_86) resistor r=58.3583
    rCP_186 (CP_83 CP_86) resistor r=4.16253
    rCP_185 (CP_83 CP_86) resistor r=58.3583
    rCP_184 (CP_83 CP_86) resistor r=4.16253
    rCP_183 (CP_86 CP_91) resistor r=24.8333
    rCP_182 (CP_86 CP_88) resistor r=24.8333
    rCP_181 (CP_86 CP_99) resistor r=24.8333
    rCP_180 (CP_86 CP_96) resistor r=24.8333
    rCP_179 (CP_86 CP_118) resistor r=14.9
    rCP_178 (CP_86 CP_124) resistor r=58.3583
    rCP_177 (CP_86 CP_127) resistor r=58.3583
    rCP_176 (CP_86 CP_91) resistor r=4.16253
    rCP_175 (CP_86 CP_99) resistor r=4.16253
    rCP_174 (CP_86 CP_124) resistor r=6.30933
    rCP_173 (CP_86 CP_118) resistor r=6.30933
    rCP_172 (CP_86 CP_88) resistor r=1.63969
    rCP_171 (CP_86 CP_96) resistor r=4.16253
    rCP_170 (CP_86 CP_127) resistor r=4.16253
    rCP_169 (CP_86 CP_91) resistor r=24.8333
    rCP_168 (CP_86 CP_88) resistor r=24.8333
    rCP_167 (CP_86 CP_99) resistor r=24.8333
    rCP_166 (CP_86 CP_96) resistor r=24.8333
    rCP_165 (CP_86 CP_368) resistor r=54.6333
    rCP_164 (CP_86 CP_118) resistor r=14.9
    rCP_163 (CP_86 CP_124) resistor r=58.3583
    rCP_162 (CP_86 MM9_ELT_g) resistor r=7.45
    rCP_161 (CP_86 CP_91) resistor r=4.16253
    rCP_160 (CP_86 CP_99) resistor r=4.16253
    rCP_159 (CP_86 CP_124) resistor r=6.30933
    rCP_158 (CP_86 CP_118) resistor r=6.30933
    rCP_157 (CP_86 CP_88) resistor r=1.63969
    rCP_156 (CP_86 CP_96) resistor r=4.16253
    rCP_155 (CP_86 CP_127) resistor r=4.16253
    rCP_154 (CP_104 CP_110) resistor r=58.3583
    rCP_153 (CP_104 CP_110) resistor r=4.16253
    rCP_152 (CP_104 CP_110) resistor r=58.3583
    rCP_151 (CP_104 CP_110) resistor r=4.16253
    rCP_150 (CP_107 CP_110) resistor r=58.3583
    rCP_149 (CP_107 CP_110) resistor r=6.30933
    rCP_148 (CP_107 CP_110) resistor r=58.3583
    rCP_147 (CP_107 CP_110) resistor r=6.30933
    rCP_146 (CP_110 CP_112) resistor r=14.9
    rCP_145 (CP_110 CP_135) resistor r=24.8333
    rCP_144 (CP_110 CP_132) resistor r=24.8333
    rCP_143 (CP_110 CP_143) resistor r=24.8333
    rCP_142 (CP_110 CP_140) resistor r=24.8333
    rCP_141 (CP_110 CP_148) resistor r=58.3583
    rCP_140 (CP_110 CP_151) resistor r=58.3583
    rCP_139 (CP_110 CP_135) resistor r=4.16253
    rCP_138 (CP_110 CP_112) resistor r=6.30933
    rCP_137 (CP_110 CP_143) resistor r=1.63969
    rCP_136 (CP_110 CP_132) resistor r=4.16253
    rCP_135 (CP_110 CP_148) resistor r=4.16253
    rCP_134 (CP_110 CP_140) resistor r=4.16253
    rCP_133 (CP_110 CP_151) resistor r=4.16253
    rCP_132 (CP_110 CP_112) resistor r=14.9
    rCP_131 (CP_110 CP_366) resistor r=40.975
    rCP_130 (CP_110 CP_135) resistor r=24.8333
    rCP_129 (CP_110 CP_132) resistor r=24.8333
    rCP_128 (CP_110 CP_143) resistor r=24.8333
    rCP_127 (CP_110 CP_140) resistor r=24.8333
    rCP_126 (CP_110 CP_148) resistor r=58.3583
    rCP_125 (CP_110 MM6_ELT_g) resistor r=7.45
    rCP_124 (CP_110 CP_135) resistor r=4.16253
    rCP_123 (CP_110 CP_112) resistor r=6.30933
    rCP_122 (CP_110 CP_143) resistor r=1.63969
    rCP_121 (CP_110 CP_132) resistor r=4.16253
    rCP_120 (CP_110 CP_148) resistor r=4.16253
    rCP_119 (CP_110 CP_140) resistor r=4.16253
    rCP_118 (CP_110 CP_151) resistor r=4.16253
    rCP_117 (CP_127 MM9_ELT_g) resistor r=50.9083
    rCP_116 (CP_151 MM6_ELT_g) resistor r=50.9083
    rCP_115 (CP_156 CP_162) resistor r=58.3583
    rCP_114 (CP_156 CP_162) resistor r=4.16253
    rCP_113 (CP_156 CP_162) resistor r=58.3583
    rCP_112 (CP_156 CP_162) resistor r=4.16253
    rCP_111 (CP_159 CP_162) resistor r=58.3583
    rCP_110 (CP_159 CP_162) resistor r=4.16253
    rCP_109 (CP_159 CP_162) resistor r=58.3583
    rCP_108 (CP_159 CP_162) resistor r=4.16253
    rCP_107 (CP_162 CP_167) resistor r=24.8333
    rCP_106 (CP_162 CP_164) resistor r=24.8333
    rCP_105 (CP_162 CP_175) resistor r=24.8333
    rCP_104 (CP_162 CP_172) resistor r=24.8333
    rCP_103 (CP_162 CP_180) resistor r=58.3583
    rCP_102 (CP_162 CP_183) resistor r=58.3583
    rCP_101 (CP_162 CP_188) resistor r=14.9
    rCP_100 (CP_162 CP_167) resistor r=4.16253
    rCP_99 (CP_162 CP_175) resistor r=4.16253
    rCP_98 (CP_162 CP_164) resistor r=4.16253
    rCP_97 (CP_162 CP_180) resistor r=4.16253
    rCP_96 (CP_162 CP_188) resistor r=6.30933
    rCP_95 (CP_162 CP_183) resistor r=6.30933
    rCP_94 (CP_162 CP_172) resistor r=1.63969
    rCP_93 (CP_162 CP_167) resistor r=24.8333
    rCP_92 (CP_162 CP_164) resistor r=24.8333
    rCP_91 (CP_162 CP_175) resistor r=24.8333
    rCP_90 (CP_162 CP_172) resistor r=24.8333
    rCP_89 (CP_162 CP_180) resistor r=58.3583
    rCP_88 (CP_162 MM5_ELT_g) resistor r=22.35
    rCP_87 (CP_162 CP_188) resistor r=14.9
    rCP_86 (CP_162 CP_404) resistor r=40.975
    rCP_85 (CP_162 CP_167) resistor r=4.16253
    rCP_84 (CP_162 CP_175) resistor r=4.16253
    rCP_83 (CP_162 CP_164) resistor r=4.16253
    rCP_82 (CP_162 CP_180) resistor r=4.16253
    rCP_81 (CP_162 CP_188) resistor r=6.30933
    rCP_80 (CP_162 CP_183) resistor r=6.30933
    rCP_79 (CP_162 CP_172) resistor r=1.63969
    rCP_78 (CP_183 MM5_ELT_g) resistor r=36.0083
    rCP_77 (CP_261 CP) resistor r=0.0423378
    rCP_76 (CP_261 CP_273) resistor r=0.103559
    rCP_75 (CP_263 CP_264) resistor r=10
    rCP_74 (CP_263 CP) resistor r=0.0864721
    rCP_73 (CP_264 CP_436) resistor r=7.88824
    rCP_72 (CP_268 CP_270) resistor r=0.18892
    rCP_71 (CP_268 CP_274) resistor r=0.0967681
    rCP_70 (CP_270 CP_271) resistor r=10
    rCP_69 (CP_271 CP_416) resistor r=12.8682
    rCP_68 (CP_273 CP_278) resistor r=0.041354
    rCP_67 (CP_274 CP_292) resistor r=1.11528
    rCP_66 (CP_275 CP_277) resistor r=0.163486
    rCP_65 (CP_275 CP_281) resistor r=0.0771447
    rCP_64 (CP_277 CP_278) resistor r=0.75
    rCP_63 (CP_280 CP_281) resistor r=0.304844
    rCP_62 (CP_280 CP_291) resistor r=0.0350658
    rCP_61 (CP_282 CP_283) resistor r=1.21058
    rCP_60 (CP_282 CP_291) resistor r=0.0421665
    rCP_59 (CP_283 CP_285) resistor r=0.0764802
    rCP_58 (CP_284 CP_285) resistor r=1.00735
    rCP_57 (CP_284 CP_287) resistor r=0.0764802
    rCP_56 (CP_286 CP_287) resistor r=0.498244
    rCP_55 (CP_286 CP_294) resistor r=0.0382401
    rCP_54 (CP_291 CP_292) resistor r=0.75
    rCP_53 (CP_294 CP_432) resistor r=0.75
    rCP_52 (CP_336 CP_436) resistor r=8.45489
    rCP_51 (CP_366 CP_417) resistor r=3.725
    rCP_50 (CP_368 CP_417) resistor r=3.725
    rCP_49 (CP_404 CP_427) resistor r=4.38767
    rCP_48 (CP_416 CP_417) resistor r=3.725
    rCP_47 (CP_426 CP_427) resistor r=3.71511
    rCP_46 (CP_426 CP_431) resistor r=6.09545
    rCP_45 (CP_431 CP_432) resistor r=10
    rD_106 (D_22 D_28) resistor r=58.3583
    rD_105 (D_22 D_28) resistor r=4.16253
    rD_104 (D_22 D_28) resistor r=58.3583
    rD_103 (D_22 D_28) resistor r=4.16253
    rD_102 (D_25 D_28) resistor r=58.3583
    rD_101 (D_25 D_28) resistor r=4.16253
    rD_100 (D_25 D_28) resistor r=58.3583
    rD_99 (D_25 D_28) resistor r=4.16253
    rD_98 (D_28 D_47) resistor r=24.8333
    rD_97 (D_28 D_44) resistor r=24.8333
    rD_96 (D_28 D_55) resistor r=24.8333
    rD_95 (D_28 D_52) resistor r=24.8333
    rD_94 (D_28 D_76) resistor r=58.3583
    rD_93 (D_28 D_79) resistor r=58.3583
    rD_92 (D_28 D_84) resistor r=14.9
    rD_91 (D_28 D_47) resistor r=4.16253
    rD_90 (D_28 D_55) resistor r=4.16253
    rD_89 (D_28 D_44) resistor r=4.16253
    rD_88 (D_28 D_76) resistor r=4.16253
    rD_87 (D_28 D_84) resistor r=6.30933
    rD_86 (D_28 D_79) resistor r=6.30933
    rD_85 (D_28 D_52) resistor r=1.63969
    rD_84 (D_28 D_47) resistor r=24.8333
    rD_83 (D_28 D_44) resistor r=24.8333
    rD_82 (D_28 D_55) resistor r=24.8333
    rD_81 (D_28 D_52) resistor r=24.8333
    rD_80 (D_28 D_76) resistor r=58.3583
    rD_79 (D_28 MM1_ELT_g) resistor r=22.35
    rD_78 (D_28 D_84) resistor r=14.9
    rD_77 (D_28 D_187) resistor r=39.7333
    rD_76 (D_28 D_47) resistor r=4.16253
    rD_75 (D_28 D_55) resistor r=4.16253
    rD_74 (D_28 D_44) resistor r=4.16253
    rD_73 (D_28 D_76) resistor r=4.16253
    rD_72 (D_28 D_84) resistor r=6.30933
    rD_71 (D_28 D_79) resistor r=6.30933
    rD_70 (D_28 D_52) resistor r=1.63969
    rD_69 (D_30 D_33) resistor r=14.9
    rD_68 (D_30 D_33) resistor r=6.30933
    rD_67 (D_30 D_33) resistor r=14.9
    rD_66 (D_30 D_33) resistor r=6.30933
    rD_65 (D_33 D_36) resistor r=58.3583
    rD_64 (D_33 D_39) resistor r=58.3583
    rD_63 (D_33 D_63) resistor r=24.8333
    rD_62 (D_33 D_60) resistor r=24.8333
    rD_61 (D_33 D_71) resistor r=24.8333
    rD_60 (D_33 D_68) resistor r=24.8333
    rD_59 (D_33 D_90) resistor r=58.3583
    rD_58 (D_33 D_93) resistor r=58.3583
    rD_57 (D_33 D_36) resistor r=6.30933
    rD_56 (D_33 D_63) resistor r=1.63969
    rD_55 (D_33 D_71) resistor r=4.16253
    rD_54 (D_33 D_39) resistor r=4.16253
    rD_53 (D_33 D_60) resistor r=4.16253
    rD_52 (D_33 D_90) resistor r=4.16253
    rD_51 (D_33 D_68) resistor r=4.16253
    rD_50 (D_33 D_93) resistor r=4.16253
    rD_49 (D_33 D_161) resistor r=39.7333
    rD_48 (D_33 D_36) resistor r=58.3583
    rD_47 (D_33 D_39) resistor r=58.3583
    rD_46 (D_33 D_63) resistor r=24.8333
    rD_45 (D_33 D_60) resistor r=24.8333
    rD_44 (D_33 D_71) resistor r=24.8333
    rD_43 (D_33 D_68) resistor r=24.8333
    rD_42 (D_33 D_90) resistor r=58.3583
    rD_41 (D_33 MM11_ELT_g) resistor r=7.45
    rD_40 (D_33 D_36) resistor r=6.30933
    rD_39 (D_33 D_63) resistor r=1.63969
    rD_38 (D_33 D_71) resistor r=4.16253
    rD_37 (D_33 D_39) resistor r=4.16253
    rD_36 (D_33 D_60) resistor r=4.16253
    rD_35 (D_33 D_90) resistor r=4.16253
    rD_34 (D_33 D_68) resistor r=4.16253
    rD_33 (D_33 D_93) resistor r=4.16253
    rD_32 (D_79 MM1_ELT_g) resistor r=36.0083
    rD_31 (D_93 MM11_ELT_g) resistor r=50.9083
    rD_30 (D_132 D_133) resistor r=10
    rD_29 (D_132 D) resistor r=0.0785015
    rD_28 (D_133 D_200) resistor r=13.5455
    rD_27 (D_161 D_201) resistor r=4.38767
    rD_26 (D_173 D_174) resistor r=57.5682
    rD_25 (D_173 D_197) resistor r=9.29775
    rD_24 (D_174 D_201) resistor r=3.71511
    rD_23 (D_187 D_195) resistor r=8.32506
    rD_22 (D_194 D_195) resistor r=40.975
    rD_21 (D_194 D_196) resistor r=8.32506
    rD_20 (D_196 D_197) resistor r=275.65
    rD_19 (D_200 D_201) resistor r=3.71511
ends DDFCNQD1UBC_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DLHCNQD1_LVT_ELT
// View name: calibre
subckt DLHCNQD1_LVT_ELT CDN D E Q VDD VSS
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=7.9985e-13 pd=1.34e-06 \
        ps=5.97e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM0_ELT (MM0_ELT_d MM0_ELT_g MM0_ELT_s MM0_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM17_ELT (MM17_ELT_d MM17_ELT_g MM17_ELT_s MM17_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.44175e-13 as=9.4e-14 pd=3.815e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM16_ELT (MM16_ELT_d MM16_ELT_g MM16_ELT_s MM16_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.31325e-13 pd=3.66e-06 \
        ps=9.4e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.98862e-13 pd=1.34e-06 \
        ps=4.19e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.98862e-13 pd=1.34e-06 \
        ps=4.19e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.33725e-13 pd=3.66e-06 \
        ps=9.44e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet17_8 (MM17_ELT_d VSS) capacitor c=7.84174e-18
    cinet17_7 (net17_5 VSS) capacitor c=4.10816e-18
    cinet17_6 (net17_7 VSS) capacitor c=6.11626e-18
    cinet17_5 (MM0_ELT_s VSS) capacitor c=9.19753e-18
    cinet17_4 (net17_11 VSS) capacitor c=6.55473e-18
    cinet17_3 (net17_14 VSS) capacitor c=1.18592e-17
    cinet17_2 (net17_16 VSS) capacitor c=4.5817e-18
    cinet17_1 (net17_18 VSS) capacitor c=1.07979e-17
    cinet17_0 (net17 VSS) capacitor c=4.29278e-18
    cinet028_5 (net028_5 VSS) capacitor c=1.13997e-17
    cinet028_4 (net028_7 VSS) capacitor c=1.12768e-18
    cinet028_3 (MM16_ELT_s VSS) capacitor c=1.112e-18
    cinet028_2 (net028_11 VSS) capacitor c=7.16788e-18
    cinet028_1 (net028_16 VSS) capacitor c=9.24374e-18
    cinet028_0 (net028 VSS) capacitor c=7.07954e-18
    ciQ_6 (Q_3 VSS) capacitor c=4.47379e-17
    ciQ_5 (Q_4 VSS) capacitor c=1.11627e-16
    ciQ_4 (Q_8 VSS) capacitor c=1.73889e-16
    ciQ_3 (Q_9 VSS) capacitor c=3.31106e-16
    ciQ_2 (Q VSS) capacitor c=7.69188e-17
    ciQ_1 (Q_23 VSS) capacitor c=2.47441e-17
    ciQ_0 (Q_27 VSS) capacitor c=1.78901e-17
    ciVDD_34 (VDD_4 VSS) capacitor c=1.32505e-16
    ciVDD_33 (VDD_13 VSS) capacitor c=4.63529e-17
    ciVDD_32 (VDD_14 VSS) capacitor c=2.63453e-17
    ciVDD_31 (VDD_20 VSS) capacitor c=6.30592e-17
    ciVDD_30 (VDD_21 VSS) capacitor c=8.40666e-17
    ciVDD_29 (VDD_23 VSS) capacitor c=8.59314e-17
    ciVDD_28 (VDD_30 VSS) capacitor c=9.02438e-17
    ciVDD_27 (VDD_31 VSS) capacitor c=1.47649e-16
    ciVDD_26 (VDD_33 VSS) capacitor c=7.62556e-17
    ciVDD_25 (VDD_40 VSS) capacitor c=1.86875e-16
    ciVDD_24 (VDD_54 VSS) capacitor c=7.46815e-17
    ciVDD_23 (VDD_62 VSS) capacitor c=3.58509e-18
    ciVDD_22 (VDD_65 VSS) capacitor c=3.58509e-18
    ciVDD_21 (VDD_67 VSS) capacitor c=3.58509e-18
    ciVDD_20 (VDD_73 VSS) capacitor c=1.11099e-18
    ciVDD_19 (VDD_74 VSS) capacitor c=3.79584e-18
    ciVDD_18 (VDD_75 VSS) capacitor c=2.3177e-18
    ciVDD_17 (VDD_78 VSS) capacitor c=2.60226e-17
    ciVDD_16 (VDD_81 VSS) capacitor c=1.64973e-18
    ciVDD_15 (VDD_84 VSS) capacitor c=1.71175e-18
    ciVDD_14 (VDD_86 VSS) capacitor c=1.64973e-18
    ciVDD_13 (VDD_89 VSS) capacitor c=1.25051e-17
    ciVDD_12 (MM8_ELT_s VSS) capacitor c=8.22979e-18
    ciVDD_11 (VDD_94 VSS) capacitor c=1.71175e-18
    ciVDD_10 (VDD_96 VSS) capacitor c=5.83962e-18
    ciVDD_9 (MM15_ELT_s VSS) capacitor c=1.34727e-18
    ciVDD_8 (VDD_99 VSS) capacitor c=6.081e-18
    ciVDD_7 (VDD_102 VSS) capacitor c=1.71175e-18
    ciVDD_6 (VDD_107 VSS) capacitor c=1.11099e-18
    ciVDD_5 (VDD_108 VSS) capacitor c=5.8958e-18
    ciVDD_4 (VDD_109 VSS) capacitor c=3.56459e-18
    ciVDD_3 (VDD_112 VSS) capacitor c=1.62337e-17
    ciVDD_2 (VDD_113 VSS) capacitor c=2.08104e-16
    ciVDD_1 (VDD_117 VSS) capacitor c=7.23396e-18
    ciVDD_0 (VDD_120 VSS) capacitor c=2.16631e-16
    ciVSS_18 (VSS_4 VSS) capacitor c=6.21529e-17
    ciVSS_17 (VSS_5 VSS) capacitor c=1.0649e-16
    ciVSS_16 (VSS_7 VSS) capacitor c=1.07542e-16
    ciVSS_15 (VSS_8 VSS) capacitor c=4.31708e-17
    ciVSS_14 (VSS_17 VSS) capacitor c=1.02942e-16
    ciVSS_13 (VSS_21 VSS) capacitor c=1.40593e-16
    ciVSS_12 (VSS_23 VSS) capacitor c=9.74446e-17
    ciVSS_11 (VSS_33 VSS) capacitor c=6.22215e-17
    ciVSS_10 (VSS_44 VSS) capacitor c=7.24272e-17
    ciVSS_9 (VSS_54 VSS) capacitor c=3.58509e-18
    ciVSS_8 (VSS_55 VSS) capacitor c=3.58509e-18
    ciVSS_7 (MM2_ELT_s VSS) capacitor c=1.112e-18
    ciVSS_6 (VSS_62 VSS) capacitor c=3.96663e-18
    ciVSS_5 (MM3_ELT_s VSS) capacitor c=5.77106e-18
    ciVSS_4 (VSS_68 VSS) capacitor c=2.72324e-18
    ciVSS_3 (MM4_ELT_s VSS) capacitor c=8.06536e-17
    ciVSS_2 (VSS_74 VSS) capacitor c=5.8958e-18
    ciVSS_1 (VSS_75 VSS) capacitor c=2.28293e-18
    ciVSS_0 (VSS_78 VSS) capacitor c=1.96647e-18
    cinet018_31 (net018_22 VSS) capacitor c=4.31636e-18
    cinet018_30 (net018_28 VSS) capacitor c=1.98615e-16
    cinet018_29 (net018_39 VSS) capacitor c=5.89253e-16
    cinet018_28 (net018_45 VSS) capacitor c=4.73887e-18
    cinet018_27 (net018_50 VSS) capacitor c=2.23559e-17
    cinet018_26 (net018_58 VSS) capacitor c=1.51948e-17
    cinet018_25 (net018_66 VSS) capacitor c=2.06726e-17
    cinet018_24 (net018_74 VSS) capacitor c=1.23274e-17
    cinet018_23 (net018_82 VSS) capacitor c=2.11871e-18
    cinet018_22 (net018_85 VSS) capacitor c=3.9912e-18
    cinet018_21 (net018_90 VSS) capacitor c=4.02575e-18
    cinet018_20 (net018_93 VSS) capacitor c=2.22299e-18
    cinet018_19 (net018_133 VSS) capacitor c=7.17912e-17
    cinet018_18 (net018_134 VSS) capacitor c=1.25445e-16
    cinet018_17 (net018_136 VSS) capacitor c=1.54221e-17
    cinet018_16 (net018_137 VSS) capacitor c=8.68531e-18
    cinet018_15 (net018_139 VSS) capacitor c=2.55988e-17
    cinet018_14 (net018_140 VSS) capacitor c=4.57406e-17
    cinet018_13 (net018_141 VSS) capacitor c=1.45485e-17
    cinet018_12 (net018_142 VSS) capacitor c=1.19684e-17
    cinet018_11 (net018_146 VSS) capacitor c=6.68464e-17
    cinet018_10 (net018_147 VSS) capacitor c=1.2171e-16
    cinet018_9 (net018_149 VSS) capacitor c=9.23817e-18
    cinet018_8 (net018_150 VSS) capacitor c=2.60553e-17
    cinet018_7 (net018_151 VSS) capacitor c=5.02949e-17
    cinet018_6 (net018_154 VSS) capacitor c=3.37544e-17
    cinet018_5 (net018_155 VSS) capacitor c=1.22962e-17
    cinet018_4 (net018_157 VSS) capacitor c=5.02586e-17
    cinet018_3 (net018_160 VSS) capacitor c=1.00018e-17
    cinet018_2 (net018_163 VSS) capacitor c=1.16747e-16
    cinet018_1 (net018_220 VSS) capacitor c=3.15005e-17
    cinet018_0 (net018_221 VSS) capacitor c=8.92074e-18
    ciCDN_13 (CDN_22 VSS) capacitor c=5.22839e-18
    ciCDN_12 (CDN_25 VSS) capacitor c=4.4443e-18
    ciCDN_11 (CDN_28 VSS) capacitor c=1.95065e-16
    ciCDN_10 (CDN_30 VSS) capacitor c=2.29198e-17
    ciCDN_9 (CDN_38 VSS) capacitor c=2.2416e-17
    ciCDN_8 (CDN_46 VSS) capacitor c=6.91386e-18
    ciCDN_7 (CDN_49 VSS) capacitor c=8.04475e-18
    ciCDN_6 (CDN_52 VSS) capacitor c=1.54927e-16
    ciCDN_5 (CDN_60 VSS) capacitor c=2.54861e-17
    ciCDN_4 (CDN_68 VSS) capacitor c=2.2672e-17
    ciCDN_3 (CDN_79 VSS) capacitor c=2.80914e-18
    ciCDN_2 (CDN_90 VSS) capacitor c=1.93052e-18
    ciCDN_1 (CDN VSS) capacitor c=4.35147e-17
    ciCDN_0 (CDN_135 VSS) capacitor c=4.45667e-17
    cinet26_8 (net26_3 VSS) capacitor c=5.01029e-17
    cinet26_7 (net26_4 VSS) capacitor c=1.07315e-16
    cinet26_6 (net26_8 VSS) capacitor c=5.39093e-17
    cinet26_5 (net26_9 VSS) capacitor c=1.11981e-16
    cinet26_4 (net26_11 VSS) capacitor c=8.57535e-17
    cinet26_3 (net26_12 VSS) capacitor c=1.40981e-17
    cinet26_2 (net26_13 VSS) capacitor c=6.80986e-17
    cinet26_1 (net26_14 VSS) capacitor c=1.4265e-17
    cinet26_0 (net26_16 VSS) capacitor c=3.43355e-17
    ciY_29 (Y_25 VSS) capacitor c=2.0467e-16
    ciY_28 (Y_31 VSS) capacitor c=4.15066e-18
    ciY_27 (Y_36 VSS) capacitor c=2.09616e-17
    ciY_26 (Y_44 VSS) capacitor c=2.2416e-17
    ciY_25 (Y_52 VSS) capacitor c=3.00043e-18
    ciY_24 (Y_55 VSS) capacitor c=2.8235e-18
    ciY_23 (Y_58 VSS) capacitor c=1.94543e-16
    ciY_22 (Y_60 VSS) capacitor c=5.01812e-18
    ciY_21 (Y_63 VSS) capacitor c=4.4443e-18
    ciY_20 (Y_68 VSS) capacitor c=2.23697e-17
    ciY_19 (Y_76 VSS) capacitor c=2.20667e-17
    ciY_18 (Y_84 VSS) capacitor c=2.14282e-18
    ciY_17 (Y_133 VSS) capacitor c=4.23515e-17
    ciY_16 (Y_134 VSS) capacitor c=1.53171e-16
    ciY_15 (Y_136 VSS) capacitor c=3.27471e-17
    ciY_14 (Y_137 VSS) capacitor c=1.52735e-17
    ciY_13 (Y_138 VSS) capacitor c=1.32223e-17
    ciY_12 (Y_139 VSS) capacitor c=2.73027e-17
    ciY_11 (Y_140 VSS) capacitor c=4.81775e-17
    ciY_10 (Y_143 VSS) capacitor c=2.54384e-17
    ciY_9 (Y_145 VSS) capacitor c=2.40704e-17
    ciY_8 (Y_149 VSS) capacitor c=5.8202e-17
    ciY_7 (Y_150 VSS) capacitor c=1.63575e-17
    ciY_6 (Y_152 VSS) capacitor c=1.0057e-16
    ciY_5 (Y_157 VSS) capacitor c=1.23379e-16
    ciY_4 (Y_160 VSS) capacitor c=2.3812e-17
    ciY_3 (Y_163 VSS) capacitor c=1.05331e-17
    ciY_2 (Y_221 VSS) capacitor c=3.98077e-17
    ciY_1 (Y_230 VSS) capacitor c=2.30865e-17
    ciY_0 (Y_231 VSS) capacitor c=3.78811e-17
    cinet33_8 (net33_3 VSS) capacitor c=5.64558e-17
    cinet33_7 (net33_6 VSS) capacitor c=8.6471e-17
    cinet33_6 (net33_7 VSS) capacitor c=8.84847e-18
    cinet33_5 (net33_10 VSS) capacitor c=1.34501e-16
    cinet33_4 (net33_11 VSS) capacitor c=1.12183e-16
    cinet33_3 (net33_17 VSS) capacitor c=3.7355e-18
    cinet33_2 (net33_18 VSS) capacitor c=2.54046e-18
    cinet33_1 (net33_21 VSS) capacitor c=8.34739e-18
    cinet33_0 (net33_22 VSS) capacitor c=8.11136e-17
    ciE_22 (E_32 VSS) capacitor c=5.8178e-18
    ciE_21 (E_35 VSS) capacitor c=8.45613e-18
    ciE_20 (E_38 VSS) capacitor c=1.38545e-16
    ciE_19 (E_40 VSS) capacitor c=2.23697e-17
    ciE_18 (E_48 VSS) capacitor c=2.44871e-17
    ciE_17 (E_56 VSS) capacitor c=2.22299e-18
    ciE_16 (E_70 VSS) capacitor c=2.22299e-18
    ciE_15 (E_76 VSS) capacitor c=1.87052e-16
    ciE_14 (E_84 VSS) capacitor c=2.2416e-17
    ciE_13 (E_92 VSS) capacitor c=1.97318e-17
    ciE_12 (E_100 VSS) capacitor c=3.00043e-18
    ciE_11 (E_103 VSS) capacitor c=2.28929e-18
    ciE_10 (E_111 VSS) capacitor c=1.623e-16
    ciE_9 (E_117 VSS) capacitor c=3.04726e-18
    ciE_8 (E_122 VSS) capacitor c=2.6608e-17
    ciE_7 (E_130 VSS) capacitor c=2.47051e-17
    ciE_6 (E_138 VSS) capacitor c=6.79161e-18
    ciE_5 (E_141 VSS) capacitor c=9.66321e-18
    ciE_4 (E VSS) capacitor c=5.46977e-17
    ciE_3 (E_262 VSS) capacitor c=8.97178e-17
    ciE_2 (E_290 VSS) capacitor c=1.27335e-17
    ciE_1 (E_293 VSS) capacitor c=3.56129e-17
    ciE_0 (E_294 VSS) capacitor c=4.5782e-18
    ciX_26 (X_24 VSS) capacitor c=2.18467e-18
    ciX_25 (X_27 VSS) capacitor c=3.25905e-18
    ciX_24 (X_30 VSS) capacitor c=2.24152e-16
    ciX_23 (X_32 VSS) capacitor c=1.33519e-17
    ciX_22 (X_40 VSS) capacitor c=2.23559e-17
    ciX_21 (X_54 VSS) capacitor c=9.4569e-18
    ciX_20 (X_60 VSS) capacitor c=2.19523e-16
    ciX_19 (X_68 VSS) capacitor c=1.43233e-17
    ciX_18 (X_76 VSS) capacitor c=3.10089e-17
    ciX_17 (X_84 VSS) capacitor c=2.35033e-17
    ciX_16 (X_92 VSS) capacitor c=4.61986e-18
    ciX_15 (X_95 VSS) capacitor c=4.04637e-18
    ciX_14 (X_100 VSS) capacitor c=7.24612e-18
    ciX_13 (X_103 VSS) capacitor c=7.49382e-18
    ciX_12 (X_148 VSS) capacitor c=6.97987e-17
    ciX_11 (X_149 VSS) capacitor c=3.50249e-16
    ciX_10 (X_152 VSS) capacitor c=7.38793e-17
    ciX_9 (X_160 VSS) capacitor c=6.09665e-17
    ciX_8 (X_164 VSS) capacitor c=6.03248e-17
    ciX_7 (X_165 VSS) capacitor c=3.80137e-17
    ciX_6 (X_166 VSS) capacitor c=9.59845e-18
    ciX_5 (X_169 VSS) capacitor c=3.6233e-17
    ciX_4 (X_170 VSS) capacitor c=1.07388e-16
    ciX_3 (X_174 VSS) capacitor c=2.75256e-17
    ciX_2 (X_176 VSS) capacitor c=5.88295e-18
    ciX_1 (X_238 VSS) capacitor c=3.32099e-17
    ciX_0 (X_240 VSS) capacitor c=1.72231e-17
    ciD_14 (D_22 VSS) capacitor c=2.22299e-18
    ciD_13 (D_28 VSS) capacitor c=1.35353e-16
    ciD_12 (D_39 VSS) capacitor c=6.32691e-16
    ciD_11 (D_45 VSS) capacitor c=3.44142e-18
    ciD_10 (D_50 VSS) capacitor c=2.45049e-17
    ciD_9 (D_58 VSS) capacitor c=1.58689e-17
    ciD_8 (D_66 VSS) capacitor c=1.35016e-17
    ciD_7 (D_74 VSS) capacitor c=1.51948e-17
    ciD_6 (D_82 VSS) capacitor c=4.27837e-18
    ciD_5 (D_85 VSS) capacitor c=6.47132e-18
    ciD_4 (D_90 VSS) capacitor c=4.89832e-18
    ciD_3 (D_93 VSS) capacitor c=3.86639e-18
    ciD_2 (D VSS) capacitor c=3.8239e-17
    ciD_1 (D_196 VSS) capacitor c=1.86543e-17
    ciD_0 (D_198 VSS) capacitor c=1.71033e-17
    rnet17_34 (MM17_ELT_d net17_2) resistor r=18.0507
    rnet17_33 (MM17_ELT_d net17_5) resistor r=15.1041
    rnet17_32 (MM17_ELT_d net17_5) resistor r=2.67027
    rnet17_31 (MM17_ELT_d net17_7) resistor r=12.8495
    rnet17_30 (MM17_ELT_d net17_7) resistor r=1.69926
    rnet17_29 (MM17_ELT_d net17_11) resistor r=4.22001
    rnet17_28 (MM17_ELT_d net17) resistor r=10.6787
    rnet17_27 (net17_2 net17_4) resistor r=9.43134
    rnet17_26 (net17_4 net17_5) resistor r=15.1041
    rnet17_25 (net17_6 net17_7) resistor r=12.8495
    rnet17_24 (net17_6 net17_18) resistor r=10.6787
    rnet17_23 (net17_8 net17_11) resistor r=4.22001
    rnet17_22 (net17_8 net17_18) resistor r=0.57282
    rnet17_21 (net17_9 net17_11) resistor r=4.22001
    rnet17_20 (net17_9 net17) resistor r=0.57282
    rnet17_19 (MM0_ELT_s net17_11) resistor r=4.22001
    rnet17_18 (MM0_ELT_s net17_14) resistor r=15.1041
    rnet17_17 (MM0_ELT_s net17_14) resistor r=2.67027
    rnet17_16 (MM0_ELT_s net17_16) resistor r=12.1643
    rnet17_15 (MM0_ELT_s net17_16) resistor r=1.36649
    rnet17_14 (MM0_ELT_s net17_17) resistor r=18.0507
    rnet17_13 (MM0_ELT_s net17_18) resistor r=10.6787
    rnet17_12 (net17_12 net17_14) resistor r=15.1041
    rnet17_11 (net17_12 net17_17) resistor r=9.43134
    rnet17_10 (net17_15 net17_16) resistor r=12.1643
    rnet17_9 (net17_15 net17) resistor r=10.6787
    rnet028_31 (MM1_ELT_d net028_2) resistor r=18.0507
    rnet028_30 (MM1_ELT_d net028_5) resistor r=2.67027
    rnet028_29 (MM1_ELT_d net028_7) resistor r=12.8495
    rnet028_28 (MM1_ELT_d net028_7) resistor r=1.69926
    rnet028_27 (MM1_ELT_d net028_11) resistor r=4.22001
    rnet028_26 (net028_2 net028_4) resistor r=9.43134
    rnet028_25 (net028_3 net028_5) resistor r=15.1041
    rnet028_24 (net028_3 net028_18) resistor r=11.0157
    rnet028_23 (net028_4 net028_5) resistor r=15.1041
    rnet028_22 (net028_6 net028_7) resistor r=12.8495
    rnet028_21 (net028_6 net028) resistor r=10.6787
    rnet028_20 (net028_8 net028_11) resistor r=4.22001
    rnet028_19 (net028_8 net028_18) resistor r=0.762262
    rnet028_18 (net028_9 net028_11) resistor r=4.22001
    rnet028_17 (net028_9 net028) resistor r=0.57282
    rnet028_16 (MM16_ELT_s net028_11) resistor r=4.22001
    rnet028_15 (MM16_ELT_s net028_14) resistor r=2.67027
    rnet028_14 (MM16_ELT_s net028_16) resistor r=12.8495
    rnet028_13 (MM16_ELT_s net028_16) resistor r=1.69926
    rnet028_12 (MM16_ELT_s net028_17) resistor r=18.0507
    rnet028_11 (net028_12 net028_14) resistor r=15.1041
    rnet028_10 (net028_12 net028_17) resistor r=9.43134
    rnet028_9 (net028_13 net028_14) resistor r=15.1041
    rnet028_8 (net028_13 net028_18) resistor r=11.0157
    rnet028_7 (net028_15 net028_16) resistor r=12.8495
    rnet028_6 (net028_15 net028) resistor r=10.6787
    rQ_26 (Q_1 Q_3) resistor r=0.303795
    rQ_25 (Q_1 Q_21) resistor r=0.0101012
    rQ_24 (Q_3 Q_4) resistor r=13
    rQ_23 (Q_4 MM4_ELT_d) resistor r=8.44
    rQ_22 (Q_6 Q_8) resistor r=0.341103
    rQ_21 (Q_6 Q_25) resistor r=0.0101012
    rQ_20 (Q_8 Q_9) resistor r=8.66667
    rQ_19 (Q_8 Q_11) resistor r=0.639568
    rQ_18 (Q_9 MM7_ELT_d) resistor r=32.3614
    rQ_17 (Q_11 Q_12) resistor r=8.66667
    rQ_16 (Q_11 Q_14) resistor r=0.426378
    rQ_15 (Q_12 MM7_ELT_d) resistor r=16.1807
    rQ_14 (Q_12 Q_15) resistor r=32.3614
    rQ_13 (Q_14 Q_15) resistor r=26
    rQ_12 (Q_17 Q) resistor r=0.156165
    rQ_11 (Q_17 Q_23) resistor r=0.0101012
    rQ_10 (Q_18 Q) resistor r=0.619193
    rQ_9 (Q_18 Q_27) resistor r=0.0101012
    rQ_8 (Q_21 Q_23) resistor r=0.126884
    rQ_7 (Q_25 Q_27) resistor r=0.126884
    rVDD_157 (MM9_ELT_b MM11_ELT_b) resistor r=0.01
    rVDD_156 (MM8_ELT_b MM11_ELT_b) resistor r=0.01
    rVDD_155 (MM15_ELT_b MM11_ELT_b) resistor r=0.01
    rVDD_154 (MM7_ELT_b MM11_ELT_b) resistor r=0.01
    rVDD_153 (MM11_ELT_b VDD_36) resistor r=8.66667
    rVDD_152 (MM11_ELT_b VDD_51) resistor r=8.66667
    rVDD_151 (MM11_ELT_b VDD_54) resistor r=13
    rVDD_150 (MM11_ELT_b VDD_65) resistor r=8.66667
    rVDD_149 (MM11_ELT_b VDD_27) resistor r=56.2667
    rVDD_148 (VDD_2 VDD_11) resistor r=0.490335
    rVDD_147 (VDD_2 VDD_60) resistor r=0.119092
    rVDD_146 (VDD_4 VDD_12) resistor r=8.66667
    rVDD_145 (VDD_4 VDD_8) resistor r=0.639568
    rVDD_144 (VDD_8 VDD_12) resistor r=8.66667
    rVDD_143 (VDD_8 VDD_11) resistor r=0.639568
    rVDD_142 (VDD_11 VDD_12) resistor r=8.66667
    rVDD_141 (VDD_12 MM11_ELT_s) resistor r=1.847
    rVDD_140 (VDD_12 VDD_113) resistor r=20.317
    rVDD_139 (VDD_13 VDD_16) resistor r=0.221168
    rVDD_138 (VDD_13 VDD_62) resistor r=0.0221351
    rVDD_137 (VDD_14 VDD_16) resistor r=0.0335701
    rVDD_136 (VDD_14 VDD_60) resistor r=0.0177724
    rVDD_135 (VDD_16 VDD_17) resistor r=8.66667
    rVDD_134 (VDD_17 VDD_63) resistor r=67.52
    rVDD_133 (VDD_18 VDD_20) resistor r=0.511654
    rVDD_132 (VDD_18 VDD_62) resistor r=0.0882547
    rVDD_131 (VDD_20 VDD_21) resistor r=8.66667
    rVDD_130 (VDD_21 VDD_115) resistor r=16.4995
    rVDD_129 (VDD_21 VDD_114) resistor r=16.4995
    rVDD_128 (VDD_21 MM9_ELT_s) resistor r=3.29107
    rVDD_127 (VDD_23 VDD_26) resistor r=0.221168
    rVDD_126 (VDD_23 VDD_65) resistor r=0.0221351
    rVDD_125 (VDD_24 VDD_26) resistor r=0.217218
    rVDD_124 (VDD_24 VDD_62) resistor r=0.0221351
    rVDD_123 (VDD_26 VDD_27) resistor r=8.66667
    rVDD_122 (VDD_27 VDD_63) resistor r=67.52
    rVDD_121 (VDD_28 VDD_30) resistor r=0.561742
    rVDD_120 (VDD_28 VDD_65) resistor r=0.0882547
    rVDD_119 (VDD_30 VDD_31) resistor r=8.66667
    rVDD_118 (VDD_31 MM15_ELT_s) resistor r=4.04518
    rVDD_117 (VDD_31 VDD_118) resistor r=4.04518
    rVDD_116 (VDD_31 MM8_ELT_s) resistor r=4.04518
    rVDD_115 (VDD_31 VDD_116) resistor r=4.04518
    rVDD_114 (VDD_33 VDD_36) resistor r=0.187598
    rVDD_113 (VDD_33 VDD_67) resistor r=0.0221351
    rVDD_112 (VDD_34 VDD_36) resistor r=0.217218
    rVDD_111 (VDD_34 VDD_65) resistor r=0.0221351
    rVDD_110 (VDD_38 VDD_47) resistor r=0.490335
    rVDD_109 (VDD_38 VDD_67) resistor r=0.0882547
    rVDD_108 (VDD_40 VDD_48) resistor r=8.66667
    rVDD_107 (VDD_40 VDD_44) resistor r=0.668941
    rVDD_106 (VDD_44 VDD_48) resistor r=8.66667
    rVDD_105 (VDD_44 VDD_47) resistor r=0.668941
    rVDD_104 (VDD_47 VDD_48) resistor r=8.66667
    rVDD_103 (VDD_48 MM7_ELT_s) resistor r=1.847
    rVDD_102 (VDD_48 VDD_120) resistor r=20.317
    rVDD_101 (VDD_49 VDD_51) resistor r=0.013823
    rVDD_100 (VDD_49 VDD_67) resistor r=0.0221351
    rVDD_99 (VDD_51 VDD_54) resistor r=0.157977
    rVDD_98 (VDD VDD_60) resistor r=0.0513425
    rVDD_97 (VDD_62 VDD_63) resistor r=8.66667
    rVDD_96 (MM11_ELT_s VDD_73) resistor r=2.55965
    rVDD_95 (MM11_ELT_s VDD_75) resistor r=12.3172
    rVDD_94 (MM11_ELT_s VDD_75) resistor r=1.62887
    rVDD_93 (MM11_ELT_s VDD_78) resistor r=6.12113
    rVDD_92 (VDD_71 VDD_73) resistor r=14.4784
    rVDD_91 (VDD_71 VDD_77) resistor r=9.04062
    rVDD_90 (VDD_72 VDD_73) resistor r=14.4784
    rVDD_89 (VDD_72 VDD_113) resistor r=9.48555
    rVDD_88 (VDD_74 VDD_75) resistor r=12.3172
    rVDD_87 (VDD_74 VDD_76) resistor r=9.04595
    rVDD_86 (VDD_76 VDD_78) resistor r=31.2341
    rVDD_85 (VDD_77 VDD_78) resistor r=31.2341
    rVDD_84 (MM9_ELT_s VDD_81) resistor r=7.31976
    rVDD_83 (MM9_ELT_s VDD_81) resistor r=1.40052
    rVDD_82 (MM9_ELT_s VDD_84) resistor r=2.55965
    rVDD_81 (MM9_ELT_s VDD_86) resistor r=7.31976
    rVDD_80 (MM9_ELT_s VDD_86) resistor r=1.40052
    rVDD_79 (MM9_ELT_s VDD_89) resistor r=4.36821
    rVDD_78 (VDD_80 VDD_81) resistor r=7.31976
    rVDD_77 (VDD_80 VDD_114) resistor r=9.39461
    rVDD_76 (VDD_82 VDD_84) resistor r=14.4784
    rVDD_75 (VDD_82 VDD_88) resistor r=9.04062
    rVDD_74 (VDD_83 VDD_84) resistor r=14.4784
    rVDD_73 (VDD_83 VDD_115) resistor r=9.48555
    rVDD_72 (VDD_85 VDD_86) resistor r=7.31976
    rVDD_71 (VDD_85 VDD_87) resistor r=9.04595
    rVDD_70 (VDD_87 VDD_89) resistor r=20.2547
    rVDD_69 (VDD_88 VDD_89) resistor r=20.2547
    rVDD_68 (MM8_ELT_s VDD_91) resistor r=17.3029
    rVDD_67 (MM8_ELT_s VDD_94) resistor r=2.55965
    rVDD_66 (MM8_ELT_s VDD_96) resistor r=12.3172
    rVDD_65 (MM8_ELT_s VDD_96) resistor r=1.62887
    rVDD_64 (VDD_91 VDD_93) resistor r=9.04062
    rVDD_63 (VDD_92 VDD_94) resistor r=14.4784
    rVDD_62 (VDD_92 VDD_119) resistor r=10.5593
    rVDD_61 (VDD_93 VDD_94) resistor r=14.4784
    rVDD_60 (VDD_95 VDD_96) resistor r=12.3172
    rVDD_59 (VDD_95 VDD_117) resistor r=10.2363
    rVDD_58 (MM15_ELT_s VDD_99) resistor r=11.6604
    rVDD_57 (MM15_ELT_s VDD_99) resistor r=1.30988
    rVDD_56 (MM15_ELT_s VDD_102) resistor r=2.55965
    rVDD_55 (MM15_ELT_s VDD_103) resistor r=9.44154
    rVDD_54 (VDD_98 VDD_99) resistor r=11.6604
    rVDD_53 (VDD_98 VDD_117) resistor r=10.2363
    rVDD_52 (VDD_100 VDD_102) resistor r=14.4784
    rVDD_51 (VDD_100 VDD_103) resistor r=14.5612
    rVDD_50 (VDD_101 VDD_102) resistor r=14.4784
    rVDD_49 (VDD_101 VDD_119) resistor r=10.5593
    rVDD_48 (MM7_ELT_s VDD_107) resistor r=2.55965
    rVDD_47 (MM7_ELT_s VDD_109) resistor r=11.6604
    rVDD_46 (MM7_ELT_s VDD_109) resistor r=1.30988
    rVDD_45 (MM7_ELT_s VDD_112) resistor r=6.12113
    rVDD_44 (VDD_105 VDD_107) resistor r=14.4784
    rVDD_43 (VDD_105 VDD_111) resistor r=9.04062
    rVDD_42 (VDD_106 VDD_107) resistor r=14.4784
    rVDD_41 (VDD_106 VDD_120) resistor r=9.48555
    rVDD_40 (VDD_108 VDD_109) resistor r=11.6604
    rVDD_39 (VDD_108 VDD_110) resistor r=9.04595
    rVDD_38 (VDD_110 VDD_112) resistor r=31.2341
    rVDD_37 (VDD_111 VDD_112) resistor r=31.2341
    rVDD_36 (VDD_116 VDD_117) resistor r=0.549089
    rVDD_35 (VDD_118 VDD_119) resistor r=0.730683
    rVSS_102 (MM16_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_101 (MM6_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_100 (MM2_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_99 (MM17_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_98 (MM3_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_97 (MM0_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_96 (MM4_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_95 (MM1_ELT_b VSS_26) resistor r=8.66667
    rVSS_94 (MM1_ELT_b VSS_29) resistor r=8.66667
    rVSS_93 (MM1_ELT_b VSS_41) resistor r=8.66667
    rVSS_92 (MM1_ELT_b VSS_44) resistor r=13
    rVSS_91 (MM1_ELT_b VSS_14) resistor r=53.9357
    rVSS_90 (VSS_2 VSS_4) resistor r=0.370891
    rVSS_89 (VSS_2 VSS_53) resistor r=0.119092
    rVSS_88 (VSS_4 VSS_5) resistor r=13
    rVSS_87 (VSS_5 MM1_ELT_s) resistor r=8.44
    rVSS_86 (VSS_7 VSS_13) resistor r=0.114533
    rVSS_85 (VSS_7 VSS_54) resistor r=0.0221351
    rVSS_84 (VSS_8 VSS_10) resistor r=0.189572
    rVSS_83 (VSS_8 VSS_53) resistor r=0.0177724
    rVSS_82 (VSS_10 VSS_11) resistor r=8.66667
    rVSS_81 (VSS_10 VSS_13) resistor r=0.236965
    rVSS_80 (VSS_11 VSS_52) resistor r=64.7228
    rVSS_79 (VSS_11 VSS_14) resistor r=64.7228
    rVSS_78 (VSS_13 VSS_14) resistor r=8.66667
    rVSS_77 (VSS_15 VSS_17) resistor r=0.438861
    rVSS_76 (VSS_15 VSS_54) resistor r=0.0882547
    rVSS_75 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_74 (VSS_17 VSS_20) resistor r=0.468119
    rVSS_73 (VSS_18 MM3_ELT_s) resistor r=4.22001
    rVSS_72 (VSS_18 VSS_90) resistor r=4.22001
    rVSS_71 (VSS_18 MM2_ELT_s) resistor r=4.22001
    rVSS_70 (VSS_18 VSS_79) resistor r=4.22001
    rVSS_69 (VSS_20 VSS_21) resistor r=26
    rVSS_68 (VSS_21 VSS_67) resistor r=10.6787
    rVSS_67 (VSS_21 VSS_61) resistor r=10.6787
    rVSS_66 (VSS_21 VSS_90) resistor r=0.57282
    rVSS_65 (VSS_23 VSS_29) resistor r=0.187598
    rVSS_64 (VSS_23 VSS_55) resistor r=0.0221351
    rVSS_63 (VSS_24 VSS_26) resistor r=0.0868873
    rVSS_62 (VSS_24 VSS_54) resistor r=0.0221351
    rVSS_61 (VSS_26 VSS_29) resistor r=0.236965
    rVSS_60 (VSS_31 VSS_33) resistor r=0.39973
    rVSS_59 (VSS_31 VSS_55) resistor r=0.0882547
    rVSS_58 (VSS_33 VSS_34) resistor r=8.66667
    rVSS_57 (VSS_33 VSS_36) resistor r=0.426378
    rVSS_56 (VSS_34 VSS_36) resistor r=26
    rVSS_55 (VSS_34 MM4_ELT_s) resistor r=5.69461
    rVSS_54 (VSS_39 VSS_41) resistor r=0.013823
    rVSS_53 (VSS_39 VSS_55) resistor r=0.0221351
    rVSS_52 (VSS_41 VSS_44) resistor r=0.157977
    rVSS_51 (VSS VSS_51) resistor r=0.10071
    rVSS_50 (VSS_51 VSS_52) resistor r=8.66667
    rVSS_49 (VSS_51 VSS_53) resistor r=0.0296207
    rVSS_48 (MM2_ELT_s VSS_57) resistor r=18.0507
    rVSS_47 (MM2_ELT_s VSS_60) resistor r=2.67027
    rVSS_46 (MM2_ELT_s VSS_62) resistor r=12.8495
    rVSS_45 (MM2_ELT_s VSS_62) resistor r=1.69926
    rVSS_44 (VSS_57 VSS_59) resistor r=9.43134
    rVSS_43 (VSS_58 VSS_60) resistor r=15.1041
    rVSS_42 (VSS_58 VSS_80) resistor r=11.0157
    rVSS_41 (VSS_59 VSS_60) resistor r=15.1041
    rVSS_40 (VSS_61 VSS_62) resistor r=12.8495
    rVSS_39 (MM3_ELT_s VSS_66) resistor r=2.67027
    rVSS_38 (MM3_ELT_s VSS_68) resistor r=12.8495
    rVSS_37 (MM3_ELT_s VSS_68) resistor r=1.69926
    rVSS_36 (MM3_ELT_s VSS_69) resistor r=18.0507
    rVSS_35 (VSS_64 VSS_66) resistor r=15.1041
    rVSS_34 (VSS_64 VSS_69) resistor r=9.43134
    rVSS_33 (VSS_65 VSS_66) resistor r=15.1041
    rVSS_32 (VSS_65 VSS_80) resistor r=11.0157
    rVSS_31 (VSS_67 VSS_68) resistor r=12.8495
    rVSS_30 (MM4_ELT_s VSS_73) resistor r=15.1041
    rVSS_29 (MM4_ELT_s VSS_73) resistor r=2.67027
    rVSS_28 (MM4_ELT_s VSS_75) resistor r=12.1643
    rVSS_27 (MM4_ELT_s VSS_75) resistor r=1.36649
    rVSS_26 (MM4_ELT_s VSS_78) resistor r=4.557
    rVSS_25 (VSS_71 VSS_73) resistor r=15.1041
    rVSS_24 (VSS_71 VSS_76) resistor r=9.43134
    rVSS_23 (VSS_74 VSS_75) resistor r=12.1643
    rVSS_22 (VSS_74 VSS_77) resistor r=9.4369
    rVSS_21 (VSS_76 VSS_78) resistor r=21.1301
    rVSS_20 (VSS_77 VSS_78) resistor r=21.1301
    rVSS_19 (VSS_79 VSS_80) resistor r=0.762262
    rnet018_140 (MM15_ELT_d net018) resistor r=0.01
    rnet018_139 (net018_22 net018_28) resistor r=58.3583
    rnet018_138 (net018_22 net018_28) resistor r=4.16253
    rnet018_137 (net018_22 net018_28) resistor r=58.3583
    rnet018_136 (net018_22 net018_28) resistor r=4.16253
    rnet018_135 (net018_25 net018_28) resistor r=58.3583
    rnet018_134 (net018_25 net018_28) resistor r=5.53947
    rnet018_133 (net018_25 net018_28) resistor r=58.3583
    rnet018_132 (net018_25 net018_28) resistor r=5.53947
    rnet018_131 (net018_28 net018_30) resistor r=11.175
    rnet018_130 (net018_28 net018_53) resistor r=24.8333
    rnet018_129 (net018_28 net018_50) resistor r=24.8333
    rnet018_128 (net018_28 net018_69) resistor r=22.35
    rnet018_127 (net018_28 net018_66) resistor r=22.35
    rnet018_126 (net018_28 net018_82) resistor r=58.3583
    rnet018_125 (net018_28 net018_85) resistor r=58.3583
    rnet018_124 (net018_28 net018_53) resistor r=4.16253
    rnet018_123 (net018_28 net018_30) resistor r=5.53947
    rnet018_122 (net018_28 net018_69) resistor r=2.32428
    rnet018_121 (net018_28 net018_50) resistor r=4.16253
    rnet018_120 (net018_28 net018_82) resistor r=4.16253
    rnet018_119 (net018_28 net018_66) resistor r=4.16253
    rnet018_118 (net018_28 net018_85) resistor r=4.16253
    rnet018_117 (net018_28 net018_30) resistor r=11.175
    rnet018_116 (net018_28 net018_188) resistor r=29.8
    rnet018_115 (net018_28 net018_53) resistor r=24.8333
    rnet018_114 (net018_28 net018_50) resistor r=24.8333
    rnet018_113 (net018_28 net018_69) resistor r=22.35
    rnet018_112 (net018_28 net018_66) resistor r=22.35
    rnet018_111 (net018_28 net018_82) resistor r=58.3583
    rnet018_110 (net018_28 MM4_ELT_g) resistor r=7.45
    rnet018_109 (net018_28 net018_53) resistor r=4.16253
    rnet018_108 (net018_28 net018_30) resistor r=5.53947
    rnet018_107 (net018_28 net018_69) resistor r=2.32428
    rnet018_106 (net018_28 net018_50) resistor r=4.16253
    rnet018_105 (net018_28 net018_82) resistor r=4.16253
    rnet018_104 (net018_28 net018_66) resistor r=4.16253
    rnet018_103 (net018_28 net018_85) resistor r=4.16253
    rnet018_102 (net018_36 net018_39) resistor r=11.175
    rnet018_101 (net018_36 net018_39) resistor r=5.53947
    rnet018_100 (net018_36 net018_39) resistor r=11.175
    rnet018_99 (net018_36 net018_39) resistor r=5.53947
    rnet018_98 (net018_39 net018_42) resistor r=202.392
    rnet018_97 (net018_39 net018_45) resistor r=202.392
    rnet018_96 (net018_39 net018_61) resistor r=24.8333
    rnet018_95 (net018_39 net018_58) resistor r=24.8333
    rnet018_94 (net018_39 net018_77) resistor r=22.35
    rnet018_93 (net018_39 net018_74) resistor r=22.35
    rnet018_92 (net018_39 net018_90) resistor r=202.392
    rnet018_91 (net018_39 net018_93) resistor r=202.392
    rnet018_90 (net018_39 net018_42) resistor r=5.53947
    rnet018_89 (net018_39 net018_77) resistor r=2.32428
    rnet018_88 (net018_39 net018_61) resistor r=4.16253
    rnet018_87 (net018_39 net018_45) resistor r=4.16253
    rnet018_86 (net018_39 net018_74) resistor r=4.16253
    rnet018_85 (net018_39 net018_90) resistor r=4.16253
    rnet018_84 (net018_39 net018_58) resistor r=4.16253
    rnet018_83 (net018_39 net018_93) resistor r=4.16253
    rnet018_82 (net018_39 net018_190) resistor r=31.6625
    rnet018_81 (net018_39 net018_42) resistor r=202.392
    rnet018_80 (net018_39 net018_45) resistor r=202.392
    rnet018_79 (net018_39 net018_61) resistor r=24.8333
    rnet018_78 (net018_39 net018_58) resistor r=24.8333
    rnet018_77 (net018_39 net018_77) resistor r=22.35
    rnet018_76 (net018_39 net018_74) resistor r=22.35
    rnet018_75 (net018_39 net018_90) resistor r=202.392
    rnet018_74 (net018_39 MM7_ELT_g) resistor r=7.45
    rnet018_73 (net018_39 net018_42) resistor r=5.53947
    rnet018_72 (net018_39 net018_77) resistor r=2.32428
    rnet018_71 (net018_39 net018_61) resistor r=4.16253
    rnet018_70 (net018_39 net018_45) resistor r=4.16253
    rnet018_69 (net018_39 net018_74) resistor r=4.16253
    rnet018_68 (net018_39 net018_90) resistor r=4.16253
    rnet018_67 (net018_39 net018_58) resistor r=4.16253
    rnet018_66 (net018_39 net018_93) resistor r=4.16253
    rnet018_65 (net018_85 MM4_ELT_g) resistor r=50.9083
    rnet018_64 (net018_93 MM7_ELT_g) resistor r=194.942
    rnet018_63 (net018_131 net018_133) resistor r=0.302011
    rnet018_62 (net018_131 net018_137) resistor r=0.0961003
    rnet018_61 (net018_133 net018_134) resistor r=13
    rnet018_60 (net018_134 MM8_ELT_d) resistor r=8.09035
    rnet018_59 (net018_136 net018_137) resistor r=0.236187
    rnet018_58 (net018_136 net018_160) resistor r=0.0728318
    rnet018_57 (net018_138 net018_139) resistor r=0.33185
    rnet018_56 (net018_138 net018_141) resistor r=0.0961003
    rnet018_55 (net018_139 net018_160) resistor r=0.0189277
    rnet018_54 (net018_140 net018_141) resistor r=0.33673
    rnet018_53 (net018_140 net018_150) resistor r=0.0961003
    rnet018_52 (net018_142 net018_143) resistor r=0.151285
    rnet018_51 (net018_142 net018_144) resistor r=0.0961003
    rnet018_50 (net018_143 net018_160) resistor r=0.0728318
    rnet018_49 (net018_144 net018_146) resistor r=0.293135
    rnet018_48 (net018_146 net018_147) resistor r=13
    rnet018_47 (net018_147 net018) resistor r=8.09035
    rnet018_46 (net018_149 net018_150) resistor r=0.366011
    rnet018_45 (net018_149 net018_162) resistor r=0.0480502
    rnet018_44 (net018_151 net018_152) resistor r=0.409368
    rnet018_43 (net018_151 net018_154) resistor r=0.0961003
    rnet018_42 (net018_152 net018_162) resistor r=0.0480502
    rnet018_41 (net018_153 net018_154) resistor r=0.355775
    rnet018_40 (net018_153 net018_155) resistor r=0.101154
    rnet018_39 (net018_155 net018_157) resistor r=0.095446
    rnet018_38 (net018_157 net018_158) resistor r=10
    rnet018_37 (net018_158 net018_220) resistor r=23.7045
    rnet018_36 (net018_162 net018_163) resistor r=13
    rnet018_35 (net018_163 MM0_ELT_d) resistor r=8.44
    rnet018_34 (net018_188 net018_221) resistor r=8.1518
    rnet018_33 (net018_190 net018_221) resistor r=8.1518
    rnet018_32 (net018_220 net018_221) resistor r=0.275023
    rCDN_94 (CDN_22 CDN_28) resistor r=58.3583
    rCDN_93 (CDN_22 CDN_28) resistor r=4.16253
    rCDN_92 (CDN_22 CDN_28) resistor r=58.3583
    rCDN_91 (CDN_22 CDN_28) resistor r=4.16253
    rCDN_90 (CDN_25 CDN_28) resistor r=58.3583
    rCDN_89 (CDN_25 CDN_28) resistor r=4.16253
    rCDN_88 (CDN_25 CDN_28) resistor r=58.3583
    rCDN_87 (CDN_25 CDN_28) resistor r=4.16253
    rCDN_86 (CDN_28 CDN_33) resistor r=22.35
    rCDN_85 (CDN_28 CDN_30) resistor r=22.35
    rCDN_84 (CDN_28 CDN_41) resistor r=24.8333
    rCDN_83 (CDN_28 CDN_38) resistor r=24.8333
    rCDN_82 (CDN_28 CDN_54) resistor r=11.175
    rCDN_81 (CDN_28 CDN_76) resistor r=58.3583
    rCDN_80 (CDN_28 CDN_79) resistor r=58.3583
    rCDN_79 (CDN_28 CDN_33) resistor r=4.16253
    rCDN_78 (CDN_28 CDN_41) resistor r=4.16253
    rCDN_77 (CDN_28 CDN_76) resistor r=5.53947
    rCDN_76 (CDN_28 CDN_54) resistor r=5.53947
    rCDN_75 (CDN_28 CDN_30) resistor r=2.32428
    rCDN_74 (CDN_28 CDN_38) resistor r=4.16253
    rCDN_73 (CDN_28 CDN_79) resistor r=4.16253
    rCDN_72 (CDN_28 CDN_33) resistor r=22.35
    rCDN_71 (CDN_28 CDN_30) resistor r=22.35
    rCDN_70 (CDN_28 CDN_41) resistor r=24.8333
    rCDN_69 (CDN_28 CDN_38) resistor r=24.8333
    rCDN_68 (CDN_28 CDN_169) resistor r=35.3875
    rCDN_67 (CDN_28 CDN_54) resistor r=11.175
    rCDN_66 (CDN_28 CDN_76) resistor r=58.3583
    rCDN_65 (CDN_28 MM15_ELT_g) resistor r=7.45
    rCDN_64 (CDN_28 CDN_33) resistor r=4.16253
    rCDN_63 (CDN_28 CDN_41) resistor r=4.16253
    rCDN_62 (CDN_28 CDN_76) resistor r=5.53947
    rCDN_61 (CDN_28 CDN_54) resistor r=5.53947
    rCDN_60 (CDN_28 CDN_30) resistor r=2.32428
    rCDN_59 (CDN_28 CDN_38) resistor r=4.16253
    rCDN_58 (CDN_28 CDN_79) resistor r=4.16253
    rCDN_57 (CDN_46 CDN_52) resistor r=58.3583
    rCDN_56 (CDN_46 CDN_52) resistor r=4.16253
    rCDN_55 (CDN_46 CDN_52) resistor r=58.3583
    rCDN_54 (CDN_46 CDN_52) resistor r=4.16253
    rCDN_53 (CDN_49 CDN_52) resistor r=58.3583
    rCDN_52 (CDN_49 CDN_52) resistor r=4.16253
    rCDN_51 (CDN_49 CDN_52) resistor r=58.3583
    rCDN_50 (CDN_49 CDN_52) resistor r=4.16253
    rCDN_49 (CDN_52 CDN_63) resistor r=24.8333
    rCDN_48 (CDN_52 CDN_60) resistor r=24.8333
    rCDN_47 (CDN_52 CDN_71) resistor r=22.35
    rCDN_46 (CDN_52 CDN_68) resistor r=22.35
    rCDN_45 (CDN_52 CDN_84) resistor r=11.175
    rCDN_44 (CDN_52 CDN_90) resistor r=58.3583
    rCDN_43 (CDN_52 CDN_93) resistor r=58.3583
    rCDN_42 (CDN_52 CDN_63) resistor r=4.16253
    rCDN_41 (CDN_52 CDN_71) resistor r=4.16253
    rCDN_40 (CDN_52 CDN_84) resistor r=5.53947
    rCDN_39 (CDN_52 CDN_93) resistor r=5.53947
    rCDN_38 (CDN_52 CDN_68) resistor r=2.32428
    rCDN_37 (CDN_52 CDN_60) resistor r=4.16253
    rCDN_36 (CDN_52 CDN_90) resistor r=4.16253
    rCDN_35 (CDN_52 CDN_63) resistor r=24.8333
    rCDN_34 (CDN_52 CDN_60) resistor r=24.8333
    rCDN_33 (CDN_52 CDN_71) resistor r=22.35
    rCDN_32 (CDN_52 CDN_68) resistor r=22.35
    rCDN_31 (CDN_52 CDN_84) resistor r=11.175
    rCDN_30 (CDN_52 CDN_184) resistor r=30.7313
    rCDN_29 (CDN_52 CDN_90) resistor r=58.3583
    rCDN_28 (CDN_52 MM0_ELT_g) resistor r=22.35
    rCDN_27 (CDN_52 CDN_63) resistor r=4.16253
    rCDN_26 (CDN_52 CDN_71) resistor r=4.16253
    rCDN_25 (CDN_52 CDN_84) resistor r=5.53947
    rCDN_24 (CDN_52 CDN_93) resistor r=5.53947
    rCDN_23 (CDN_52 CDN_68) resistor r=2.32428
    rCDN_22 (CDN_52 CDN_60) resistor r=4.16253
    rCDN_21 (CDN_52 CDN_90) resistor r=4.16253
    rCDN_20 (CDN_79 MM15_ELT_g) resistor r=50.9083
    rCDN_19 (CDN_93 MM0_ELT_g) resistor r=36.0083
    rCDN_18 (CDN CDN_135) resistor r=10
    rCDN_17 (CDN_135 CDN_203) resistor r=0.677273
    rCDN_16 (CDN_169 CDN_201) resistor r=3.1797
    rCDN_15 (CDN_184 CDN_203) resistor r=3.1797
    rCDN_14 (CDN_201 CDN_203) resistor r=25.7364
    rnet26_22 (MM3_ELT_d net26) resistor r=0.01
    rnet26_21 (net26_1 net26_3) resistor r=0.222089
    rnet26_20 (net26_1 net26_12) resistor r=0.0961003
    rnet26_19 (net26_3 net26_4) resistor r=13
    rnet26_18 (net26_4 MM17_ELT_s) resistor r=8.44
    rnet26_17 (net26_6 net26_8) resistor r=0.39973
    rnet26_16 (net26_6 net26_14) resistor r=0.0961003
    rnet26_15 (net26_8 net26_9) resistor r=13
    rnet26_14 (net26_9 net26) resistor r=8.44
    rnet26_13 (net26_11 net26_12) resistor r=0.735471
    rnet26_12 (net26_11 net26_16) resistor r=0.0961003
    rnet26_11 (net26_13 net26_14) resistor r=0.469686
    rnet26_10 (net26_13 net26_15) resistor r=0.0961003
    rnet26_9 (net26_15 net26_16) resistor r=0.429976
    rY_136 (MM9_ELT_d Y) resistor r=0.01
    rY_135 (Y_22 Y_25) resistor r=14.9
    rY_134 (Y_22 Y_25) resistor r=6.30933
    rY_133 (Y_22 Y_25) resistor r=14.9
    rY_132 (Y_22 Y_25) resistor r=6.30933
    rY_131 (Y_25 Y_28) resistor r=58.3583
    rY_130 (Y_25 Y_31) resistor r=58.3583
    rY_129 (Y_25 Y_39) resistor r=24.8333
    rY_128 (Y_25 Y_36) resistor r=24.8333
    rY_127 (Y_25 Y_47) resistor r=24.8333
    rY_126 (Y_25 Y_44) resistor r=24.8333
    rY_125 (Y_25 Y_60) resistor r=58.3583
    rY_124 (Y_25 Y_63) resistor r=58.3583
    rY_123 (Y_25 Y_28) resistor r=6.30933
    rY_122 (Y_25 Y_39) resistor r=1.63969
    rY_121 (Y_25 Y_47) resistor r=4.16253
    rY_120 (Y_25 Y_31) resistor r=4.16253
    rY_119 (Y_25 Y_36) resistor r=4.16253
    rY_118 (Y_25 Y_60) resistor r=4.16253
    rY_117 (Y_25 Y_44) resistor r=4.16253
    rY_116 (Y_25 Y_63) resistor r=4.16253
    rY_115 (Y_25 Y_185) resistor r=47.1833
    rY_114 (Y_25 Y_28) resistor r=58.3583
    rY_113 (Y_25 Y_31) resistor r=58.3583
    rY_112 (Y_25 Y_39) resistor r=24.8333
    rY_111 (Y_25 Y_36) resistor r=24.8333
    rY_110 (Y_25 Y_47) resistor r=24.8333
    rY_109 (Y_25 Y_44) resistor r=24.8333
    rY_108 (Y_25 Y_60) resistor r=58.3583
    rY_107 (Y_25 MM8_ELT_g) resistor r=7.45
    rY_106 (Y_25 Y_28) resistor r=6.30933
    rY_105 (Y_25 Y_39) resistor r=1.63969
    rY_104 (Y_25 Y_47) resistor r=4.16253
    rY_103 (Y_25 Y_31) resistor r=4.16253
    rY_102 (Y_25 Y_36) resistor r=4.16253
    rY_101 (Y_25 Y_60) resistor r=4.16253
    rY_100 (Y_25 Y_44) resistor r=4.16253
    rY_99 (Y_25 Y_63) resistor r=4.16253
    rY_98 (Y_52 Y_58) resistor r=58.3583
    rY_97 (Y_52 Y_58) resistor r=4.16253
    rY_96 (Y_52 Y_58) resistor r=58.3583
    rY_95 (Y_52 Y_58) resistor r=4.16253
    rY_94 (Y_55 Y_58) resistor r=58.3583
    rY_93 (Y_55 Y_58) resistor r=4.16253
    rY_92 (Y_55 Y_58) resistor r=58.3583
    rY_91 (Y_55 Y_58) resistor r=4.16253
    rY_90 (Y_58 Y_71) resistor r=24.8333
    rY_89 (Y_58 Y_68) resistor r=24.8333
    rY_88 (Y_58 Y_79) resistor r=24.8333
    rY_87 (Y_58 Y_76) resistor r=24.8333
    rY_86 (Y_58 Y_84) resistor r=58.3583
    rY_85 (Y_58 Y_87) resistor r=58.3583
    rY_84 (Y_58 Y_92) resistor r=14.9
    rY_83 (Y_58 Y_71) resistor r=4.16253
    rY_82 (Y_58 Y_79) resistor r=4.16253
    rY_81 (Y_58 Y_68) resistor r=4.16253
    rY_80 (Y_58 Y_84) resistor r=4.16253
    rY_79 (Y_58 Y_92) resistor r=6.30933
    rY_78 (Y_58 Y_87) resistor r=6.30933
    rY_77 (Y_58 Y_76) resistor r=1.63969
    rY_76 (Y_58 Y_71) resistor r=24.8333
    rY_75 (Y_58 Y_68) resistor r=24.8333
    rY_74 (Y_58 Y_79) resistor r=24.8333
    rY_73 (Y_58 Y_76) resistor r=24.8333
    rY_72 (Y_58 Y_84) resistor r=58.3583
    rY_71 (Y_58 MM3_ELT_g) resistor r=22.35
    rY_70 (Y_58 Y_92) resistor r=14.9
    rY_69 (Y_58 Y_217) resistor r=39.7333
    rY_68 (Y_58 Y_71) resistor r=4.16253
    rY_67 (Y_58 Y_79) resistor r=4.16253
    rY_66 (Y_58 Y_68) resistor r=4.16253
    rY_65 (Y_58 Y_84) resistor r=4.16253
    rY_64 (Y_58 Y_92) resistor r=6.30933
    rY_63 (Y_58 Y_87) resistor r=6.30933
    rY_62 (Y_58 Y_76) resistor r=1.63969
    rY_61 (Y_63 MM8_ELT_g) resistor r=50.9083
    rY_60 (Y_87 MM3_ELT_g) resistor r=36.0083
    rY_59 (Y_131 Y_133) resistor r=0.0906054
    rY_58 (Y_131 Y_137) resistor r=0.0961003
    rY_57 (Y_133 Y_134) resistor r=13
    rY_56 (Y_134 Y) resistor r=8.09035
    rY_55 (Y_136 Y_137) resistor r=0.263528
    rY_54 (Y_136 Y_145) resistor r=0.0961003
    rY_53 (Y_138 Y_139) resistor r=0.298465
    rY_52 (Y_138 Y_156) resistor r=0.0480502
    rY_51 (Y_139 Y_158) resistor r=0.0101012
    rY_50 (Y_140 Y_141) resistor r=0.395773
    rY_49 (Y_140 Y_149) resistor r=0.0961003
    rY_48 (Y_141 Y_156) resistor r=0.0480502
    rY_47 (Y_142 Y_143) resistor r=0.248888
    rY_46 (Y_142 Y_160) resistor r=0.0101012
    rY_45 (Y_143 Y_163) resistor r=0.0728318
    rY_44 (Y_144 Y_145) resistor r=0.281097
    rY_43 (Y_144 Y_163) resistor r=0.0728318
    rY_42 (Y_148 Y_149) resistor r=0.457572
    rY_41 (Y_148 Y_150) resistor r=0.0961003
    rY_40 (Y_150 Y_152) resistor r=0.483979
    rY_39 (Y_152 Y_153) resistor r=10
    rY_38 (Y_153 Y_230) resistor r=7.45
    rY_37 (Y_156 Y_157) resistor r=13
    rY_36 (Y_157 MM6_ELT_d) resistor r=8.44
    rY_35 (Y_158 Y_160) resistor r=0.167681
    rY_34 (Y_163 Y_164) resistor r=10
    rY_33 (Y_164 Y_221) resistor r=23.0273
    rY_32 (Y_185 Y_221) resistor r=9.29775
    rY_31 (Y_217 Y_231) resistor r=4.38767
    rY_30 (Y_230 Y_231) resistor r=3.71511
    rnet33_31 (MM2_ELT_d net33) resistor r=0.01
    rnet33_30 (net33_1 net33_3) resistor r=0.293135
    rnet33_29 (net33_1 net33_7) resistor r=0.0961003
    rnet33_28 (net33_3 net33_4) resistor r=8.66667
    rnet33_27 (net33_4 MM6_ELT_s) resistor r=2.90692
    rnet33_26 (net33_4 net33_22) resistor r=12.1406
    rnet33_25 (net33_6 net33_7) resistor r=0.645565
    rnet33_24 (net33_6 net33_8) resistor r=0.0961003
    rnet33_23 (net33_8 net33_10) resistor r=1.30848
    rnet33_22 (net33_10 net33_11) resistor r=13
    rnet33_21 (net33_11 net33) resistor r=8.44
    rnet33_20 (MM6_ELT_s net33_16) resistor r=2.67027
    rnet33_19 (MM6_ELT_s net33_18) resistor r=12.8495
    rnet33_18 (MM6_ELT_s net33_18) resistor r=1.69926
    rnet33_17 (MM6_ELT_s net33_21) resistor r=4.557
    rnet33_16 (net33_14 net33_16) resistor r=15.1041
    rnet33_15 (net33_14 net33_19) resistor r=9.43134
    rnet33_14 (net33_15 net33_16) resistor r=15.1041
    rnet33_13 (net33_15 net33_22) resistor r=9.89549
    rnet33_12 (net33_17 net33_18) resistor r=12.8495
    rnet33_11 (net33_17 net33_20) resistor r=9.4369
    rnet33_10 (net33_19 net33_21) resistor r=21.1301
    rnet33_9 (net33_20 net33_21) resistor r=21.1301
    rE_146 (E_32 E_38) resistor r=58.3583
    rE_145 (E_32 E_38) resistor r=4.16253
    rE_144 (E_32 E_38) resistor r=58.3583
    rE_143 (E_32 E_38) resistor r=4.16253
    rE_142 (E_35 E_38) resistor r=58.3583
    rE_141 (E_35 E_38) resistor r=4.16253
    rE_140 (E_35 E_38) resistor r=58.3583
    rE_139 (E_35 E_38) resistor r=4.16253
    rE_138 (E_38 E_43) resistor r=24.8333
    rE_137 (E_38 E_40) resistor r=24.8333
    rE_136 (E_38 E_51) resistor r=24.8333
    rE_135 (E_38 E_48) resistor r=24.8333
    rE_134 (E_38 E_56) resistor r=58.3583
    rE_133 (E_38 E_59) resistor r=58.3583
    rE_132 (E_38 E_64) resistor r=14.9
    rE_131 (E_38 E_43) resistor r=4.16253
    rE_130 (E_38 E_51) resistor r=4.16253
    rE_129 (E_38 E_40) resistor r=4.16253
    rE_128 (E_38 E_56) resistor r=4.16253
    rE_127 (E_38 E_64) resistor r=6.30933
    rE_126 (E_38 E_59) resistor r=6.30933
    rE_125 (E_38 E_48) resistor r=1.63969
    rE_124 (E_38 E_43) resistor r=24.8333
    rE_123 (E_38 E_40) resistor r=24.8333
    rE_122 (E_38 E_51) resistor r=24.8333
    rE_121 (E_38 E_48) resistor r=24.8333
    rE_120 (E_38 E_56) resistor r=58.3583
    rE_119 (E_38 MM16_ELT_g) resistor r=22.35
    rE_118 (E_38 E_64) resistor r=14.9
    rE_117 (E_38 E_248) resistor r=39.7333
    rE_116 (E_38 E_43) resistor r=4.16253
    rE_115 (E_38 E_51) resistor r=4.16253
    rE_114 (E_38 E_40) resistor r=4.16253
    rE_113 (E_38 E_56) resistor r=4.16253
    rE_112 (E_38 E_64) resistor r=6.30933
    rE_111 (E_38 E_59) resistor r=6.30933
    rE_110 (E_38 E_48) resistor r=1.63969
    rE_109 (E_59 MM16_ELT_g) resistor r=36.0083
    rE_108 (E_70 E_76) resistor r=58.3583
    rE_107 (E_70 E_76) resistor r=4.16253
    rE_106 (E_70 E_76) resistor r=58.3583
    rE_105 (E_70 E_76) resistor r=4.16253
    rE_104 (E_73 E_76) resistor r=58.3583
    rE_103 (E_73 E_76) resistor r=6.30933
    rE_102 (E_73 E_76) resistor r=58.3583
    rE_101 (E_73 E_76) resistor r=6.30933
    rE_100 (E_76 E_78) resistor r=14.9
    rE_99 (E_76 E_87) resistor r=24.8333
    rE_98 (E_76 E_84) resistor r=24.8333
    rE_97 (E_76 E_95) resistor r=24.8333
    rE_96 (E_76 E_92) resistor r=24.8333
    rE_95 (E_76 E_100) resistor r=58.3583
    rE_94 (E_76 E_103) resistor r=58.3583
    rE_93 (E_76 E_87) resistor r=4.16253
    rE_92 (E_76 E_78) resistor r=6.30933
    rE_91 (E_76 E_95) resistor r=1.63969
    rE_90 (E_76 E_84) resistor r=4.16253
    rE_89 (E_76 E_100) resistor r=4.16253
    rE_88 (E_76 E_92) resistor r=4.16253
    rE_87 (E_76 E_103) resistor r=4.16253
    rE_86 (E_76 E_78) resistor r=14.9
    rE_85 (E_76 E_254) resistor r=39.7333
    rE_84 (E_76 E_87) resistor r=24.8333
    rE_83 (E_76 E_84) resistor r=24.8333
    rE_82 (E_76 E_95) resistor r=24.8333
    rE_81 (E_76 E_92) resistor r=24.8333
    rE_80 (E_76 E_100) resistor r=58.3583
    rE_79 (E_76 MM2_ELT_g) resistor r=7.45
    rE_78 (E_76 E_87) resistor r=4.16253
    rE_77 (E_76 E_78) resistor r=6.30933
    rE_76 (E_76 E_95) resistor r=1.63969
    rE_75 (E_76 E_84) resistor r=4.16253
    rE_74 (E_76 E_100) resistor r=4.16253
    rE_73 (E_76 E_92) resistor r=4.16253
    rE_72 (E_76 E_103) resistor r=4.16253
    rE_71 (E_103 MM2_ELT_g) resistor r=50.9083
    rE_70 (E_108 E_111) resistor r=14.9
    rE_69 (E_108 E_111) resistor r=6.30933
    rE_68 (E_108 E_111) resistor r=14.9
    rE_67 (E_108 E_111) resistor r=6.30933
    rE_66 (E_111 E_114) resistor r=58.3583
    rE_65 (E_111 E_117) resistor r=58.3583
    rE_64 (E_111 E_125) resistor r=24.8333
    rE_63 (E_111 E_122) resistor r=24.8333
    rE_62 (E_111 E_133) resistor r=24.8333
    rE_61 (E_111 E_130) resistor r=24.8333
    rE_60 (E_111 E_138) resistor r=58.3583
    rE_59 (E_111 E_141) resistor r=58.3583
    rE_58 (E_111 E_114) resistor r=6.30933
    rE_57 (E_111 E_125) resistor r=1.63969
    rE_56 (E_111 E_133) resistor r=4.16253
    rE_55 (E_111 E_117) resistor r=4.16253
    rE_54 (E_111 E_122) resistor r=4.16253
    rE_53 (E_111 E_138) resistor r=4.16253
    rE_52 (E_111 E_130) resistor r=4.16253
    rE_51 (E_111 E_141) resistor r=4.16253
    rE_50 (E_111 E_269) resistor r=39.7333
    rE_49 (E_111 E_114) resistor r=58.3583
    rE_48 (E_111 E_117) resistor r=58.3583
    rE_47 (E_111 E_125) resistor r=24.8333
    rE_46 (E_111 E_122) resistor r=24.8333
    rE_45 (E_111 E_133) resistor r=24.8333
    rE_44 (E_111 E_130) resistor r=24.8333
    rE_43 (E_111 E_138) resistor r=58.3583
    rE_42 (E_111 MM17_ELT_g) resistor r=7.45
    rE_41 (E_111 E_114) resistor r=6.30933
    rE_40 (E_111 E_125) resistor r=1.63969
    rE_39 (E_111 E_133) resistor r=4.16253
    rE_38 (E_111 E_117) resistor r=4.16253
    rE_37 (E_111 E_122) resistor r=4.16253
    rE_36 (E_111 E_138) resistor r=4.16253
    rE_35 (E_111 E_130) resistor r=4.16253
    rE_34 (E_111 E_141) resistor r=4.16253
    rE_33 (E_141 MM17_ELT_g) resistor r=50.9083
    rE_32 (E_197 E_198) resistor r=10
    rE_31 (E_197 E) resistor r=0.0867487
    rE_30 (E_198 E_290) resistor r=10.8364
    rE_29 (E_198 E_293) resistor r=37.9273
    rE_28 (E_248 E_290) resistor r=9.29775
    rE_27 (E_254 E_294) resistor r=4.38767
    rE_26 (E_262 E_263) resistor r=54.1818
    rE_25 (E_262 E_269) resistor r=9.29775
    rE_24 (E_263 E_294) resistor r=3.71511
    rE_23 (E_293 E_294) resistor r=3.71511
    rX_141 (MM11_ELT_d X) resistor r=0.01
    rX_140 (X_24 X_30) resistor r=58.3583
    rX_139 (X_24 X_30) resistor r=4.16253
    rX_138 (X_24 X_30) resistor r=58.3583
    rX_137 (X_24 X_30) resistor r=4.16253
    rX_136 (X_27 X_30) resistor r=58.3583
    rX_135 (X_27 X_30) resistor r=4.16253
    rX_134 (X_27 X_30) resistor r=58.3583
    rX_133 (X_27 X_30) resistor r=4.16253
    rX_132 (X_30 X_35) resistor r=8.69167
    rX_131 (X_30 X_32) resistor r=8.69167
    rX_130 (X_30 X_43) resistor r=24.8333
    rX_129 (X_30 X_40) resistor r=24.8333
    rX_128 (X_30 X_48) resistor r=14.9
    rX_127 (X_30 X_71) resistor r=8.69167
    rX_126 (X_30 X_68) resistor r=8.69167
    rX_125 (X_30 X_92) resistor r=58.3583
    rX_124 (X_30 X_95) resistor r=58.3583
    rX_123 (X_30 X_35) resistor r=4.16253
    rX_122 (X_30 X_43) resistor r=4.16253
    rX_121 (X_30 X_71) resistor r=6.30933
    rX_120 (X_30 X_32) resistor r=6.30933
    rX_119 (X_30 X_48) resistor r=1.63969
    rX_118 (X_30 X_68) resistor r=4.16253
    rX_117 (X_30 X_92) resistor r=4.16253
    rX_116 (X_30 X_40) resistor r=4.16253
    rX_115 (X_30 X_95) resistor r=4.16253
    rX_114 (X_30 X_35) resistor r=8.69167
    rX_113 (X_30 X_32) resistor r=8.69167
    rX_112 (X_30 X_43) resistor r=24.8333
    rX_111 (X_30 X_40) resistor r=24.8333
    rX_110 (X_30 X_208) resistor r=47.1833
    rX_109 (X_30 X_48) resistor r=14.9
    rX_108 (X_30 X_71) resistor r=8.69167
    rX_107 (X_30 X_68) resistor r=8.69167
    rX_106 (X_30 X_92) resistor r=58.3583
    rX_105 (X_30 MM9_ELT_g) resistor r=7.45
    rX_104 (X_30 X_35) resistor r=4.16253
    rX_103 (X_30 X_43) resistor r=4.16253
    rX_102 (X_30 X_71) resistor r=6.30933
    rX_101 (X_30 X_32) resistor r=6.30933
    rX_100 (X_30 X_48) resistor r=1.63969
    rX_99 (X_30 X_68) resistor r=4.16253
    rX_98 (X_30 X_92) resistor r=4.16253
    rX_97 (X_30 X_40) resistor r=4.16253
    rX_96 (X_30 X_95) resistor r=4.16253
    rX_95 (X_54 X_60) resistor r=58.3583
    rX_94 (X_54 X_60) resistor r=4.16253
    rX_93 (X_54 X_60) resistor r=58.3583
    rX_92 (X_54 X_60) resistor r=4.16253
    rX_91 (X_57 X_60) resistor r=58.3583
    rX_90 (X_57 X_60) resistor r=6.30933
    rX_89 (X_57 X_60) resistor r=58.3583
    rX_88 (X_57 X_60) resistor r=6.30933
    rX_87 (X_60 X_62) resistor r=14.9
    rX_86 (X_60 X_79) resistor r=24.8333
    rX_85 (X_60 X_76) resistor r=24.8333
    rX_84 (X_60 X_87) resistor r=24.8333
    rX_83 (X_60 X_84) resistor r=24.8333
    rX_82 (X_60 X_100) resistor r=58.3583
    rX_81 (X_60 X_103) resistor r=58.3583
    rX_80 (X_60 X_79) resistor r=4.16253
    rX_79 (X_60 X_62) resistor r=6.30933
    rX_78 (X_60 X_87) resistor r=1.63969
    rX_77 (X_60 X_76) resistor r=4.16253
    rX_76 (X_60 X_100) resistor r=4.16253
    rX_75 (X_60 X_84) resistor r=4.16253
    rX_74 (X_60 X_103) resistor r=4.16253
    rX_73 (X_60 X_62) resistor r=14.9
    rX_72 (X_60 X_215) resistor r=40.975
    rX_71 (X_60 X_79) resistor r=24.8333
    rX_70 (X_60 X_76) resistor r=24.8333
    rX_69 (X_60 X_87) resistor r=24.8333
    rX_68 (X_60 X_84) resistor r=24.8333
    rX_67 (X_60 X_100) resistor r=58.3583
    rX_66 (X_60 MM6_ELT_g) resistor r=7.45
    rX_65 (X_60 X_79) resistor r=4.16253
    rX_64 (X_60 X_62) resistor r=6.30933
    rX_63 (X_60 X_87) resistor r=1.63969
    rX_62 (X_60 X_76) resistor r=4.16253
    rX_61 (X_60 X_100) resistor r=4.16253
    rX_60 (X_60 X_84) resistor r=4.16253
    rX_59 (X_60 X_103) resistor r=4.16253
    rX_58 (X_95 MM9_ELT_g) resistor r=50.9083
    rX_57 (X_103 MM6_ELT_g) resistor r=50.9083
    rX_56 (X_145 X_148) resistor r=0.39973
    rX_55 (X_145 X_172) resistor r=0.0101012
    rX_54 (X_146 X_148) resistor r=0.346432
    rX_53 (X_146 X_176) resistor r=0.0857772
    rX_52 (X_148 X_149) resistor r=8.66667
    rX_51 (X_149 X) resistor r=32.3614
    rX_50 (X_150 X_152) resistor r=0.175881
    rX_49 (X_150 X_176) resistor r=0.0857772
    rX_48 (X_152 X_153) resistor r=8.66667
    rX_47 (X_152 X_155) resistor r=0.426378
    rX_46 (X_153 X) resistor r=16.1807
    rX_45 (X_153 X_156) resistor r=32.3614
    rX_44 (X_155 X_156) resistor r=26
    rX_43 (X_158 X_160) resistor r=0.41054
    rX_42 (X_158 X_176) resistor r=0.00859602
    rX_41 (X_160 X_161) resistor r=10
    rX_40 (X_161 X_238) resistor r=30.4773
    rX_39 (X_163 X_164) resistor r=0.638344
    rX_38 (X_163 X_166) resistor r=0.0961003
    rX_37 (X_164 X_174) resistor r=0.0101012
    rX_36 (X_165 X_166) resistor r=0.239127
    rX_35 (X_165 X_167) resistor r=0.0961003
    rX_34 (X_167 X_169) resistor r=0.366011
    rX_33 (X_169 X_170) resistor r=13
    rX_32 (X_170 MM16_ELT_d) resistor r=8.44
    rX_31 (X_172 X_174) resistor r=0.126884
    rX_30 (X_208 X_239) resistor r=5.23411
    rX_29 (X_215 X_240) resistor r=5.23411
    rX_28 (X_238 X_239) resistor r=4.06364
    rX_27 (X_239 X_240) resistor r=8.12727
    rD_97 (D_22 D_28) resistor r=58.3583
    rD_96 (D_22 D_28) resistor r=4.16253
    rD_95 (D_22 D_28) resistor r=58.3583
    rD_94 (D_22 D_28) resistor r=4.16253
    rD_93 (D_25 D_28) resistor r=58.3583
    rD_92 (D_25 D_28) resistor r=6.30933
    rD_91 (D_25 D_28) resistor r=58.3583
    rD_90 (D_25 D_28) resistor r=6.30933
    rD_89 (D_28 D_30) resistor r=14.9
    rD_88 (D_28 D_53) resistor r=24.8333
    rD_87 (D_28 D_50) resistor r=24.8333
    rD_86 (D_28 D_61) resistor r=24.8333
    rD_85 (D_28 D_58) resistor r=24.8333
    rD_84 (D_28 D_82) resistor r=58.3583
    rD_83 (D_28 D_85) resistor r=58.3583
    rD_82 (D_28 D_53) resistor r=4.16253
    rD_81 (D_28 D_30) resistor r=6.30933
    rD_80 (D_28 D_61) resistor r=1.63969
    rD_79 (D_28 D_50) resistor r=4.16253
    rD_78 (D_28 D_82) resistor r=4.16253
    rD_77 (D_28 D_58) resistor r=4.16253
    rD_76 (D_28 D_85) resistor r=4.16253
    rD_75 (D_28 D_30) resistor r=14.9
    rD_74 (D_28 D_162) resistor r=40.975
    rD_73 (D_28 D_53) resistor r=24.8333
    rD_72 (D_28 D_50) resistor r=24.8333
    rD_71 (D_28 D_61) resistor r=24.8333
    rD_70 (D_28 D_58) resistor r=24.8333
    rD_69 (D_28 D_82) resistor r=58.3583
    rD_68 (D_28 MM1_ELT_g) resistor r=7.45
    rD_67 (D_28 D_53) resistor r=4.16253
    rD_66 (D_28 D_30) resistor r=6.30933
    rD_65 (D_28 D_61) resistor r=1.63969
    rD_64 (D_28 D_50) resistor r=4.16253
    rD_63 (D_28 D_82) resistor r=4.16253
    rD_62 (D_28 D_58) resistor r=4.16253
    rD_61 (D_28 D_85) resistor r=4.16253
    rD_60 (D_36 D_39) resistor r=14.9
    rD_59 (D_36 D_39) resistor r=6.30933
    rD_58 (D_36 D_39) resistor r=14.9
    rD_57 (D_36 D_39) resistor r=6.30933
    rD_56 (D_39 D_42) resistor r=202.392
    rD_55 (D_39 D_45) resistor r=202.392
    rD_54 (D_39 D_69) resistor r=24.8333
    rD_53 (D_39 D_66) resistor r=24.8333
    rD_52 (D_39 D_77) resistor r=24.8333
    rD_51 (D_39 D_74) resistor r=24.8333
    rD_50 (D_39 D_90) resistor r=202.392
    rD_49 (D_39 D_93) resistor r=202.392
    rD_48 (D_39 D_42) resistor r=6.30933
    rD_47 (D_39 D_69) resistor r=1.63969
    rD_46 (D_39 D_77) resistor r=4.16253
    rD_45 (D_39 D_45) resistor r=4.16253
    rD_44 (D_39 D_66) resistor r=4.16253
    rD_43 (D_39 D_90) resistor r=4.16253
    rD_42 (D_39 D_74) resistor r=4.16253
    rD_41 (D_39 D_93) resistor r=4.16253
    rD_40 (D_39 D_164) resistor r=40.975
    rD_39 (D_39 D_42) resistor r=202.392
    rD_38 (D_39 D_45) resistor r=202.392
    rD_37 (D_39 D_69) resistor r=24.8333
    rD_36 (D_39 D_66) resistor r=24.8333
    rD_35 (D_39 D_77) resistor r=24.8333
    rD_34 (D_39 D_74) resistor r=24.8333
    rD_33 (D_39 D_90) resistor r=202.392
    rD_32 (D_39 MM11_ELT_g) resistor r=7.45
    rD_31 (D_39 D_42) resistor r=6.30933
    rD_30 (D_39 D_69) resistor r=1.63969
    rD_29 (D_39 D_77) resistor r=4.16253
    rD_28 (D_39 D_45) resistor r=4.16253
    rD_27 (D_39 D_66) resistor r=4.16253
    rD_26 (D_39 D_90) resistor r=4.16253
    rD_25 (D_39 D_74) resistor r=4.16253
    rD_24 (D_39 D_93) resistor r=4.16253
    rD_23 (D_85 MM1_ELT_g) resistor r=50.9083
    rD_22 (D_93 MM11_ELT_g) resistor r=194.942
    rD_21 (D_132 D_133) resistor r=10
    rD_20 (D_132 D) resistor r=0.085212
    rD_19 (D_133 D_196) resistor r=4.74091
    rD_18 (D_162 D_197) resistor r=5.23411
    rD_17 (D_164 D_198) resistor r=5.23411
    rD_16 (D_196 D_197) resistor r=4.06364
    rD_15 (D_197 D_198) resistor r=7.45
ends DLHCNQD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: DDFD1_LVT_ELT
// View name: calibre
subckt DDFD1_LVT_ELT D CP Q QN VDD VSS
    MM4_ELT (MM4_ELT_d MM4_ELT_g MM4_ELT_s MM4_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 \
        ps=4.76e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.00725e-13 pd=1.34e-06 \
        ps=4.76e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM12_ELT (MM12_ELT_d MM12_ELT_g MM12_ELT_s MM12_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM5_ELT (MM5_ELT_d MM5_ELT_g MM5_ELT_s MM5_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM3_ELT (MM3_ELT_d MM3_ELT_g MM3_ELT_s MM3_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM6_ELT (MM6_ELT_d MM6_ELT_g MM6_ELT_s MM6_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM7_ELT (MM7_ELT_d MM7_ELT_g MM7_ELT_s MM7_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.31325e-13 pd=3.66e-06 \
        ps=9.4e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM14_ELT (MM14_ELT_d MM14_ELT_g MM14_ELT_s MM14_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=6.31325e-13 pd=3.66e-06 \
        ps=9.4e-06 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM13_ELT (MM13_ELT_d MM13_ELT_g MM13_ELT_s MM13_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM8_ELT (MM8_ELT_d MM8_ELT_g MM8_ELT_s MM8_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.44175e-13 pd=1.34e-06 \
        ps=3.815e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM9_ELT (MM9_ELT_d MM9_ELT_g MM9_ELT_s MM9_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=3.03125e-13 pd=1.34e-06 \
        ps=4.8e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    ciQ_6 (Q_3 VSS) capacitor c=4.47366e-17
    ciQ_5 (Q_4 VSS) capacitor c=1.11627e-16
    ciQ_4 (Q_8 VSS) capacitor c=1.76029e-16
    ciQ_3 (Q_9 VSS) capacitor c=3.31106e-16
    ciQ_2 (Q VSS) capacitor c=7.99685e-17
    ciQ_1 (Q_23 VSS) capacitor c=2.45976e-17
    ciQ_0 (Q_27 VSS) capacitor c=2.11696e-17
    ciVDD_42 (VDD_4 VSS) capacitor c=4.69335e-17
    ciVDD_41 (VDD_7 VSS) capacitor c=4.55859e-17
    ciVDD_40 (VDD_8 VSS) capacitor c=2.63453e-17
    ciVDD_39 (VDD_14 VSS) capacitor c=6.67116e-17
    ciVDD_38 (VDD_15 VSS) capacitor c=8.25587e-17
    ciVDD_37 (VDD_17 VSS) capacitor c=8.57817e-17
    ciVDD_36 (VDD_24 VSS) capacitor c=8.82809e-17
    ciVDD_35 (VDD_25 VSS) capacitor c=1.48625e-16
    ciVDD_34 (VDD_27 VSS) capacitor c=4.68332e-17
    ciVDD_33 (VDD_34 VSS) capacitor c=2.16366e-16
    ciVDD_32 (VDD_43 VSS) capacitor c=4.72265e-17
    ciVDD_31 (VDD_50 VSS) capacitor c=1.98974e-16
    ciVDD_30 (VDD_61 VSS) capacitor c=6.26194e-17
    ciVDD_29 (VDD_69 VSS) capacitor c=3.58509e-18
    ciVDD_28 (VDD_72 VSS) capacitor c=3.58509e-18
    ciVDD_27 (VDD_74 VSS) capacitor c=3.58509e-18
    ciVDD_26 (VDD_75 VSS) capacitor c=3.58509e-18
    ciVDD_25 (VDD_81 VSS) capacitor c=1.71175e-18
    ciVDD_24 (VDD_82 VSS) capacitor c=5.32543e-18
    ciVDD_23 (VDD_83 VSS) capacitor c=1.64973e-18
    ciVDD_22 (VDD_86 VSS) capacitor c=8.5829e-18
    ciVDD_21 (VDD_89 VSS) capacitor c=1.64973e-18
    ciVDD_20 (VDD_92 VSS) capacitor c=1.71175e-18
    ciVDD_19 (VDD_94 VSS) capacitor c=1.64973e-18
    ciVDD_18 (VDD_97 VSS) capacitor c=1.20012e-17
    ciVDD_17 (MM8_ELT_s VSS) capacitor c=8.22979e-18
    ciVDD_16 (VDD_102 VSS) capacitor c=1.71175e-18
    ciVDD_15 (VDD_104 VSS) capacitor c=7.60342e-18
    ciVDD_14 (MM13_ELT_s VSS) capacitor c=5.30711e-18
    ciVDD_13 (VDD_107 VSS) capacitor c=6.34551e-18
    ciVDD_12 (VDD_110 VSS) capacitor c=1.71175e-18
    ciVDD_11 (VDD_115 VSS) capacitor c=1.11099e-18
    ciVDD_10 (VDD_116 VSS) capacitor c=3.18988e-18
    ciVDD_9 (VDD_117 VSS) capacitor c=3.57628e-18
    ciVDD_8 (VDD_120 VSS) capacitor c=1.67421e-17
    ciVDD_7 (VDD_124 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_125 VSS) capacitor c=5.8958e-18
    ciVDD_5 (VDD_126 VSS) capacitor c=3.57577e-18
    ciVDD_4 (VDD_129 VSS) capacitor c=2.11187e-17
    ciVDD_3 (VDD_130 VSS) capacitor c=7.61352e-17
    ciVDD_2 (VDD_134 VSS) capacitor c=5.23311e-18
    ciVDD_1 (VDD_137 VSS) capacitor c=2.22323e-16
    ciVDD_0 (VDD_138 VSS) capacitor c=2.43472e-16
    ciVSS_32 (VSS_4 VSS) capacitor c=5.2394e-17
    ciVSS_31 (VSS_10 VSS) capacitor c=4.59041e-17
    ciVSS_30 (VSS_11 VSS) capacitor c=2.63635e-17
    ciVSS_29 (VSS_17 VSS) capacitor c=7.75043e-17
    ciVSS_28 (VSS_18 VSS) capacitor c=7.92333e-19
    ciVSS_27 (VSS_23 VSS) capacitor c=8.59836e-17
    ciVSS_26 (VSS_30 VSS) capacitor c=1.0031e-16
    ciVSS_25 (VSS_34 VSS) capacitor c=1.35763e-16
    ciVSS_24 (VSS_36 VSS) capacitor c=4.67787e-17
    ciVSS_23 (VSS_43 VSS) capacitor c=7.44804e-17
    ciVSS_22 (VSS_49 VSS) capacitor c=4.65e-17
    ciVSS_21 (VSS_56 VSS) capacitor c=8.15104e-17
    ciVSS_20 (VSS_64 VSS) capacitor c=6.07341e-17
    ciVSS_19 (VSS_72 VSS) capacitor c=3.58509e-18
    ciVSS_18 (VSS_75 VSS) capacitor c=3.58509e-18
    ciVSS_17 (VSS_77 VSS) capacitor c=3.58509e-18
    ciVSS_16 (VSS_78 VSS) capacitor c=3.58509e-18
    ciVSS_15 (MM1_ELT_s VSS) capacitor c=5.08702e-18
    ciVSS_14 (VSS_84 VSS) capacitor c=6.77529e-18
    ciVSS_13 (VSS_96 VSS) capacitor c=7.67129e-18
    ciVSS_12 (MM3_ELT_s VSS) capacitor c=4.12817e-18
    ciVSS_11 (VSS_103 VSS) capacitor c=2.92983e-18
    ciVSS_10 (VSS_109 VSS) capacitor c=4.17262e-18
    ciVSS_9 (VSS_115 VSS) capacitor c=2.57761e-18
    ciVSS_8 (VSS_116 VSS) capacitor c=2.2923e-18
    ciVSS_7 (VSS_119 VSS) capacitor c=2.40767e-18
    ciVSS_6 (VSS_124 VSS) capacitor c=5.8958e-18
    ciVSS_5 (VSS_125 VSS) capacitor c=2.31469e-18
    ciVSS_4 (VSS_128 VSS) capacitor c=1.96647e-18
    ciVSS_3 (VSS_133 VSS) capacitor c=7.775e-17
    ciVSS_2 (VSS_134 VSS) capacitor c=7.77889e-17
    ciVSS_1 (VSS_139 VSS) capacitor c=7.02138e-17
    ciVSS_0 (VSS_141 VSS) capacitor c=7.18053e-17
    ciQN_6 (QN_3 VSS) capacitor c=4.0734e-17
    ciQN_5 (QN_4 VSS) capacitor c=1.13565e-16
    ciQN_4 (QN_8 VSS) capacitor c=1.64135e-16
    ciQN_3 (QN_9 VSS) capacitor c=3.41341e-16
    ciQN_2 (QN VSS) capacitor c=9.85236e-17
    ciQN_1 (QN_23 VSS) capacitor c=2.85154e-17
    ciQN_0 (QN_27 VSS) capacitor c=2.31836e-17
    cinet030_21 (net030_22 VSS) capacitor c=3.00043e-18
    cinet030_20 (net030_28 VSS) capacitor c=2.093e-16
    cinet030_19 (net030_39 VSS) capacitor c=6.3231e-16
    cinet030_18 (net030_45 VSS) capacitor c=3.15349e-18
    cinet030_17 (net030_50 VSS) capacitor c=2.23559e-17
    cinet030_16 (net030_58 VSS) capacitor c=1.51948e-17
    cinet030_15 (net030_66 VSS) capacitor c=2.11074e-17
    cinet030_14 (net030_74 VSS) capacitor c=1.29297e-17
    cinet030_13 (net030_82 VSS) capacitor c=3.24866e-18
    cinet030_12 (net030_85 VSS) capacitor c=4.84667e-18
    cinet030_11 (net030_90 VSS) capacitor c=5.12001e-18
    cinet030_10 (net030_93 VSS) capacitor c=3.65682e-18
    cinet030_9 (net030_133 VSS) capacitor c=8.38717e-17
    cinet030_8 (net030_134 VSS) capacitor c=1.13024e-16
    cinet030_7 (net030_138 VSS) capacitor c=7.06115e-17
    cinet030_6 (net030_139 VSS) capacitor c=1.26796e-16
    cinet030_5 (net030_142 VSS) capacitor c=1.96945e-16
    cinet030_4 (net030_143 VSS) capacitor c=3.39118e-17
    cinet030_3 (net030_145 VSS) capacitor c=9.67815e-17
    cinet030_2 (net030_152 VSS) capacitor c=3.59916e-17
    cinet030_1 (net030_210 VSS) capacitor c=3.00031e-17
    cinet030_0 (net030_211 VSS) capacitor c=1.28908e-17
    cinet031_42 (net031_42 VSS) capacitor c=3.00043e-18
    cinet031_41 (net031_45 VSS) capacitor c=4.40198e-18
    cinet031_40 (net031_48 VSS) capacitor c=3.79353e-16
    cinet031_39 (net031_50 VSS) capacitor c=3.44178e-18
    cinet031_38 (net031_53 VSS) capacitor c=4.4443e-18
    cinet031_37 (net031_56 VSS) capacitor c=2.13775e-16
    cinet031_36 (net031_58 VSS) capacitor c=2.2416e-17
    cinet031_35 (net031_66 VSS) capacitor c=2.17259e-17
    cinet031_34 (net031_74 VSS) capacitor c=1.95445e-17
    cinet031_33 (net031_82 VSS) capacitor c=2.23915e-17
    cinet031_32 (net031_102 VSS) capacitor c=3.35294e-18
    cinet031_31 (net031_113 VSS) capacitor c=3.60501e-18
    cinet031_30 (net031_118 VSS) capacitor c=4.28147e-18
    cinet031_29 (net031_124 VSS) capacitor c=1.98687e-16
    cinet031_28 (net031_135 VSS) capacitor c=5.93351e-16
    cinet031_27 (net031_141 VSS) capacitor c=4.43454e-18
    cinet031_26 (net031_146 VSS) capacitor c=2.23559e-17
    cinet031_25 (net031_154 VSS) capacitor c=1.51948e-17
    cinet031_24 (net031_162 VSS) capacitor c=2.05318e-17
    cinet031_23 (net031_170 VSS) capacitor c=1.23035e-17
    cinet031_22 (net031_178 VSS) capacitor c=2.11871e-18
    cinet031_21 (net031_181 VSS) capacitor c=3.9912e-18
    cinet031_20 (net031_186 VSS) capacitor c=4.02575e-18
    cinet031_19 (net031_189 VSS) capacitor c=2.22299e-18
    cinet031_18 (net031_263 VSS) capacitor c=7.45523e-17
    cinet031_17 (net031_264 VSS) capacitor c=1.25959e-16
    cinet031_16 (net031_266 VSS) capacitor c=3.15678e-17
    cinet031_15 (net031_267 VSS) capacitor c=1.31323e-17
    cinet031_14 (net031_270 VSS) capacitor c=9.20732e-17
    cinet031_13 (net031_271 VSS) capacitor c=1.12846e-16
    cinet031_12 (net031_274 VSS) capacitor c=9.6277e-18
    cinet031_11 (net031_277 VSS) capacitor c=4.37838e-17
    cinet031_10 (net031_280 VSS) capacitor c=2.76026e-17
    cinet031_9 (net031_283 VSS) capacitor c=1.10475e-16
    cinet031_8 (net031_285 VSS) capacitor c=1.1152e-17
    cinet031_7 (net031_286 VSS) capacitor c=3.41587e-18
    cinet031_6 (net031_288 VSS) capacitor c=2.57656e-17
    cinet031_5 (net031_289 VSS) capacitor c=5.0331e-17
    cinet031_4 (net031_291 VSS) capacitor c=6.68772e-17
    cinet031_3 (net031_405 VSS) capacitor c=5.33656e-17
    cinet031_2 (net031_406 VSS) capacitor c=9.43197e-18
    cinet031_1 (net031_412 VSS) capacitor c=2.98343e-17
    cinet031_0 (net031_413 VSS) capacitor c=1.33475e-17
    cinet26_8 (net26_2 VSS) capacitor c=1.09018e-16
    cinet26_7 (net26_5 VSS) capacitor c=3.9548e-17
    cinet26_6 (net26_6 VSS) capacitor c=1.12825e-16
    cinet26_5 (net26_10 VSS) capacitor c=8.13562e-17
    cinet26_4 (net26_15 VSS) capacitor c=3.184e-17
    cinet26_3 (net26_19 VSS) capacitor c=3.52129e-17
    cinet26_2 (net26_24 VSS) capacitor c=4.27483e-18
    cinet26_1 (net26_26 VSS) capacitor c=5.85055e-19
    cinet26_0 (net26_30 VSS) capacitor c=1.20445e-16
    ciY_26 (Y_22 VSS) capacitor c=4.04637e-18
    ciY_25 (Y_28 VSS) capacitor c=2.26661e-16
    ciY_24 (Y_39 VSS) capacitor c=2.04764e-16
    ciY_23 (Y_45 VSS) capacitor c=4.15066e-18
    ciY_22 (Y_50 VSS) capacitor c=2.23923e-17
    ciY_21 (Y_58 VSS) capacitor c=2.66942e-17
    ciY_20 (Y_66 VSS) capacitor c=2.1956e-17
    ciY_19 (Y_74 VSS) capacitor c=2.23936e-17
    ciY_18 (Y_82 VSS) capacitor c=3.00043e-18
    ciY_17 (Y_85 VSS) capacitor c=5.54754e-18
    ciY_16 (Y_90 VSS) capacitor c=5.79984e-18
    ciY_15 (Y_93 VSS) capacitor c=4.42349e-18
    ciY_14 (Y_133 VSS) capacitor c=4.235e-17
    ciY_13 (Y_134 VSS) capacitor c=1.5313e-16
    ciY_12 (Y_136 VSS) capacitor c=3.80313e-17
    ciY_11 (Y_137 VSS) capacitor c=1.52047e-17
    ciY_10 (Y_140 VSS) capacitor c=4.98693e-17
    ciY_9 (Y_141 VSS) capacitor c=1.39927e-16
    ciY_8 (Y_144 VSS) capacitor c=2.4565e-17
    ciY_7 (Y_146 VSS) capacitor c=2.82266e-17
    ciY_6 (Y_149 VSS) capacitor c=2.61809e-17
    ciY_5 (Y_154 VSS) capacitor c=2.96037e-17
    ciY_4 (Y_156 VSS) capacitor c=1.03288e-17
    ciY_3 (Y_178 VSS) capacitor c=1.73319e-16
    ciY_2 (Y_216 VSS) capacitor c=1.15936e-17
    ciY_1 (Y_217 VSS) capacitor c=2.44648e-17
    ciY_0 (Y_218 VSS) capacitor c=2.78847e-17
    cinet27_15 (net27_3 VSS) capacitor c=7.59447e-17
    cinet27_14 (net27_4 VSS) capacitor c=9.505e-17
    cinet27_13 (net27_8 VSS) capacitor c=3.9548e-17
    cinet27_12 (net27_9 VSS) capacitor c=1.37932e-16
    cinet27_11 (net27_11 VSS) capacitor c=7.06798e-17
    cinet27_10 (net27_12 VSS) capacitor c=1.52424e-17
    cinet27_9 (net27_13 VSS) capacitor c=4.39945e-17
    cinet27_8 (net27_14 VSS) capacitor c=1.55923e-17
    cinet27_7 (net27_16 VSS) capacitor c=7.13617e-17
    cinet27_6 (net27_18 VSS) capacitor c=9.40503e-19
    cinet27_5 (net27_19 VSS) capacitor c=4.93738e-19
    cinet27_4 (net27_20 VSS) capacitor c=1.13444e-18
    cinet27_3 (net27_21 VSS) capacitor c=9.8772e-19
    cinet27_2 (net27_23 VSS) capacitor c=1.9733e-18
    cinet27_1 (net27_24 VSS) capacitor c=2.02724e-18
    cinet27_0 (net27_27 VSS) capacitor c=7.92452e-18
    ciX_20 (X_14 VSS) capacitor c=3.00043e-18
    ciX_19 (X_17 VSS) capacitor c=2.05848e-18
    ciX_18 (X_20 VSS) capacitor c=2.18716e-16
    ciX_17 (X_22 VSS) capacitor c=2.23559e-17
    ciX_16 (X_30 VSS) capacitor c=1.3338e-17
    ciX_15 (X_44 VSS) capacitor c=1.34086e-17
    ciX_14 (X_52 VSS) capacitor c=4.04637e-18
    ciX_13 (X_55 VSS) capacitor c=3.49319e-18
    ciX_12 (X_82 VSS) capacitor c=5.38971e-17
    ciX_11 (X_83 VSS) capacitor c=1.24359e-16
    ciX_10 (X_87 VSS) capacitor c=4.0734e-17
    ciX_9 (X_88 VSS) capacitor c=1.13426e-16
    ciX_8 (X_90 VSS) capacitor c=2.58628e-17
    ciX_7 (X_91 VSS) capacitor c=1.54891e-17
    ciX_6 (X_93 VSS) capacitor c=4.78612e-17
    ciX_5 (X_95 VSS) capacitor c=4.14545e-17
    ciX_4 (X_98 VSS) capacitor c=1.12383e-16
    ciX_3 (X_103 VSS) capacitor c=2.82134e-17
    ciX_2 (X_105 VSS) capacitor c=1.17449e-17
    ciX_1 (X_143 VSS) capacitor c=2.24862e-17
    ciX_0 (X_144 VSS) capacitor c=4.16838e-17
    cinet29_10 (net29_3 VSS) capacitor c=4.46459e-17
    cinet29_9 (net29_4 VSS) capacitor c=1.28339e-16
    cinet29_8 (net29_6 VSS) capacitor c=2.40067e-17
    cinet29_7 (net29_7 VSS) capacitor c=1.48569e-17
    cinet29_6 (net29_10 VSS) capacitor c=1.16328e-16
    cinet29_5 (net29_11 VSS) capacitor c=5.86337e-18
    cinet29_4 (MM10_ELT_s VSS) capacitor c=3.97088e-18
    cinet29_3 (net29_15 VSS) capacitor c=1.06911e-16
    cinet29_2 (net29_17 VSS) capacitor c=1.71175e-18
    cinet29_1 (net29_18 VSS) capacitor c=3.55173e-18
    cinet29_0 (net29_19 VSS) capacitor c=7.55329e-18
    ciCP_47 (CP_49 VSS) capacitor c=1.71822e-16
    ciCP_46 (CP_55 VSS) capacitor c=3.55739e-18
    ciCP_45 (CP_60 VSS) capacitor c=2.50576e-17
    ciCP_44 (CP_68 VSS) capacitor c=2.76145e-17
    ciCP_43 (CP_76 VSS) capacitor c=9.39633e-18
    ciCP_42 (CP_79 VSS) capacitor c=5.8276e-18
    ciCP_41 (CP_84 VSS) capacitor c=2.20805e-18
    ciCP_40 (CP_87 VSS) capacitor c=3.25905e-18
    ciCP_39 (CP_90 VSS) capacitor c=2.25367e-16
    ciCP_38 (CP_92 VSS) capacitor c=1.33632e-17
    ciCP_37 (CP_100 VSS) capacitor c=2.23559e-17
    ciCP_36 (CP_114 VSS) capacitor c=9.15866e-18
    ciCP_35 (CP_117 VSS) capacitor c=2.37624e-18
    ciCP_34 (CP_120 VSS) capacitor c=2.40103e-16
    ciCP_33 (CP_122 VSS) capacitor c=1.34861e-17
    ciCP_32 (CP_130 VSS) capacitor c=3.0617e-17
    ciCP_31 (CP_138 VSS) capacitor c=1.34977e-17
    ciCP_30 (CP_146 VSS) capacitor c=3.78631e-18
    ciCP_29 (CP_149 VSS) capacitor c=4.04637e-18
    ciCP_28 (CP_160 VSS) capacitor c=1.48136e-17
    ciCP_27 (CP_168 VSS) capacitor c=8.26936e-18
    ciCP_26 (CP_171 VSS) capacitor c=8.11547e-18
    ciCP_25 (CP_179 VSS) capacitor c=2.2151e-16
    ciCP_24 (CP_185 VSS) capacitor c=5.18686e-18
    ciCP_23 (CP_190 VSS) capacitor c=1.57316e-17
    ciCP_22 (CP_198 VSS) capacitor c=2.79498e-17
    ciCP_21 (CP_206 VSS) capacitor c=5.11504e-18
    ciCP_20 (CP_209 VSS) capacitor c=7.41049e-18
    ciCP_19 (CP_289 VSS) capacitor c=4.61741e-17
    ciCP_18 (CP_299 VSS) capacitor c=1.44812e-17
    ciCP_17 (CP_300 VSS) capacitor c=2.00038e-17
    ciCP_16 (CP_302 VSS) capacitor c=4.98462e-17
    ciCP_15 (CP_303 VSS) capacitor c=7.24219e-18
    ciCP_14 (CP_305 VSS) capacitor c=8.45989e-17
    ciCP_13 (CP_306 VSS) capacitor c=9.00539e-17
    ciCP_12 (CP_308 VSS) capacitor c=1.27872e-17
    ciCP_11 (CP_310 VSS) capacitor c=1.98446e-17
    ciCP_10 (CP_311 VSS) capacitor c=4.43488e-17
    ciCP_9 (CP_313 VSS) capacitor c=1.07641e-17
    ciCP_8 (CP_314 VSS) capacitor c=5.84064e-18
    ciCP_7 (CP_317 VSS) capacitor c=7.84244e-18
    ciCP_6 (CP_319 VSS) capacitor c=1.71662e-17
    ciCP_5 (CP_320 VSS) capacitor c=6.37614e-17
    ciCP_4 (CP_397 VSS) capacitor c=2.1621e-17
    ciCP_3 (CP_447 VSS) capacitor c=2.00035e-17
    ciCP_2 (CP_448 VSS) capacitor c=7.29748e-18
    ciCP_1 (CP_467 VSS) capacitor c=5.49658e-17
    ciCP_0 (CP_473 VSS) capacitor c=5.75044e-17
    ciD_18 (D_22 VSS) capacitor c=2.9802e-18
    ciD_17 (D_25 VSS) capacitor c=5.03564e-18
    ciD_16 (D_28 VSS) capacitor c=2.19709e-16
    ciD_15 (D_33 VSS) capacitor c=2.05228e-16
    ciD_14 (D_39 VSS) capacitor c=3.74555e-18
    ciD_13 (D_44 VSS) capacitor c=2.23446e-17
    ciD_12 (D_52 VSS) capacitor c=2.58117e-17
    ciD_11 (D_60 VSS) capacitor c=1.92953e-17
    ciD_10 (D_68 VSS) capacitor c=2.23559e-17
    ciD_9 (D_76 VSS) capacitor c=3.24866e-18
    ciD_8 (D_90 VSS) capacitor c=4.35642e-18
    ciD_7 (D_93 VSS) capacitor c=3.76211e-18
    ciD_6 (D VSS) capacitor c=4.01296e-17
    ciD_5 (D_173 VSS) capacitor c=7.0045e-17
    ciD_4 (D_194 VSS) capacitor c=3.10956e-17
    ciD_3 (D_195 VSS) capacitor c=1.05112e-17
    ciD_2 (D_197 VSS) capacitor c=1.86532e-16
    ciD_1 (D_200 VSS) capacitor c=2.43222e-17
    ciD_0 (D_201 VSS) capacitor c=4.44047e-18
    rQ_26 (Q_1 Q_3) resistor r=0.303806
    rQ_25 (Q_1 Q_21) resistor r=0.0101016
    rQ_24 (Q_3 Q_4) resistor r=13
    rQ_23 (Q_4 MM4_ELT_d) resistor r=8.44
    rQ_22 (Q_6 Q_8) resistor r=0.341115
    rQ_21 (Q_6 Q_25) resistor r=0.0101016
    rQ_20 (Q_8 Q_9) resistor r=8.66667
    rQ_19 (Q_8 Q_11) resistor r=0.639591
    rQ_18 (Q_9 MM7_ELT_d) resistor r=32.3614
    rQ_17 (Q_11 Q_12) resistor r=8.66667
    rQ_16 (Q_11 Q_14) resistor r=0.426394
    rQ_15 (Q_12 MM7_ELT_d) resistor r=16.1807
    rQ_14 (Q_12 Q_15) resistor r=32.3614
    rQ_13 (Q_14 Q_15) resistor r=26
    rQ_12 (Q_17 Q) resistor r=0.156171
    rQ_11 (Q_17 Q_23) resistor r=0.0101016
    rQ_10 (Q_18 Q) resistor r=0.619216
    rQ_9 (Q_18 Q_27) resistor r=0.0101016
    rQ_8 (Q_21 Q_23) resistor r=0.126889
    rQ_7 (Q_25 Q_27) resistor r=0.126889
    rVDD_190 (MM11_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_189 (MM9_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_188 (MM8_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_187 (MM13_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_186 (MM14_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_185 (MM7_ELT_b MM10_ELT_b) resistor r=0.01
    rVDD_184 (MM10_ELT_b VDD_72) resistor r=8.66667
    rVDD_183 (MM10_ELT_b VDD_21) resistor r=67.52
    rVDD_182 (MM10_ELT_b VDD_31) resistor r=67.52
    rVDD_181 (VDD_2 VDD_4) resistor r=0.511673
    rVDD_180 (VDD_2 VDD_67) resistor r=0.119189
    rVDD_179 (VDD_4 VDD_5) resistor r=8.66667
    rVDD_178 (VDD_5 MM11_ELT_s) resistor r=2.78649
    rVDD_177 (VDD_5 VDD_130) resistor r=11.6377
    rVDD_176 (VDD_7 VDD_10) resistor r=0.221347
    rVDD_175 (VDD_7 VDD_69) resistor r=0.022153
    rVDD_174 (VDD_8 VDD_10) resistor r=0.0335973
    rVDD_173 (VDD_8 VDD_67) resistor r=0.0177868
    rVDD_172 (VDD_10 VDD_11) resistor r=8.66667
    rVDD_171 (VDD_11 VDD_70) resistor r=67.52
    rVDD_170 (VDD_12 VDD_14) resistor r=0.511673
    rVDD_169 (VDD_12 VDD_69) resistor r=0.0882494
    rVDD_168 (VDD_14 VDD_15) resistor r=8.66667
    rVDD_167 (VDD_15 VDD_132) resistor r=16.4995
    rVDD_166 (VDD_15 VDD_131) resistor r=16.4995
    rVDD_165 (VDD_15 MM9_ELT_s) resistor r=3.29107
    rVDD_164 (VDD_17 VDD_20) resistor r=0.221347
    rVDD_163 (VDD_17 VDD_72) resistor r=0.022153
    rVDD_162 (VDD_18 VDD_20) resistor r=0.217394
    rVDD_161 (VDD_18 VDD_69) resistor r=0.022153
    rVDD_160 (VDD_20 VDD_21) resistor r=8.66667
    rVDD_159 (VDD_21 VDD_70) resistor r=67.52
    rVDD_158 (VDD_22 VDD_24) resistor r=0.561763
    rVDD_157 (VDD_22 VDD_72) resistor r=0.0882494
    rVDD_156 (VDD_24 VDD_25) resistor r=8.66667
    rVDD_155 (VDD_25 MM13_ELT_s) resistor r=4.04518
    rVDD_154 (VDD_25 VDD_135) resistor r=4.04518
    rVDD_153 (VDD_25 MM8_ELT_s) resistor r=4.04518
    rVDD_152 (VDD_25 VDD_133) resistor r=4.04518
    rVDD_151 (VDD_27 VDD_30) resistor r=0.0375499
    rVDD_150 (VDD_27 VDD_74) resistor r=0.022153
    rVDD_149 (VDD_28 VDD_30) resistor r=0.217394
    rVDD_148 (VDD_28 VDD_72) resistor r=0.022153
    rVDD_147 (VDD_30 VDD_31) resistor r=8.66667
    rVDD_146 (VDD_31 VDD_47) resistor r=67.52
    rVDD_145 (VDD_32 VDD_41) resistor r=0.490353
    rVDD_144 (VDD_32 VDD_74) resistor r=0.0882494
    rVDD_143 (VDD_34 VDD_42) resistor r=8.66667
    rVDD_142 (VDD_34 VDD_38) resistor r=0.649169
    rVDD_141 (VDD_38 VDD_42) resistor r=8.66667
    rVDD_140 (VDD_38 VDD_41) resistor r=0.649169
    rVDD_139 (VDD_41 VDD_42) resistor r=8.66667
    rVDD_138 (VDD_42 MM14_ELT_s) resistor r=1.847
    rVDD_137 (VDD_42 VDD_137) resistor r=20.317
    rVDD_136 (VDD_43 VDD_46) resistor r=0.0909103
    rVDD_135 (VDD_43 VDD_75) resistor r=0.022153
    rVDD_134 (VDD_44 VDD_46) resistor r=0.164034
    rVDD_133 (VDD_44 VDD_74) resistor r=0.022153
    rVDD_132 (VDD_46 VDD_47) resistor r=8.66667
    rVDD_131 (VDD_47 VDD_62) resistor r=67.52
    rVDD_130 (VDD_48 VDD_57) resistor r=0.490353
    rVDD_129 (VDD_48 VDD_75) resistor r=0.0882494
    rVDD_128 (VDD_50 VDD_58) resistor r=8.66667
    rVDD_127 (VDD_50 VDD_54) resistor r=0.639591
    rVDD_126 (VDD_54 VDD_58) resistor r=8.66667
    rVDD_125 (VDD_54 VDD_57) resistor r=0.639591
    rVDD_124 (VDD_57 VDD_58) resistor r=8.66667
    rVDD_123 (VDD_58 MM7_ELT_s) resistor r=1.847
    rVDD_122 (VDD_58 VDD_138) resistor r=20.317
    rVDD_121 (VDD_59 VDD_61) resistor r=0.110673
    rVDD_120 (VDD_59 VDD_75) resistor r=0.022153
    rVDD_119 (VDD_61 VDD_62) resistor r=8.66667
    rVDD_118 (VDD VDD_67) resistor r=0.0513841
    rVDD_117 (VDD_69 VDD_70) resistor r=8.66667
    rVDD_116 (MM11_ELT_s VDD_81) resistor r=2.55965
    rVDD_115 (MM11_ELT_s VDD_83) resistor r=12.3172
    rVDD_114 (MM11_ELT_s VDD_83) resistor r=1.62887
    rVDD_113 (MM11_ELT_s VDD_86) resistor r=4.36821
    rVDD_112 (VDD_79 VDD_81) resistor r=14.4784
    rVDD_111 (VDD_79 VDD_85) resistor r=9.04062
    rVDD_110 (VDD_80 VDD_81) resistor r=14.4784
    rVDD_109 (VDD_80 VDD_130) resistor r=9.48555
    rVDD_108 (VDD_82 VDD_83) resistor r=12.3172
    rVDD_107 (VDD_82 VDD_84) resistor r=9.04595
    rVDD_106 (VDD_84 VDD_86) resistor r=20.2547
    rVDD_105 (VDD_85 VDD_86) resistor r=20.2547
    rVDD_104 (MM9_ELT_s VDD_89) resistor r=7.31976
    rVDD_103 (MM9_ELT_s VDD_89) resistor r=1.40052
    rVDD_102 (MM9_ELT_s VDD_92) resistor r=2.55965
    rVDD_101 (MM9_ELT_s VDD_94) resistor r=7.31976
    rVDD_100 (MM9_ELT_s VDD_94) resistor r=1.40052
    rVDD_99 (MM9_ELT_s VDD_97) resistor r=4.36821
    rVDD_98 (VDD_88 VDD_89) resistor r=7.31976
    rVDD_97 (VDD_88 VDD_131) resistor r=9.39461
    rVDD_96 (VDD_90 VDD_92) resistor r=14.4784
    rVDD_95 (VDD_90 VDD_96) resistor r=9.04062
    rVDD_94 (VDD_91 VDD_92) resistor r=14.4784
    rVDD_93 (VDD_91 VDD_132) resistor r=9.48555
    rVDD_92 (VDD_93 VDD_94) resistor r=7.31976
    rVDD_91 (VDD_93 VDD_95) resistor r=9.04595
    rVDD_90 (VDD_95 VDD_97) resistor r=20.2547
    rVDD_89 (VDD_96 VDD_97) resistor r=20.2547
    rVDD_88 (MM8_ELT_s VDD_99) resistor r=17.3029
    rVDD_87 (MM8_ELT_s VDD_102) resistor r=2.55965
    rVDD_86 (MM8_ELT_s VDD_104) resistor r=12.3172
    rVDD_85 (MM8_ELT_s VDD_104) resistor r=1.62887
    rVDD_84 (VDD_99 VDD_101) resistor r=9.04062
    rVDD_83 (VDD_100 VDD_102) resistor r=14.4784
    rVDD_82 (VDD_100 VDD_136) resistor r=10.5593
    rVDD_81 (VDD_101 VDD_102) resistor r=14.4784
    rVDD_80 (VDD_103 VDD_104) resistor r=12.3172
    rVDD_79 (VDD_103 VDD_134) resistor r=10.2363
    rVDD_78 (MM13_ELT_s VDD_107) resistor r=11.6604
    rVDD_77 (MM13_ELT_s VDD_107) resistor r=1.30988
    rVDD_76 (MM13_ELT_s VDD_110) resistor r=2.55965
    rVDD_75 (MM13_ELT_s VDD_111) resistor r=17.3029
    rVDD_74 (VDD_106 VDD_107) resistor r=11.6604
    rVDD_73 (VDD_106 VDD_134) resistor r=10.2363
    rVDD_72 (VDD_108 VDD_110) resistor r=14.4784
    rVDD_71 (VDD_108 VDD_111) resistor r=9.04062
    rVDD_70 (VDD_109 VDD_110) resistor r=14.4784
    rVDD_69 (VDD_109 VDD_136) resistor r=10.5593
    rVDD_68 (MM14_ELT_s VDD_115) resistor r=2.55965
    rVDD_67 (MM14_ELT_s VDD_117) resistor r=11.6604
    rVDD_66 (MM14_ELT_s VDD_117) resistor r=1.30988
    rVDD_65 (MM14_ELT_s VDD_120) resistor r=6.12113
    rVDD_64 (VDD_113 VDD_115) resistor r=14.4784
    rVDD_63 (VDD_113 VDD_119) resistor r=9.04062
    rVDD_62 (VDD_114 VDD_115) resistor r=14.4784
    rVDD_61 (VDD_114 VDD_137) resistor r=9.48555
    rVDD_60 (VDD_116 VDD_117) resistor r=11.6604
    rVDD_59 (VDD_116 VDD_118) resistor r=9.04595
    rVDD_58 (VDD_118 VDD_120) resistor r=31.2341
    rVDD_57 (VDD_119 VDD_120) resistor r=31.2341
    rVDD_56 (MM7_ELT_s VDD_124) resistor r=2.55965
    rVDD_55 (MM7_ELT_s VDD_126) resistor r=11.6604
    rVDD_54 (MM7_ELT_s VDD_126) resistor r=1.30988
    rVDD_53 (MM7_ELT_s VDD_129) resistor r=6.12113
    rVDD_52 (VDD_122 VDD_124) resistor r=14.4784
    rVDD_51 (VDD_122 VDD_128) resistor r=9.04062
    rVDD_50 (VDD_123 VDD_124) resistor r=14.4784
    rVDD_49 (VDD_123 VDD_138) resistor r=9.48555
    rVDD_48 (VDD_125 VDD_126) resistor r=11.6604
    rVDD_47 (VDD_125 VDD_127) resistor r=9.04595
    rVDD_46 (VDD_127 VDD_129) resistor r=31.2341
    rVDD_45 (VDD_128 VDD_129) resistor r=31.2341
    rVDD_44 (VDD_133 VDD_134) resistor r=0.549089
    rVDD_43 (VDD_135 VDD_136) resistor r=0.730683
    rVSS_184 (MM2_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_183 (MM6_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_182 (MM3_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_181 (MM5_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_180 (MM12_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_179 (MM15_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_178 (MM4_ELT_b MM1_ELT_b) resistor r=0.01
    rVSS_177 (MM1_ELT_b VSS_75) resistor r=8.66667
    rVSS_176 (MM1_ELT_b VSS_27) resistor r=64.7228
    rVSS_175 (MM1_ELT_b VSS_40) resistor r=64.7228
    rVSS_174 (VSS_2 VSS_4) resistor r=0.405074
    rVSS_173 (VSS_2 VSS_70) resistor r=0.119189
    rVSS_172 (VSS_4 VSS_5) resistor r=8.66667
    rVSS_171 (VSS_4 VSS_7) resistor r=0.426394
    rVSS_170 (VSS_5 VSS_139) resistor r=17.2126
    rVSS_169 (VSS_5 VSS_129) resistor r=17.2126
    rVSS_168 (VSS_5 MM1_ELT_s) resistor r=3.43331
    rVSS_167 (VSS_7 VSS_8) resistor r=26
    rVSS_166 (VSS_8 VSS_83) resistor r=5.7452
    rVSS_165 (VSS_8 VSS_139) resistor r=4.05543
    rVSS_164 (VSS_10 VSS_13) resistor r=0.221347
    rVSS_163 (VSS_10 VSS_72) resistor r=0.022153
    rVSS_162 (VSS_11 VSS_13) resistor r=0.0335973
    rVSS_161 (VSS_11 VSS_70) resistor r=0.0177868
    rVSS_160 (VSS_13 VSS_14) resistor r=8.66667
    rVSS_159 (VSS_14 VSS_73) resistor r=64.7228
    rVSS_158 (VSS_15 VSS_17) resistor r=0.405074
    rVSS_157 (VSS_15 VSS_72) resistor r=0.0882494
    rVSS_156 (VSS_17 VSS_18) resistor r=8.66667
    rVSS_155 (VSS_17 VSS_20) resistor r=0.43117
    rVSS_154 (VSS_18 VSS_141) resistor r=17.2126
    rVSS_153 (VSS_18 VSS_130) resistor r=17.2126
    rVSS_152 (VSS_18 MM2_ELT_s) resistor r=3.43331
    rVSS_151 (VSS_20 VSS_21) resistor r=26
    rVSS_150 (VSS_21 VSS_90) resistor r=5.7452
    rVSS_149 (VSS_21 VSS_141) resistor r=4.05543
    rVSS_148 (VSS_23 VSS_26) resistor r=0.221347
    rVSS_147 (VSS_23 VSS_75) resistor r=0.022153
    rVSS_146 (VSS_24 VSS_26) resistor r=0.217394
    rVSS_145 (VSS_24 VSS_72) resistor r=0.022153
    rVSS_144 (VSS_26 VSS_27) resistor r=8.66667
    rVSS_143 (VSS_27 VSS_73) resistor r=64.7228
    rVSS_142 (VSS_28 VSS_30) resistor r=0.438877
    rVSS_141 (VSS_28 VSS_75) resistor r=0.0882494
    rVSS_140 (VSS_30 VSS_31) resistor r=8.66667
    rVSS_139 (VSS_30 VSS_33) resistor r=0.468136
    rVSS_138 (VSS_31 MM12_ELT_s) resistor r=4.22001
    rVSS_137 (VSS_31 VSS_143) resistor r=4.22001
    rVSS_136 (VSS_31 MM3_ELT_s) resistor r=4.22001
    rVSS_135 (VSS_31 VSS_131) resistor r=4.22001
    rVSS_134 (VSS_33 VSS_34) resistor r=26
    rVSS_133 (VSS_34 VSS_108) resistor r=10.6787
    rVSS_132 (VSS_34 VSS_102) resistor r=10.6787
    rVSS_131 (VSS_34 VSS_143) resistor r=0.57282
    rVSS_130 (VSS_36 VSS_39) resistor r=0.0375499
    rVSS_129 (VSS_36 VSS_77) resistor r=0.022153
    rVSS_128 (VSS_37 VSS_39) resistor r=0.217394
    rVSS_127 (VSS_37 VSS_75) resistor r=0.022153
    rVSS_126 (VSS_39 VSS_40) resistor r=8.66667
    rVSS_125 (VSS_40 VSS_53) resistor r=64.7228
    rVSS_124 (VSS_41 VSS_43) resistor r=0.405074
    rVSS_123 (VSS_41 VSS_77) resistor r=0.0882494
    rVSS_122 (VSS_43 VSS_47) resistor r=8.66667
    rVSS_121 (VSS_43 VSS_46) resistor r=0.426394
    rVSS_120 (VSS_46 VSS_47) resistor r=26
    rVSS_119 (VSS_47 MM15_ELT_s) resistor r=2.90692
    rVSS_118 (VSS_47 VSS_133) resistor r=12.1406
    rVSS_117 (VSS_49 VSS_52) resistor r=0.0909103
    rVSS_116 (VSS_49 VSS_78) resistor r=0.022153
    rVSS_115 (VSS_50 VSS_52) resistor r=0.164034
    rVSS_114 (VSS_50 VSS_77) resistor r=0.022153
    rVSS_113 (VSS_52 VSS_53) resistor r=8.66667
    rVSS_112 (VSS_53 VSS_65) resistor r=64.7228
    rVSS_111 (VSS_54 VSS_56) resistor r=0.399744
    rVSS_110 (VSS_54 VSS_78) resistor r=0.0882494
    rVSS_109 (VSS_56 VSS_60) resistor r=8.66667
    rVSS_108 (VSS_56 VSS_59) resistor r=0.43117
    rVSS_107 (VSS_59 VSS_60) resistor r=26
    rVSS_106 (VSS_60 MM4_ELT_s) resistor r=2.90692
    rVSS_105 (VSS_60 VSS_134) resistor r=12.1406
    rVSS_104 (VSS_62 VSS_64) resistor r=0.110673
    rVSS_103 (VSS_62 VSS_78) resistor r=0.022153
    rVSS_102 (VSS_64 VSS_65) resistor r=8.66667
    rVSS_101 (VSS VSS_70) resistor r=0.0494078
    rVSS_100 (VSS_72 VSS_73) resistor r=8.66667
    rVSS_99 (MM1_ELT_s VSS_82) resistor r=2.67027
    rVSS_98 (MM1_ELT_s VSS_84) resistor r=12.8495
    rVSS_97 (MM1_ELT_s VSS_84) resistor r=1.69926
    rVSS_96 (MM1_ELT_s VSS_85) resistor r=18.0507
    rVSS_95 (VSS_80 VSS_82) resistor r=15.1041
    rVSS_94 (VSS_80 VSS_85) resistor r=9.43134
    rVSS_93 (VSS_81 VSS_82) resistor r=15.1041
    rVSS_92 (VSS_81 VSS_129) resistor r=9.89549
    rVSS_91 (VSS_83 VSS_84) resistor r=12.8495
    rVSS_90 (MM2_ELT_s VSS_89) resistor r=2.67027
    rVSS_89 (MM2_ELT_s VSS_91) resistor r=7.63611
    rVSS_88 (MM2_ELT_s VSS_91) resistor r=1.46105
    rVSS_87 (MM2_ELT_s VSS_93) resistor r=7.63611
    rVSS_86 (MM2_ELT_s VSS_93) resistor r=1.46105
    rVSS_85 (MM2_ELT_s VSS_96) resistor r=4.557
    rVSS_84 (VSS_87 VSS_89) resistor r=15.1041
    rVSS_83 (VSS_87 VSS_94) resistor r=9.43134
    rVSS_82 (VSS_88 VSS_89) resistor r=15.1041
    rVSS_81 (VSS_88 VSS_130) resistor r=9.89549
    rVSS_80 (VSS_90 VSS_91) resistor r=7.63611
    rVSS_79 (VSS_92 VSS_93) resistor r=7.63611
    rVSS_78 (VSS_92 VSS_95) resistor r=9.4369
    rVSS_77 (VSS_94 VSS_96) resistor r=21.1301
    rVSS_76 (VSS_95 VSS_96) resistor r=21.1301
    rVSS_75 (MM3_ELT_s VSS_98) resistor r=18.0507
    rVSS_74 (MM3_ELT_s VSS_101) resistor r=2.67027
    rVSS_73 (MM3_ELT_s VSS_103) resistor r=12.8495
    rVSS_72 (MM3_ELT_s VSS_103) resistor r=1.69926
    rVSS_71 (VSS_98 VSS_100) resistor r=9.43134
    rVSS_70 (VSS_99 VSS_101) resistor r=15.1041
    rVSS_69 (VSS_99 VSS_132) resistor r=11.0157
    rVSS_68 (VSS_100 VSS_101) resistor r=15.1041
    rVSS_67 (VSS_102 VSS_103) resistor r=12.8495
    rVSS_66 (MM12_ELT_s VSS_107) resistor r=2.67027
    rVSS_65 (MM12_ELT_s VSS_109) resistor r=12.1643
    rVSS_64 (MM12_ELT_s VSS_109) resistor r=1.36649
    rVSS_63 (MM12_ELT_s VSS_110) resistor r=18.0507
    rVSS_62 (VSS_105 VSS_107) resistor r=15.1041
    rVSS_61 (VSS_105 VSS_110) resistor r=9.43134
    rVSS_60 (VSS_106 VSS_107) resistor r=15.1041
    rVSS_59 (VSS_106 VSS_132) resistor r=11.0157
    rVSS_58 (VSS_108 VSS_109) resistor r=12.1643
    rVSS_57 (MM15_ELT_s VSS_114) resistor r=2.67027
    rVSS_56 (MM15_ELT_s VSS_116) resistor r=12.1643
    rVSS_55 (MM15_ELT_s VSS_116) resistor r=1.36649
    rVSS_54 (MM15_ELT_s VSS_119) resistor r=4.557
    rVSS_53 (VSS_112 VSS_114) resistor r=15.1041
    rVSS_52 (VSS_112 VSS_117) resistor r=9.43134
    rVSS_51 (VSS_113 VSS_114) resistor r=15.1041
    rVSS_50 (VSS_113 VSS_133) resistor r=9.89549
    rVSS_49 (VSS_115 VSS_116) resistor r=12.1643
    rVSS_48 (VSS_115 VSS_118) resistor r=9.4369
    rVSS_47 (VSS_117 VSS_119) resistor r=21.1301
    rVSS_46 (VSS_118 VSS_119) resistor r=21.1301
    rVSS_45 (MM4_ELT_s VSS_123) resistor r=2.67027
    rVSS_44 (MM4_ELT_s VSS_125) resistor r=12.1643
    rVSS_43 (MM4_ELT_s VSS_125) resistor r=1.36649
    rVSS_42 (MM4_ELT_s VSS_128) resistor r=4.557
    rVSS_41 (VSS_121 VSS_123) resistor r=15.1041
    rVSS_40 (VSS_121 VSS_126) resistor r=9.43134
    rVSS_39 (VSS_122 VSS_123) resistor r=15.1041
    rVSS_38 (VSS_122 VSS_134) resistor r=9.89549
    rVSS_37 (VSS_124 VSS_125) resistor r=12.1643
    rVSS_36 (VSS_124 VSS_127) resistor r=9.4369
    rVSS_35 (VSS_126 VSS_128) resistor r=21.1301
    rVSS_34 (VSS_127 VSS_128) resistor r=21.1301
    rVSS_33 (VSS_131 VSS_132) resistor r=0.762262
    rQN_26 (QN_1 QN_3) resistor r=0.303806
    rQN_25 (QN_1 QN_21) resistor r=0.0101016
    rQN_24 (QN_3 QN_4) resistor r=13
    rQN_23 (QN_4 MM15_ELT_d) resistor r=8.44
    rQN_22 (QN_6 QN_8) resistor r=0.341115
    rQN_21 (QN_6 QN_25) resistor r=0.0101016
    rQN_20 (QN_8 QN_9) resistor r=8.66667
    rQN_19 (QN_8 QN_11) resistor r=0.639591
    rQN_18 (QN_9 MM14_ELT_d) resistor r=32.3614
    rQN_17 (QN_11 QN_12) resistor r=8.66667
    rQN_16 (QN_11 QN_14) resistor r=0.426394
    rQN_15 (QN_12 MM14_ELT_d) resistor r=16.1807
    rQN_14 (QN_12 QN_15) resistor r=32.3614
    rQN_13 (QN_14 QN_15) resistor r=26
    rQN_12 (QN_17 QN) resistor r=0.157823
    rQN_11 (QN_17 QN_23) resistor r=0.0101016
    rQN_10 (QN_18 QN) resistor r=0.663081
    rQN_9 (QN_18 QN_27) resistor r=0.0101016
    rQN_8 (QN_21 QN_23) resistor r=0.126889
    rQN_7 (QN_25 QN_27) resistor r=0.126889
    rnet030_118 (MM13_ELT_d net030) resistor r=0.01
    rnet030_117 (net030_22 net030_28) resistor r=58.3583
    rnet030_116 (net030_22 net030_28) resistor r=4.16253
    rnet030_115 (net030_22 net030_28) resistor r=58.3583
    rnet030_114 (net030_22 net030_28) resistor r=4.16253
    rnet030_113 (net030_25 net030_28) resistor r=58.3583
    rnet030_112 (net030_25 net030_28) resistor r=5.53947
    rnet030_111 (net030_25 net030_28) resistor r=58.3583
    rnet030_110 (net030_25 net030_28) resistor r=5.53947
    rnet030_109 (net030_28 net030_30) resistor r=11.175
    rnet030_108 (net030_28 net030_53) resistor r=24.8333
    rnet030_107 (net030_28 net030_50) resistor r=24.8333
    rnet030_106 (net030_28 net030_69) resistor r=22.35
    rnet030_105 (net030_28 net030_66) resistor r=22.35
    rnet030_104 (net030_28 net030_82) resistor r=58.3583
    rnet030_103 (net030_28 net030_85) resistor r=58.3583
    rnet030_102 (net030_28 net030_53) resistor r=4.16253
    rnet030_101 (net030_28 net030_30) resistor r=5.53947
    rnet030_100 (net030_28 net030_69) resistor r=2.32428
    rnet030_99 (net030_28 net030_50) resistor r=4.16253
    rnet030_98 (net030_28 net030_82) resistor r=4.16253
    rnet030_97 (net030_28 net030_66) resistor r=4.16253
    rnet030_96 (net030_28 net030_85) resistor r=4.16253
    rnet030_95 (net030_28 net030_30) resistor r=11.175
    rnet030_94 (net030_28 net030_178) resistor r=30.7313
    rnet030_93 (net030_28 net030_53) resistor r=24.8333
    rnet030_92 (net030_28 net030_50) resistor r=24.8333
    rnet030_91 (net030_28 net030_69) resistor r=22.35
    rnet030_90 (net030_28 net030_66) resistor r=22.35
    rnet030_89 (net030_28 net030_82) resistor r=58.3583
    rnet030_88 (net030_28 MM15_ELT_g) resistor r=7.45
    rnet030_87 (net030_28 net030_53) resistor r=4.16253
    rnet030_86 (net030_28 net030_30) resistor r=5.53947
    rnet030_85 (net030_28 net030_69) resistor r=2.32428
    rnet030_84 (net030_28 net030_50) resistor r=4.16253
    rnet030_83 (net030_28 net030_82) resistor r=4.16253
    rnet030_82 (net030_28 net030_66) resistor r=4.16253
    rnet030_81 (net030_28 net030_85) resistor r=4.16253
    rnet030_80 (net030_36 net030_39) resistor r=11.175
    rnet030_79 (net030_36 net030_39) resistor r=5.53947
    rnet030_78 (net030_36 net030_39) resistor r=11.175
    rnet030_77 (net030_36 net030_39) resistor r=5.53947
    rnet030_76 (net030_39 net030_42) resistor r=202.392
    rnet030_75 (net030_39 net030_45) resistor r=202.392
    rnet030_74 (net030_39 net030_61) resistor r=24.8333
    rnet030_73 (net030_39 net030_58) resistor r=24.8333
    rnet030_72 (net030_39 net030_77) resistor r=22.35
    rnet030_71 (net030_39 net030_74) resistor r=22.35
    rnet030_70 (net030_39 net030_90) resistor r=202.392
    rnet030_69 (net030_39 net030_93) resistor r=202.392
    rnet030_68 (net030_39 net030_42) resistor r=5.53947
    rnet030_67 (net030_39 net030_77) resistor r=2.32428
    rnet030_66 (net030_39 net030_61) resistor r=4.16253
    rnet030_65 (net030_39 net030_45) resistor r=4.16253
    rnet030_64 (net030_39 net030_74) resistor r=4.16253
    rnet030_63 (net030_39 net030_90) resistor r=4.16253
    rnet030_62 (net030_39 net030_58) resistor r=4.16253
    rnet030_61 (net030_39 net030_93) resistor r=4.16253
    rnet030_60 (net030_39 net030_180) resistor r=30.7313
    rnet030_59 (net030_39 net030_42) resistor r=202.392
    rnet030_58 (net030_39 net030_45) resistor r=202.392
    rnet030_57 (net030_39 net030_61) resistor r=24.8333
    rnet030_56 (net030_39 net030_58) resistor r=24.8333
    rnet030_55 (net030_39 net030_77) resistor r=22.35
    rnet030_54 (net030_39 net030_74) resistor r=22.35
    rnet030_53 (net030_39 net030_90) resistor r=202.392
    rnet030_52 (net030_39 MM14_ELT_g) resistor r=7.45
    rnet030_51 (net030_39 net030_42) resistor r=5.53947
    rnet030_50 (net030_39 net030_77) resistor r=2.32428
    rnet030_49 (net030_39 net030_61) resistor r=4.16253
    rnet030_48 (net030_39 net030_45) resistor r=4.16253
    rnet030_47 (net030_39 net030_74) resistor r=4.16253
    rnet030_46 (net030_39 net030_90) resistor r=4.16253
    rnet030_45 (net030_39 net030_58) resistor r=4.16253
    rnet030_44 (net030_39 net030_93) resistor r=4.16253
    rnet030_43 (net030_85 MM15_ELT_g) resistor r=50.9083
    rnet030_42 (net030_93 MM14_ELT_g) resistor r=194.942
    rnet030_41 (net030_131 net030_133) resistor r=0.745435
    rnet030_40 (net030_131 net030_148) resistor r=0.0353484
    rnet030_39 (net030_133 net030_134) resistor r=13
    rnet030_38 (net030_134 MM12_ELT_d) resistor r=8.44
    rnet030_37 (net030_136 net030_138) resistor r=0.298476
    rnet030_36 (net030_136 net030_150) resistor r=0.0101016
    rnet030_35 (net030_138 net030_139) resistor r=13
    rnet030_34 (net030_139 net030) resistor r=8.09035
    rnet030_33 (net030_141 net030_142) resistor r=1.53186
    rnet030_32 (net030_141 net030_149) resistor r=0.0353484
    rnet030_31 (net030_142 net030_152) resistor r=0.0101016
    rnet030_30 (net030_143 net030_145) resistor r=0.258288
    rnet030_29 (net030_143 net030_149) resistor r=0.0588104
    rnet030_28 (net030_145 net030_146) resistor r=10
    rnet030_27 (net030_146 net030_210) resistor r=13.5455
    rnet030_26 (net030_148 net030_149) resistor r=0.189333
    rnet030_25 (net030_150 net030_152) resistor r=0.131769
    rnet030_24 (net030_178 net030_211) resistor r=8.1518
    rnet030_23 (net030_180 net030_211) resistor r=8.1518
    rnet030_22 (net030_210 net030_211) resistor r=0.275023
    rnet031_226 (MM8_ELT_d net031) resistor r=0.01
    rnet031_225 (net031_42 net031_48) resistor r=58.3583
    rnet031_224 (net031_42 net031_48) resistor r=4.16253
    rnet031_223 (net031_42 net031_48) resistor r=58.3583
    rnet031_222 (net031_42 net031_48) resistor r=4.16253
    rnet031_221 (net031_45 net031_48) resistor r=58.3583
    rnet031_220 (net031_45 net031_48) resistor r=4.16253
    rnet031_219 (net031_45 net031_48) resistor r=58.3583
    rnet031_218 (net031_45 net031_48) resistor r=4.16253
    rnet031_217 (net031_48 net031_61) resistor r=24.8333
    rnet031_216 (net031_48 net031_58) resistor r=24.8333
    rnet031_215 (net031_48 net031_69) resistor r=22.35
    rnet031_214 (net031_48 net031_66) resistor r=22.35
    rnet031_213 (net031_48 net031_90) resistor r=11.175
    rnet031_212 (net031_48 net031_102) resistor r=58.3583
    rnet031_211 (net031_48 net031_105) resistor r=58.3583
    rnet031_210 (net031_48 net031_61) resistor r=4.16253
    rnet031_209 (net031_48 net031_69) resistor r=4.16253
    rnet031_208 (net031_48 net031_90) resistor r=5.53947
    rnet031_207 (net031_48 net031_105) resistor r=5.53947
    rnet031_206 (net031_48 net031_66) resistor r=2.32428
    rnet031_205 (net031_48 net031_58) resistor r=4.16253
    rnet031_204 (net031_48 net031_102) resistor r=4.16253
    rnet031_203 (net031_48 net031_61) resistor r=24.8333
    rnet031_202 (net031_48 net031_58) resistor r=24.8333
    rnet031_201 (net031_48 net031_69) resistor r=22.35
    rnet031_200 (net031_48 net031_66) resistor r=22.35
    rnet031_199 (net031_48 net031_90) resistor r=11.175
    rnet031_198 (net031_48 net031_351) resistor r=236.538
    rnet031_197 (net031_48 net031_102) resistor r=58.3583
    rnet031_196 (net031_48 MM12_ELT_g) resistor r=22.35
    rnet031_195 (net031_48 net031_61) resistor r=4.16253
    rnet031_194 (net031_48 net031_69) resistor r=4.16253
    rnet031_193 (net031_48 net031_90) resistor r=5.53947
    rnet031_192 (net031_48 net031_105) resistor r=5.53947
    rnet031_191 (net031_48 net031_66) resistor r=2.32428
    rnet031_190 (net031_48 net031_58) resistor r=4.16253
    rnet031_189 (net031_48 net031_102) resistor r=4.16253
    rnet031_188 (net031_50 net031_56) resistor r=58.3583
    rnet031_187 (net031_50 net031_56) resistor r=4.16253
    rnet031_186 (net031_50 net031_56) resistor r=58.3583
    rnet031_185 (net031_50 net031_56) resistor r=4.16253
    rnet031_184 (net031_53 net031_56) resistor r=58.3583
    rnet031_183 (net031_53 net031_56) resistor r=4.16253
    rnet031_182 (net031_53 net031_56) resistor r=58.3583
    rnet031_181 (net031_53 net031_56) resistor r=4.16253
    rnet031_180 (net031_56 net031_77) resistor r=22.35
    rnet031_179 (net031_56 net031_74) resistor r=22.35
    rnet031_178 (net031_56 net031_85) resistor r=24.8333
    rnet031_177 (net031_56 net031_82) resistor r=24.8333
    rnet031_176 (net031_56 net031_96) resistor r=11.175
    rnet031_175 (net031_56 net031_110) resistor r=58.3583
    rnet031_174 (net031_56 net031_113) resistor r=58.3583
    rnet031_173 (net031_56 net031_77) resistor r=4.16253
    rnet031_172 (net031_56 net031_85) resistor r=4.16253
    rnet031_171 (net031_56 net031_110) resistor r=5.53947
    rnet031_170 (net031_56 net031_96) resistor r=5.53947
    rnet031_169 (net031_56 net031_74) resistor r=2.32428
    rnet031_168 (net031_56 net031_82) resistor r=4.16253
    rnet031_167 (net031_56 net031_113) resistor r=4.16253
    rnet031_166 (net031_56 net031_77) resistor r=22.35
    rnet031_165 (net031_56 net031_74) resistor r=22.35
    rnet031_164 (net031_56 net031_85) resistor r=24.8333
    rnet031_163 (net031_56 net031_82) resistor r=24.8333
    rnet031_162 (net031_56 net031_353) resistor r=40.975
    rnet031_161 (net031_56 net031_96) resistor r=11.175
    rnet031_160 (net031_56 net031_110) resistor r=58.3583
    rnet031_159 (net031_56 MM13_ELT_g) resistor r=7.45
    rnet031_158 (net031_56 net031_77) resistor r=4.16253
    rnet031_157 (net031_56 net031_85) resistor r=4.16253
    rnet031_156 (net031_56 net031_110) resistor r=5.53947
    rnet031_155 (net031_56 net031_96) resistor r=5.53947
    rnet031_154 (net031_56 net031_74) resistor r=2.32428
    rnet031_153 (net031_56 net031_82) resistor r=4.16253
    rnet031_152 (net031_56 net031_113) resistor r=4.16253
    rnet031_151 (net031_105 MM12_ELT_g) resistor r=36.0083
    rnet031_150 (net031_113 MM13_ELT_g) resistor r=50.9083
    rnet031_149 (net031_118 net031_124) resistor r=58.3583
    rnet031_148 (net031_118 net031_124) resistor r=4.16253
    rnet031_147 (net031_118 net031_124) resistor r=58.3583
    rnet031_146 (net031_118 net031_124) resistor r=4.16253
    rnet031_145 (net031_121 net031_124) resistor r=58.3583
    rnet031_144 (net031_121 net031_124) resistor r=5.53947
    rnet031_143 (net031_121 net031_124) resistor r=58.3583
    rnet031_142 (net031_121 net031_124) resistor r=5.53947
    rnet031_141 (net031_124 net031_126) resistor r=11.175
    rnet031_140 (net031_124 net031_149) resistor r=24.8333
    rnet031_139 (net031_124 net031_146) resistor r=24.8333
    rnet031_138 (net031_124 net031_165) resistor r=22.35
    rnet031_137 (net031_124 net031_162) resistor r=22.35
    rnet031_136 (net031_124 net031_178) resistor r=58.3583
    rnet031_135 (net031_124 net031_181) resistor r=58.3583
    rnet031_134 (net031_124 net031_149) resistor r=4.16253
    rnet031_133 (net031_124 net031_126) resistor r=5.53947
    rnet031_132 (net031_124 net031_165) resistor r=2.32428
    rnet031_131 (net031_124 net031_146) resistor r=4.16253
    rnet031_130 (net031_124 net031_178) resistor r=4.16253
    rnet031_129 (net031_124 net031_162) resistor r=4.16253
    rnet031_128 (net031_124 net031_181) resistor r=4.16253
    rnet031_127 (net031_124 net031_126) resistor r=11.175
    rnet031_126 (net031_124 net031_370) resistor r=29.8
    rnet031_125 (net031_124 net031_149) resistor r=24.8333
    rnet031_124 (net031_124 net031_146) resistor r=24.8333
    rnet031_123 (net031_124 net031_165) resistor r=22.35
    rnet031_122 (net031_124 net031_162) resistor r=22.35
    rnet031_121 (net031_124 net031_178) resistor r=58.3583
    rnet031_120 (net031_124 MM4_ELT_g) resistor r=7.45
    rnet031_119 (net031_124 net031_149) resistor r=4.16253
    rnet031_118 (net031_124 net031_126) resistor r=5.53947
    rnet031_117 (net031_124 net031_165) resistor r=2.32428
    rnet031_116 (net031_124 net031_146) resistor r=4.16253
    rnet031_115 (net031_124 net031_178) resistor r=4.16253
    rnet031_114 (net031_124 net031_162) resistor r=4.16253
    rnet031_113 (net031_124 net031_181) resistor r=4.16253
    rnet031_112 (net031_132 net031_135) resistor r=11.175
    rnet031_111 (net031_132 net031_135) resistor r=5.53947
    rnet031_110 (net031_132 net031_135) resistor r=11.175
    rnet031_109 (net031_132 net031_135) resistor r=5.53947
    rnet031_108 (net031_135 net031_138) resistor r=202.392
    rnet031_107 (net031_135 net031_141) resistor r=202.392
    rnet031_106 (net031_135 net031_157) resistor r=24.8333
    rnet031_105 (net031_135 net031_154) resistor r=24.8333
    rnet031_104 (net031_135 net031_173) resistor r=22.35
    rnet031_103 (net031_135 net031_170) resistor r=22.35
    rnet031_102 (net031_135 net031_186) resistor r=202.392
    rnet031_101 (net031_135 net031_189) resistor r=202.392
    rnet031_100 (net031_135 net031_138) resistor r=5.53947
    rnet031_99 (net031_135 net031_173) resistor r=2.32428
    rnet031_98 (net031_135 net031_157) resistor r=4.16253
    rnet031_97 (net031_135 net031_141) resistor r=4.16253
    rnet031_96 (net031_135 net031_170) resistor r=4.16253
    rnet031_95 (net031_135 net031_186) resistor r=4.16253
    rnet031_94 (net031_135 net031_154) resistor r=4.16253
    rnet031_93 (net031_135 net031_189) resistor r=4.16253
    rnet031_92 (net031_135 net031_372) resistor r=31.6625
    rnet031_91 (net031_135 net031_138) resistor r=202.392
    rnet031_90 (net031_135 net031_141) resistor r=202.392
    rnet031_89 (net031_135 net031_157) resistor r=24.8333
    rnet031_88 (net031_135 net031_154) resistor r=24.8333
    rnet031_87 (net031_135 net031_173) resistor r=22.35
    rnet031_86 (net031_135 net031_170) resistor r=22.35
    rnet031_85 (net031_135 net031_186) resistor r=202.392
    rnet031_84 (net031_135 MM7_ELT_g) resistor r=7.45
    rnet031_83 (net031_135 net031_138) resistor r=5.53947
    rnet031_82 (net031_135 net031_173) resistor r=2.32428
    rnet031_81 (net031_135 net031_157) resistor r=4.16253
    rnet031_80 (net031_135 net031_141) resistor r=4.16253
    rnet031_79 (net031_135 net031_170) resistor r=4.16253
    rnet031_78 (net031_135 net031_186) resistor r=4.16253
    rnet031_77 (net031_135 net031_154) resistor r=4.16253
    rnet031_76 (net031_135 net031_189) resistor r=4.16253
    rnet031_75 (net031_181 MM4_ELT_g) resistor r=50.9083
    rnet031_74 (net031_189 MM7_ELT_g) resistor r=194.942
    rnet031_73 (net031_261 net031_263) resistor r=0.318497
    rnet031_72 (net031_261 net031_267) resistor r=0.0961039
    rnet031_71 (net031_263 net031_264) resistor r=13
    rnet031_70 (net031_264 net031) resistor r=8.09035
    rnet031_69 (net031_266 net031_267) resistor r=0.306403
    rnet031_68 (net031_266 net031_274) resistor r=0.0961039
    rnet031_67 (net031_268 net031_270) resistor r=0.660911
    rnet031_66 (net031_268 net031_280) resistor r=0.0794365
    rnet031_65 (net031_270 net031_271) resistor r=13
    rnet031_64 (net031_271 MM5_ELT_d) resistor r=8.44
    rnet031_63 (net031_273 net031_274) resistor r=0.0976066
    rnet031_62 (net031_273 net031_280) resistor r=0.0794365
    rnet031_61 (net031_277 net031_279) resistor r=0.394123
    rnet031_60 (net031_277 net031_283) resistor r=0.0763323
    rnet031_59 (net031_279 net031_280) resistor r=0.75
    rnet031_58 (net031_280 net031_421) resistor r=10
    rnet031_57 (net031_282 net031_283) resistor r=0.736192
    rnet031_56 (net031_282 net031_285) resistor r=0.0763323
    rnet031_55 (net031_285 net031_291) resistor r=0.539131
    rnet031_54 (net031_286 net031_288) resistor r=0.0144003
    rnet031_53 (net031_286 net031_291) resistor r=0.0524882
    rnet031_52 (net031_288 net031_289) resistor r=0.75
    rnet031_51 (net031_289 net031_425) resistor r=10
    rnet031_50 (net031_351 net031_406) resistor r=8.1518
    rnet031_49 (net031_353 net031_406) resistor r=8.1518
    rnet031_48 (net031_370 net031_413) resistor r=8.1518
    rnet031_47 (net031_372 net031_413) resistor r=8.1518
    rnet031_46 (net031_405 net031_406) resistor r=0.275023
    rnet031_45 (net031_405 net031_421) resistor r=49.4409
    rnet031_44 (net031_412 net031_413) resistor r=0.275023
    rnet031_43 (net031_412 net031_425) resistor r=16.2545
    rnet26_35 (MM3_ELT_d net26) resistor r=0.01
    rnet26_34 (net26_1 net26_2) resistor r=0.773863
    rnet26_33 (net26_1 net26_13) resistor r=0.0101016
    rnet26_32 (net26_2 net26_17) resistor r=0.0101016
    rnet26_31 (net26_3 net26_5) resistor r=0.303806
    rnet26_30 (net26_3 net26_15) resistor r=0.0101016
    rnet26_29 (net26_5 net26_6) resistor r=13
    rnet26_28 (net26_6 net26) resistor r=8.44
    rnet26_27 (net26_8 net26_10) resistor r=0.309136
    rnet26_26 (net26_8 net26_19) resistor r=0.0101016
    rnet26_25 (net26_10 net26_11) resistor r=8.66667
    rnet26_24 (net26_11 MM5_ELT_s) resistor r=2.90692
    rnet26_23 (net26_11 net26_30) resistor r=12.1406
    rnet26_22 (net26_13 net26_15) resistor r=0.131769
    rnet26_21 (net26_17 net26_19) resistor r=0.181765
    rnet26_20 (MM5_ELT_s net26_24) resistor r=2.67027
    rnet26_19 (MM5_ELT_s net26_26) resistor r=12.8495
    rnet26_18 (MM5_ELT_s net26_26) resistor r=1.69926
    rnet26_17 (MM5_ELT_s net26_29) resistor r=4.557
    rnet26_16 (net26_22 net26_24) resistor r=15.1041
    rnet26_15 (net26_22 net26_28) resistor r=9.43134
    rnet26_14 (net26_23 net26_24) resistor r=15.1041
    rnet26_13 (net26_23 net26_30) resistor r=9.89549
    rnet26_12 (net26_25 net26_26) resistor r=12.8495
    rnet26_11 (net26_25 net26_27) resistor r=9.4369
    rnet26_10 (net26_27 net26_29) resistor r=21.1301
    rnet26_9 (net26_28 net26_29) resistor r=21.1301
    rY_128 (MM9_ELT_d Y) resistor r=0.01
    rY_127 (Y_22 Y_28) resistor r=58.3583
    rY_126 (Y_22 Y_28) resistor r=4.16253
    rY_125 (Y_22 Y_28) resistor r=58.3583
    rY_124 (Y_22 Y_28) resistor r=4.16253
    rY_123 (Y_25 Y_28) resistor r=58.3583
    rY_122 (Y_25 Y_28) resistor r=6.30933
    rY_121 (Y_25 Y_28) resistor r=58.3583
    rY_120 (Y_25 Y_28) resistor r=6.30933
    rY_119 (Y_28 Y_30) resistor r=14.9
    rY_118 (Y_28 Y_53) resistor r=24.8333
    rY_117 (Y_28 Y_50) resistor r=24.8333
    rY_116 (Y_28 Y_61) resistor r=24.8333
    rY_115 (Y_28 Y_58) resistor r=24.8333
    rY_114 (Y_28 Y_82) resistor r=58.3583
    rY_113 (Y_28 Y_85) resistor r=58.3583
    rY_112 (Y_28 Y_53) resistor r=4.16253
    rY_111 (Y_28 Y_30) resistor r=6.30933
    rY_110 (Y_28 Y_61) resistor r=1.63969
    rY_109 (Y_28 Y_50) resistor r=4.16253
    rY_108 (Y_28 Y_82) resistor r=4.16253
    rY_107 (Y_28 Y_58) resistor r=4.16253
    rY_106 (Y_28 Y_85) resistor r=4.16253
    rY_105 (Y_28 Y_30) resistor r=14.9
    rY_104 (Y_28 Y_215) resistor r=45.9417
    rY_103 (Y_28 Y_53) resistor r=24.8333
    rY_102 (Y_28 Y_50) resistor r=24.8333
    rY_101 (Y_28 Y_61) resistor r=24.8333
    rY_100 (Y_28 Y_58) resistor r=24.8333
    rY_99 (Y_28 Y_82) resistor r=58.3583
    rY_98 (Y_28 MM3_ELT_g) resistor r=7.45
    rY_97 (Y_28 Y_53) resistor r=4.16253
    rY_96 (Y_28 Y_30) resistor r=6.30933
    rY_95 (Y_28 Y_61) resistor r=1.63969
    rY_94 (Y_28 Y_50) resistor r=4.16253
    rY_93 (Y_28 Y_82) resistor r=4.16253
    rY_92 (Y_28 Y_58) resistor r=4.16253
    rY_91 (Y_28 Y_85) resistor r=4.16253
    rY_90 (Y_36 Y_39) resistor r=14.9
    rY_89 (Y_36 Y_39) resistor r=6.30933
    rY_88 (Y_36 Y_39) resistor r=14.9
    rY_87 (Y_36 Y_39) resistor r=6.30933
    rY_86 (Y_39 Y_42) resistor r=58.3583
    rY_85 (Y_39 Y_45) resistor r=58.3583
    rY_84 (Y_39 Y_69) resistor r=24.8333
    rY_83 (Y_39 Y_66) resistor r=24.8333
    rY_82 (Y_39 Y_77) resistor r=24.8333
    rY_81 (Y_39 Y_74) resistor r=24.8333
    rY_80 (Y_39 Y_90) resistor r=58.3583
    rY_79 (Y_39 Y_93) resistor r=58.3583
    rY_78 (Y_39 Y_42) resistor r=6.30933
    rY_77 (Y_39 Y_69) resistor r=1.63969
    rY_76 (Y_39 Y_77) resistor r=4.16253
    rY_75 (Y_39 Y_45) resistor r=4.16253
    rY_74 (Y_39 Y_66) resistor r=4.16253
    rY_73 (Y_39 Y_90) resistor r=4.16253
    rY_72 (Y_39 Y_74) resistor r=4.16253
    rY_71 (Y_39 Y_93) resistor r=4.16253
    rY_70 (Y_39 Y_185) resistor r=54.6333
    rY_69 (Y_39 Y_42) resistor r=58.3583
    rY_68 (Y_39 Y_45) resistor r=58.3583
    rY_67 (Y_39 Y_69) resistor r=24.8333
    rY_66 (Y_39 Y_66) resistor r=24.8333
    rY_65 (Y_39 Y_77) resistor r=24.8333
    rY_64 (Y_39 Y_74) resistor r=24.8333
    rY_63 (Y_39 Y_90) resistor r=58.3583
    rY_62 (Y_39 MM8_ELT_g) resistor r=7.45
    rY_61 (Y_39 Y_42) resistor r=6.30933
    rY_60 (Y_39 Y_69) resistor r=1.63969
    rY_59 (Y_39 Y_77) resistor r=4.16253
    rY_58 (Y_39 Y_45) resistor r=4.16253
    rY_57 (Y_39 Y_66) resistor r=4.16253
    rY_56 (Y_39 Y_90) resistor r=4.16253
    rY_55 (Y_39 Y_74) resistor r=4.16253
    rY_54 (Y_39 Y_93) resistor r=4.16253
    rY_53 (Y_85 MM3_ELT_g) resistor r=50.9083
    rY_52 (Y_93 MM8_ELT_g) resistor r=50.9083
    rY_51 (Y_131 Y_133) resistor r=0.0906087
    rY_50 (Y_131 Y_137) resistor r=0.0961039
    rY_49 (Y_133 Y_134) resistor r=13
    rY_48 (Y_134 Y) resistor r=8.09035
    rY_47 (Y_136 Y_137) resistor r=0.263538
    rY_46 (Y_136 Y_146) resistor r=0.0961039
    rY_45 (Y_138 Y_140) resistor r=0.303806
    rY_44 (Y_138 Y_152) resistor r=0.0101016
    rY_43 (Y_140 Y_141) resistor r=13
    rY_42 (Y_141 MM6_ELT_d) resistor r=8.44
    rY_41 (Y_143 Y_144) resistor r=0.332428
    rY_40 (Y_143 Y_154) resistor r=0.0101016
    rY_39 (Y_144 Y_156) resistor r=0.0728345
    rY_38 (Y_145 Y_146) resistor r=0.40926
    rY_37 (Y_145 Y_156) resistor r=0.0728345
    rY_36 (Y_147 Y_149) resistor r=0.0195213
    rY_35 (Y_147 Y_156) resistor r=0.0189284
    rY_34 (Y_149 Y_150) resistor r=10
    rY_33 (Y_150 Y_217) resistor r=12.1909
    rY_32 (Y_152 Y_154) resistor r=0.168278
    rY_31 (Y_178 Y_216) resistor r=254.542
    rY_30 (Y_178 Y_218) resistor r=3.725
    rY_29 (Y_185 Y_218) resistor r=3.725
    rY_28 (Y_215 Y_216) resistor r=13.5246
    rY_27 (Y_217 Y_218) resistor r=3.725
    rnet27_47 (MM2_ELT_d net27) resistor r=0.01
    rnet27_46 (net27_1 net27_3) resistor r=0.309136
    rnet27_45 (net27_1 net27_12) resistor r=0.0961039
    rnet27_44 (net27_3 net27_4) resistor r=8.66667
    rnet27_43 (net27_4 net27_29) resistor r=17.2126
    rnet27_42 (net27_4 net27_28) resistor r=17.2126
    rnet27_41 (net27_4 MM6_ELT_s) resistor r=3.43331
    rnet27_40 (net27_6 net27_8) resistor r=0.303806
    rnet27_39 (net27_6 net27_14) resistor r=0.0961039
    rnet27_38 (net27_8 net27_9) resistor r=13
    rnet27_37 (net27_9 net27) resistor r=8.44
    rnet27_36 (net27_11 net27_12) resistor r=0.541291
    rnet27_35 (net27_11 net27_16) resistor r=0.0961039
    rnet27_34 (net27_13 net27_14) resistor r=0.262316
    rnet27_33 (net27_13 net27_15) resistor r=0.0961039
    rnet27_32 (net27_15 net27_16) resistor r=0.773863
    rnet27_31 (MM6_ELT_s net27_20) resistor r=2.67027
    rnet27_30 (MM6_ELT_s net27_22) resistor r=7.63611
    rnet27_29 (MM6_ELT_s net27_22) resistor r=1.46105
    rnet27_28 (MM6_ELT_s net27_24) resistor r=7.63611
    rnet27_27 (MM6_ELT_s net27_24) resistor r=1.46105
    rnet27_26 (MM6_ELT_s net27_27) resistor r=4.557
    rnet27_25 (net27_18 net27_20) resistor r=15.1041
    rnet27_24 (net27_18 net27_25) resistor r=9.43134
    rnet27_23 (net27_19 net27_20) resistor r=15.1041
    rnet27_22 (net27_19 net27_28) resistor r=9.89549
    rnet27_21 (net27_21 net27_22) resistor r=7.63611
    rnet27_20 (net27_21 net27_29) resistor r=9.80063
    rnet27_19 (net27_23 net27_24) resistor r=7.63611
    rnet27_18 (net27_23 net27_26) resistor r=9.4369
    rnet27_17 (net27_25 net27_27) resistor r=21.1301
    rnet27_16 (net27_26 net27_27) resistor r=21.1301
    rX_89 (MM10_ELT_d X) resistor r=0.01
    rX_88 (X_14 X_20) resistor r=58.3583
    rX_87 (X_14 X_20) resistor r=4.16253
    rX_86 (X_14 X_20) resistor r=58.3583
    rX_85 (X_14 X_20) resistor r=4.16253
    rX_84 (X_17 X_20) resistor r=58.3583
    rX_83 (X_17 X_20) resistor r=4.16253
    rX_82 (X_17 X_20) resistor r=58.3583
    rX_81 (X_17 X_20) resistor r=4.16253
    rX_80 (X_20 X_25) resistor r=24.8333
    rX_79 (X_20 X_22) resistor r=24.8333
    rX_78 (X_20 X_33) resistor r=8.69167
    rX_77 (X_20 X_30) resistor r=8.69167
    rX_76 (X_20 X_38) resistor r=14.9
    rX_75 (X_20 X_47) resistor r=8.69167
    rX_74 (X_20 X_44) resistor r=8.69167
    rX_73 (X_20 X_52) resistor r=58.3583
    rX_72 (X_20 X_55) resistor r=58.3583
    rX_71 (X_20 X_25) resistor r=4.16253
    rX_70 (X_20 X_33) resistor r=4.16253
    rX_69 (X_20 X_47) resistor r=6.30933
    rX_68 (X_20 X_30) resistor r=6.30933
    rX_67 (X_20 X_38) resistor r=1.63969
    rX_66 (X_20 X_22) resistor r=4.16253
    rX_65 (X_20 X_52) resistor r=4.16253
    rX_64 (X_20 X_44) resistor r=4.16253
    rX_63 (X_20 X_55) resistor r=4.16253
    rX_62 (X_20 X_25) resistor r=24.8333
    rX_61 (X_20 X_22) resistor r=24.8333
    rX_60 (X_20 X_33) resistor r=8.69167
    rX_59 (X_20 X_30) resistor r=8.69167
    rX_58 (X_20 X_38) resistor r=14.9
    rX_57 (X_20 X_128) resistor r=39.7333
    rX_56 (X_20 X_47) resistor r=8.69167
    rX_55 (X_20 X_44) resistor r=8.69167
    rX_54 (X_20 X_52) resistor r=58.3583
    rX_53 (X_20 MM2_ELT_g) resistor r=7.45
    rX_52 (X_20 X_25) resistor r=4.16253
    rX_51 (X_20 X_33) resistor r=4.16253
    rX_50 (X_20 X_47) resistor r=6.30933
    rX_49 (X_20 X_30) resistor r=6.30933
    rX_48 (X_20 X_38) resistor r=1.63969
    rX_47 (X_20 X_22) resistor r=4.16253
    rX_46 (X_20 X_52) resistor r=4.16253
    rX_45 (X_20 X_44) resistor r=4.16253
    rX_44 (X_20 X_55) resistor r=4.16253
    rX_43 (X_55 MM2_ELT_g) resistor r=50.9083
    rX_42 (X_80 X_82) resistor r=0.159898
    rX_41 (X_80 X_91) resistor r=0.0961039
    rX_40 (X_82 X_83) resistor r=13
    rX_39 (X_83 X) resistor r=8.09035
    rX_38 (X_85 X_87) resistor r=0.303806
    rX_37 (X_85 X_101) resistor r=0.0101016
    rX_36 (X_87 X_88) resistor r=13
    rX_35 (X_88 MM1_ELT_d) resistor r=8.44
    rX_34 (X_90 X_91) resistor r=0.0927262
    rX_33 (X_90 X_95) resistor r=0.0961039
    rX_32 (X_92 X_93) resistor r=0.309897
    rX_31 (X_92 X_103) resistor r=0.0101016
    rX_30 (X_93 X_105) resistor r=0.0728345
    rX_29 (X_94 X_95) resistor r=0.306149
    rX_28 (X_94 X_105) resistor r=0.0728345
    rX_27 (X_96 X_98) resistor r=0.731991
    rX_26 (X_96 X_105) resistor r=0.0189284
    rX_25 (X_98 X_99) resistor r=10
    rX_24 (X_99 X_143) resistor r=4.74091
    rX_23 (X_101 X_103) resistor r=0.126889
    rX_22 (X_128 X_144) resistor r=4.38767
    rX_21 (X_143 X_144) resistor r=3.71511
    rnet29_32 (MM11_ELT_d net29) resistor r=0.01
    rnet29_31 (net29_1 net29_3) resistor r=0.0906087
    rnet29_30 (net29_1 net29_7) resistor r=0.0961039
    rnet29_29 (net29_3 net29_4) resistor r=13
    rnet29_28 (net29_4 net29) resistor r=8.09035
    rnet29_27 (net29_6 net29_7) resistor r=0.112248
    rnet29_26 (net29_6 net29_8) resistor r=0.0961039
    rnet29_25 (net29_8 net29_10) resistor r=0.804173
    rnet29_24 (net29_10 net29_11) resistor r=8.66667
    rnet29_23 (net29_11 net29_21) resistor r=16.4995
    rnet29_22 (net29_11 net29_20) resistor r=16.4995
    rnet29_21 (net29_11 MM10_ELT_s) resistor r=3.29107
    rnet29_20 (MM10_ELT_s net29_14) resistor r=17.3029
    rnet29_19 (MM10_ELT_s net29_17) resistor r=2.55965
    rnet29_18 (MM10_ELT_s net29_19) resistor r=12.3172
    rnet29_17 (MM10_ELT_s net29_19) resistor r=1.62887
    rnet29_16 (net29_14 net29_16) resistor r=9.04062
    rnet29_15 (net29_15 net29_17) resistor r=14.4784
    rnet29_14 (net29_15 net29_21) resistor r=9.48555
    rnet29_13 (net29_16 net29_17) resistor r=14.4784
    rnet29_12 (net29_18 net29_19) resistor r=12.3172
    rnet29_11 (net29_18 net29_20) resistor r=9.39461
    rCP_248 (CP_46 CP_49) resistor r=14.9
    rCP_247 (CP_46 CP_49) resistor r=6.30933
    rCP_246 (CP_46 CP_49) resistor r=14.9
    rCP_245 (CP_46 CP_49) resistor r=6.30933
    rCP_244 (CP_49 CP_52) resistor r=58.3583
    rCP_243 (CP_49 CP_55) resistor r=58.3583
    rCP_242 (CP_49 CP_63) resistor r=24.8333
    rCP_241 (CP_49 CP_60) resistor r=24.8333
    rCP_240 (CP_49 CP_71) resistor r=24.8333
    rCP_239 (CP_49 CP_68) resistor r=24.8333
    rCP_238 (CP_49 CP_76) resistor r=58.3583
    rCP_237 (CP_49 CP_79) resistor r=58.3583
    rCP_236 (CP_49 CP_52) resistor r=6.30933
    rCP_235 (CP_49 CP_63) resistor r=1.63969
    rCP_234 (CP_49 CP_71) resistor r=4.16253
    rCP_233 (CP_49 CP_55) resistor r=4.16253
    rCP_232 (CP_49 CP_60) resistor r=4.16253
    rCP_231 (CP_49 CP_76) resistor r=4.16253
    rCP_230 (CP_49 CP_68) resistor r=4.16253
    rCP_229 (CP_49 CP_79) resistor r=4.16253
    rCP_228 (CP_49 CP_365) resistor r=39.7333
    rCP_227 (CP_49 CP_52) resistor r=58.3583
    rCP_226 (CP_49 CP_55) resistor r=58.3583
    rCP_225 (CP_49 CP_63) resistor r=24.8333
    rCP_224 (CP_49 CP_60) resistor r=24.8333
    rCP_223 (CP_49 CP_71) resistor r=24.8333
    rCP_222 (CP_49 CP_68) resistor r=24.8333
    rCP_221 (CP_49 CP_76) resistor r=58.3583
    rCP_220 (CP_49 MM10_ELT_g) resistor r=7.45
    rCP_219 (CP_49 CP_52) resistor r=6.30933
    rCP_218 (CP_49 CP_63) resistor r=1.63969
    rCP_217 (CP_49 CP_71) resistor r=4.16253
    rCP_216 (CP_49 CP_55) resistor r=4.16253
    rCP_215 (CP_49 CP_60) resistor r=4.16253
    rCP_214 (CP_49 CP_76) resistor r=4.16253
    rCP_213 (CP_49 CP_68) resistor r=4.16253
    rCP_212 (CP_49 CP_79) resistor r=4.16253
    rCP_211 (CP_79 MM10_ELT_g) resistor r=50.9083
    rCP_210 (CP_84 CP_90) resistor r=58.3583
    rCP_209 (CP_84 CP_90) resistor r=4.16253
    rCP_208 (CP_84 CP_90) resistor r=58.3583
    rCP_207 (CP_84 CP_90) resistor r=4.16253
    rCP_206 (CP_87 CP_90) resistor r=58.3583
    rCP_205 (CP_87 CP_90) resistor r=4.16253
    rCP_204 (CP_87 CP_90) resistor r=58.3583
    rCP_203 (CP_87 CP_90) resistor r=4.16253
    rCP_202 (CP_90 CP_95) resistor r=8.69167
    rCP_201 (CP_90 CP_92) resistor r=8.69167
    rCP_200 (CP_90 CP_103) resistor r=24.8333
    rCP_199 (CP_90 CP_100) resistor r=24.8333
    rCP_198 (CP_90 CP_108) resistor r=14.9
    rCP_197 (CP_90 CP_125) resistor r=8.69167
    rCP_196 (CP_90 CP_122) resistor r=8.69167
    rCP_195 (CP_90 CP_146) resistor r=58.3583
    rCP_194 (CP_90 CP_149) resistor r=58.3583
    rCP_193 (CP_90 CP_95) resistor r=4.16253
    rCP_192 (CP_90 CP_103) resistor r=4.16253
    rCP_191 (CP_90 CP_125) resistor r=6.30933
    rCP_190 (CP_90 CP_92) resistor r=6.30933
    rCP_189 (CP_90 CP_108) resistor r=1.63969
    rCP_188 (CP_90 CP_122) resistor r=4.16253
    rCP_187 (CP_90 CP_146) resistor r=4.16253
    rCP_186 (CP_90 CP_100) resistor r=4.16253
    rCP_185 (CP_90 CP_149) resistor r=4.16253
    rCP_184 (CP_90 CP_95) resistor r=8.69167
    rCP_183 (CP_90 CP_92) resistor r=8.69167
    rCP_182 (CP_90 CP_103) resistor r=24.8333
    rCP_181 (CP_90 CP_100) resistor r=24.8333
    rCP_180 (CP_90 CP_391) resistor r=54.6333
    rCP_179 (CP_90 CP_108) resistor r=14.9
    rCP_178 (CP_90 CP_125) resistor r=8.69167
    rCP_177 (CP_90 CP_122) resistor r=8.69167
    rCP_176 (CP_90 CP_146) resistor r=58.3583
    rCP_175 (CP_90 MM9_ELT_g) resistor r=7.45
    rCP_174 (CP_90 CP_95) resistor r=4.16253
    rCP_173 (CP_90 CP_103) resistor r=4.16253
    rCP_172 (CP_90 CP_125) resistor r=6.30933
    rCP_171 (CP_90 CP_92) resistor r=6.30933
    rCP_170 (CP_90 CP_108) resistor r=1.63969
    rCP_169 (CP_90 CP_122) resistor r=4.16253
    rCP_168 (CP_90 CP_146) resistor r=4.16253
    rCP_167 (CP_90 CP_100) resistor r=4.16253
    rCP_166 (CP_90 CP_149) resistor r=4.16253
    rCP_165 (CP_114 CP_120) resistor r=58.3583
    rCP_164 (CP_114 CP_120) resistor r=4.16253
    rCP_163 (CP_114 CP_120) resistor r=58.3583
    rCP_162 (CP_114 CP_120) resistor r=4.16253
    rCP_161 (CP_117 CP_120) resistor r=58.3583
    rCP_160 (CP_117 CP_120) resistor r=4.16253
    rCP_159 (CP_117 CP_120) resistor r=58.3583
    rCP_158 (CP_117 CP_120) resistor r=4.16253
    rCP_157 (CP_120 CP_133) resistor r=24.8333
    rCP_156 (CP_120 CP_130) resistor r=24.8333
    rCP_155 (CP_120 CP_141) resistor r=8.69167
    rCP_154 (CP_120 CP_138) resistor r=8.69167
    rCP_153 (CP_120 CP_154) resistor r=14.9
    rCP_152 (CP_120 CP_163) resistor r=8.69167
    rCP_151 (CP_120 CP_160) resistor r=8.69167
    rCP_150 (CP_120 CP_168) resistor r=58.3583
    rCP_149 (CP_120 CP_171) resistor r=58.3583
    rCP_148 (CP_120 CP_133) resistor r=4.16253
    rCP_147 (CP_120 CP_141) resistor r=4.16253
    rCP_146 (CP_120 CP_163) resistor r=6.30933
    rCP_145 (CP_120 CP_138) resistor r=6.30933
    rCP_144 (CP_120 CP_154) resistor r=1.63969
    rCP_143 (CP_120 CP_130) resistor r=4.16253
    rCP_142 (CP_120 CP_168) resistor r=4.16253
    rCP_141 (CP_120 CP_160) resistor r=4.16253
    rCP_140 (CP_120 CP_171) resistor r=4.16253
    rCP_139 (CP_120 CP_133) resistor r=24.8333
    rCP_138 (CP_120 CP_130) resistor r=24.8333
    rCP_137 (CP_120 CP_141) resistor r=8.69167
    rCP_136 (CP_120 CP_138) resistor r=8.69167
    rCP_135 (CP_120 CP_154) resistor r=14.9
    rCP_134 (CP_120 CP_414) resistor r=40.975
    rCP_133 (CP_120 CP_163) resistor r=8.69167
    rCP_132 (CP_120 CP_160) resistor r=8.69167
    rCP_131 (CP_120 CP_168) resistor r=58.3583
    rCP_130 (CP_120 MM6_ELT_g) resistor r=7.45
    rCP_129 (CP_120 CP_133) resistor r=4.16253
    rCP_128 (CP_120 CP_141) resistor r=4.16253
    rCP_127 (CP_120 CP_163) resistor r=6.30933
    rCP_126 (CP_120 CP_138) resistor r=6.30933
    rCP_125 (CP_120 CP_154) resistor r=1.63969
    rCP_124 (CP_120 CP_130) resistor r=4.16253
    rCP_123 (CP_120 CP_168) resistor r=4.16253
    rCP_122 (CP_120 CP_160) resistor r=4.16253
    rCP_121 (CP_120 CP_171) resistor r=4.16253
    rCP_120 (CP_149 MM9_ELT_g) resistor r=50.9083
    rCP_119 (CP_171 MM6_ELT_g) resistor r=50.9083
    rCP_118 (CP_176 CP_179) resistor r=14.9
    rCP_117 (CP_176 CP_179) resistor r=6.30933
    rCP_116 (CP_176 CP_179) resistor r=14.9
    rCP_115 (CP_176 CP_179) resistor r=6.30933
    rCP_114 (CP_179 CP_182) resistor r=58.3583
    rCP_113 (CP_179 CP_185) resistor r=58.3583
    rCP_112 (CP_179 CP_193) resistor r=24.8333
    rCP_111 (CP_179 CP_190) resistor r=24.8333
    rCP_110 (CP_179 CP_201) resistor r=24.8333
    rCP_109 (CP_179 CP_198) resistor r=24.8333
    rCP_108 (CP_179 CP_206) resistor r=58.3583
    rCP_107 (CP_179 CP_209) resistor r=58.3583
    rCP_106 (CP_179 CP_182) resistor r=6.30933
    rCP_105 (CP_179 CP_193) resistor r=1.63969
    rCP_104 (CP_179 CP_201) resistor r=4.16253
    rCP_103 (CP_179 CP_185) resistor r=4.16253
    rCP_102 (CP_179 CP_190) resistor r=4.16253
    rCP_101 (CP_179 CP_206) resistor r=4.16253
    rCP_100 (CP_179 CP_198) resistor r=4.16253
    rCP_99 (CP_179 CP_209) resistor r=4.16253
    rCP_98 (CP_179 CP_424) resistor r=39.7333
    rCP_97 (CP_179 CP_182) resistor r=58.3583
    rCP_96 (CP_179 CP_185) resistor r=58.3583
    rCP_95 (CP_179 CP_193) resistor r=24.8333
    rCP_94 (CP_179 CP_190) resistor r=24.8333
    rCP_93 (CP_179 CP_201) resistor r=24.8333
    rCP_92 (CP_179 CP_198) resistor r=24.8333
    rCP_91 (CP_179 CP_206) resistor r=58.3583
    rCP_90 (CP_179 MM5_ELT_g) resistor r=7.45
    rCP_89 (CP_179 CP_182) resistor r=6.30933
    rCP_88 (CP_179 CP_193) resistor r=1.63969
    rCP_87 (CP_179 CP_201) resistor r=4.16253
    rCP_86 (CP_179 CP_185) resistor r=4.16253
    rCP_85 (CP_179 CP_190) resistor r=4.16253
    rCP_84 (CP_179 CP_206) resistor r=4.16253
    rCP_83 (CP_179 CP_198) resistor r=4.16253
    rCP_82 (CP_179 CP_209) resistor r=4.16253
    rCP_81 (CP_209 MM5_ELT_g) resistor r=50.9083
    rCP_80 (CP_289 CP) resistor r=0.0423209
    rCP_79 (CP_289 CP_296) resistor r=0.103518
    rCP_78 (CP_291 CP_292) resistor r=10
    rCP_77 (CP_291 CP) resistor r=0.0864375
    rCP_76 (CP_292 CP_467) resistor r=7.88824
    rCP_75 (CP_296 CP_300) resistor r=0.0413301
    rCP_74 (CP_297 CP_299) resistor r=0.163522
    rCP_73 (CP_297 CP_303) resistor r=0.0771557
    rCP_72 (CP_299 CP_300) resistor r=0.75
    rCP_71 (CP_302 CP_303) resistor r=0.382969
    rCP_70 (CP_302 CP_317) resistor r=0.0578502
    rCP_69 (CP_304 CP_305) resistor r=0.606057
    rCP_68 (CP_304 CP_317) resistor r=0.0150343
    rCP_67 (CP_305 CP_308) resistor r=0.0763323
    rCP_66 (CP_306 CP_307) resistor r=0.598621
    rCP_65 (CP_306 CP_314) resistor r=0.0763323
    rCP_64 (CP_307 CP_317) resistor r=0.0578502
    rCP_63 (CP_308 CP_310) resistor r=0.0446177
    rCP_62 (CP_310 CP_311) resistor r=0.75
    rCP_61 (CP_311 CP_462) resistor r=10
    rCP_60 (CP_313 CP_314) resistor r=0.0632084
    rCP_59 (CP_313 CP_319) resistor r=0.0414192
    rCP_58 (CP_319 CP_320) resistor r=0.75
    rCP_57 (CP_320 CP_470) resistor r=10
    rCP_56 (CP_365 CP_467) resistor r=8.45489
    rCP_55 (CP_391 CP_448) resistor r=4.38767
    rCP_54 (CP_397 CP_398) resistor r=17.6091
    rCP_53 (CP_397 CP_414) resistor r=9.29775
    rCP_52 (CP_398 CP_448) resistor r=3.71511
    rCP_51 (CP_424 CP_473) resistor r=5.23411
    rCP_50 (CP_447 CP_448) resistor r=3.71511
    rCP_49 (CP_447 CP_462) resistor r=4.74091
    rCP_48 (CP_470 CP_473) resistor r=5.41818
    rD_106 (D_22 D_28) resistor r=58.3583
    rD_105 (D_22 D_28) resistor r=4.16253
    rD_104 (D_22 D_28) resistor r=58.3583
    rD_103 (D_22 D_28) resistor r=4.16253
    rD_102 (D_25 D_28) resistor r=58.3583
    rD_101 (D_25 D_28) resistor r=4.16253
    rD_100 (D_25 D_28) resistor r=58.3583
    rD_99 (D_25 D_28) resistor r=4.16253
    rD_98 (D_28 D_47) resistor r=24.8333
    rD_97 (D_28 D_44) resistor r=24.8333
    rD_96 (D_28 D_55) resistor r=24.8333
    rD_95 (D_28 D_52) resistor r=24.8333
    rD_94 (D_28 D_76) resistor r=58.3583
    rD_93 (D_28 D_79) resistor r=58.3583
    rD_92 (D_28 D_84) resistor r=14.9
    rD_91 (D_28 D_47) resistor r=4.16253
    rD_90 (D_28 D_55) resistor r=4.16253
    rD_89 (D_28 D_44) resistor r=4.16253
    rD_88 (D_28 D_76) resistor r=4.16253
    rD_87 (D_28 D_84) resistor r=6.30933
    rD_86 (D_28 D_79) resistor r=6.30933
    rD_85 (D_28 D_52) resistor r=1.63969
    rD_84 (D_28 D_47) resistor r=24.8333
    rD_83 (D_28 D_44) resistor r=24.8333
    rD_82 (D_28 D_55) resistor r=24.8333
    rD_81 (D_28 D_52) resistor r=24.8333
    rD_80 (D_28 D_76) resistor r=58.3583
    rD_79 (D_28 MM1_ELT_g) resistor r=22.35
    rD_78 (D_28 D_84) resistor r=14.9
    rD_77 (D_28 D_187) resistor r=39.7333
    rD_76 (D_28 D_47) resistor r=4.16253
    rD_75 (D_28 D_55) resistor r=4.16253
    rD_74 (D_28 D_44) resistor r=4.16253
    rD_73 (D_28 D_76) resistor r=4.16253
    rD_72 (D_28 D_84) resistor r=6.30933
    rD_71 (D_28 D_79) resistor r=6.30933
    rD_70 (D_28 D_52) resistor r=1.63969
    rD_69 (D_30 D_33) resistor r=14.9
    rD_68 (D_30 D_33) resistor r=6.30933
    rD_67 (D_30 D_33) resistor r=14.9
    rD_66 (D_30 D_33) resistor r=6.30933
    rD_65 (D_33 D_36) resistor r=58.3583
    rD_64 (D_33 D_39) resistor r=58.3583
    rD_63 (D_33 D_63) resistor r=24.8333
    rD_62 (D_33 D_60) resistor r=24.8333
    rD_61 (D_33 D_71) resistor r=24.8333
    rD_60 (D_33 D_68) resistor r=24.8333
    rD_59 (D_33 D_90) resistor r=58.3583
    rD_58 (D_33 D_93) resistor r=58.3583
    rD_57 (D_33 D_36) resistor r=6.30933
    rD_56 (D_33 D_63) resistor r=1.63969
    rD_55 (D_33 D_71) resistor r=4.16253
    rD_54 (D_33 D_39) resistor r=4.16253
    rD_53 (D_33 D_60) resistor r=4.16253
    rD_52 (D_33 D_90) resistor r=4.16253
    rD_51 (D_33 D_68) resistor r=4.16253
    rD_50 (D_33 D_93) resistor r=4.16253
    rD_49 (D_33 D_161) resistor r=39.7333
    rD_48 (D_33 D_36) resistor r=58.3583
    rD_47 (D_33 D_39) resistor r=58.3583
    rD_46 (D_33 D_63) resistor r=24.8333
    rD_45 (D_33 D_60) resistor r=24.8333
    rD_44 (D_33 D_71) resistor r=24.8333
    rD_43 (D_33 D_68) resistor r=24.8333
    rD_42 (D_33 D_90) resistor r=58.3583
    rD_41 (D_33 MM11_ELT_g) resistor r=7.45
    rD_40 (D_33 D_36) resistor r=6.30933
    rD_39 (D_33 D_63) resistor r=1.63969
    rD_38 (D_33 D_71) resistor r=4.16253
    rD_37 (D_33 D_39) resistor r=4.16253
    rD_36 (D_33 D_60) resistor r=4.16253
    rD_35 (D_33 D_90) resistor r=4.16253
    rD_34 (D_33 D_68) resistor r=4.16253
    rD_33 (D_33 D_93) resistor r=4.16253
    rD_32 (D_79 MM1_ELT_g) resistor r=36.0083
    rD_31 (D_93 MM11_ELT_g) resistor r=50.9083
    rD_30 (D_132 D_133) resistor r=10
    rD_29 (D_132 D) resistor r=0.0784805
    rD_28 (D_133 D_200) resistor r=13.5455
    rD_27 (D_161 D_201) resistor r=4.38767
    rD_26 (D_173 D_174) resistor r=57.5682
    rD_25 (D_173 D_197) resistor r=9.29775
    rD_24 (D_174 D_201) resistor r=3.71511
    rD_23 (D_187 D_195) resistor r=8.32506
    rD_22 (D_194 D_195) resistor r=40.975
    rD_21 (D_194 D_196) resistor r=8.32506
    rD_20 (D_196 D_197) resistor r=275.65
    rD_19 (D_200 D_201) resistor r=3.71511
ends DDFD1_LVT_ELT
// End of subcircuit definition.

// Library name: lpGbtxHsLib
// Cell name: ND4D1_LVT_ELT
// View name: calibre
subckt ND4D1_LVT_ELT A1 A2 A3 A4 VDD VSS ZN
    MM26_ELT (MM26_ELT_d MM26_ELT_g MM26_ELT_s MM26_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM22_ELT (MM22_ELT_d MM22_ELT_g MM22_ELT_s MM22_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM21_ELT (MM21_ELT_d MM21_ELT_g MM21_ELT_s MM21_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM1_ELT (MM1_ELT_d MM1_ELT_g MM1_ELT_s MM1_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM25_ELT (MM25_ELT_d MM25_ELT_g MM25_ELT_s MM25_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM24_ELT (MM24_ELT_d MM24_ELT_g MM24_ELT_s MM24_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=9.4e-14 as=2.45375e-13 pd=1.34e-06 \
        ps=3.835e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM23_ELT (MM23_ELT_d MM23_ELT_g MM23_ELT_s MM23_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM2_ELT (MM2_ELT_d MM2_ELT_g MM2_ELT_s MM2_ELT_b) nch_lvt l=6e-08 \
        w=1.42e-06 m=1 nf=1 ad=2.45375e-13 as=9.4e-14 pd=3.835e-06 \
        ps=1.34e-06 nrd=0.0704225 nrs=0.0704225 sa=175.00n sb=175.00n \
        sca=0 scb=0 scc=0
    MM16_ELT (MM16_ELT_d MM16_ELT_g MM16_ELT_s MM16_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=1.55675e-12 pd=3.66e-06 \
        ps=1.037e-05 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM15_ELT (MM15_ELT_d MM15_ELT_g MM15_ELT_s MM15_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=1.55675e-12 pd=3.66e-06 \
        ps=1.037e-05 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM11_ELT (MM11_ELT_d MM11_ELT_g MM11_ELT_s MM11_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=1.55675e-12 pd=3.66e-06 \
        ps=1.037e-05 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    MM10_ELT (MM10_ELT_d MM10_ELT_g MM10_ELT_s MM10_ELT_b) pch_lvt l=6e-08 \
        w=3.74e-06 m=1 nf=1 ad=3.26e-13 as=1.55675e-12 pd=3.66e-06 \
        ps=1.037e-05 nrd=0.026738 nrs=0.026738 sa=175.00n sb=175.00n sca=0 \
        scb=0 scc=0
    cinet022_8 (net022_4 VSS) capacitor c=1.0316e-17
    cinet022_7 (net022_6 VSS) capacitor c=1.4183e-18
    cinet022_6 (net022_7 VSS) capacitor c=5.86199e-18
    cinet022_5 (net022_8 VSS) capacitor c=1.29855e-18
    cinet022_4 (net022_9 VSS) capacitor c=3.83028e-18
    cinet022_3 (net022_12 VSS) capacitor c=1.51239e-17
    cinet022_2 (net022_16 VSS) capacitor c=2.76039e-18
    cinet022_1 (net022_17 VSS) capacitor c=2.91383e-18
    cinet022_0 (net022_20 VSS) capacitor c=9.87787e-18
    cinet013_8 (net013_4 VSS) capacitor c=1.12329e-17
    cinet013_7 (net013_6 VSS) capacitor c=1.4183e-18
    cinet013_6 (net013_7 VSS) capacitor c=3.52298e-18
    cinet013_5 (MM25_ELT_d VSS) capacitor c=1.27412e-17
    cinet013_4 (net013_13 VSS) capacitor c=1.13006e-17
    cinet013_3 (net013_14 VSS) capacitor c=1.4183e-18
    cinet013_2 (net013_16 VSS) capacitor c=3.52298e-18
    cinet013_1 (net013_18 VSS) capacitor c=4.28125e-18
    cinet013_0 (net013_20 VSS) capacitor c=2.21571e-18
    ciZN_26 (ZN_3 VSS) capacitor c=1.65536e-16
    ciZN_25 (ZN_4 VSS) capacitor c=1.14224e-16
    ciZN_24 (ZN_6 VSS) capacitor c=2.8005e-17
    ciZN_23 (ZN_7 VSS) capacitor c=1.63056e-17
    ciZN_22 (ZN_10 VSS) capacitor c=1.64938e-16
    ciZN_21 (ZN_11 VSS) capacitor c=3.29491e-16
    ciZN_20 (ZN_19 VSS) capacitor c=7.85838e-17
    ciZN_19 (ZN_23 VSS) capacitor c=1.75026e-16
    ciZN_18 (ZN_24 VSS) capacitor c=3.35291e-16
    ciZN_17 (ZN_32 VSS) capacitor c=2.03385e-16
    ciZN_16 (ZN_36 VSS) capacitor c=1.95554e-16
    ciZN_15 (ZN_37 VSS) capacitor c=3.34216e-16
    ciZN_14 (ZN_45 VSS) capacitor c=2.88151e-16
    ciZN_13 (ZN_49 VSS) capacitor c=1.91044e-16
    ciZN_12 (ZN_50 VSS) capacitor c=3.25774e-16
    ciZN_11 (ZN_58 VSS) capacitor c=4.10421e-17
    ciZN_10 (ZN_60 VSS) capacitor c=4.29201e-17
    ciZN_9 (ZN_63 VSS) capacitor c=1.20619e-17
    ciZN_8 (ZN_64 VSS) capacitor c=1.20619e-17
    ciZN_7 (ZN_65 VSS) capacitor c=7.93905e-18
    ciZN_6 (ZN_66 VSS) capacitor c=1.19932e-17
    ciZN_5 (ZN_73 VSS) capacitor c=5.86199e-18
    ciZN_4 (ZN_75 VSS) capacitor c=4.1563e-18
    ciZN_3 (ZN_77 VSS) capacitor c=1.4183e-18
    ciZN_2 (ZN_79 VSS) capacitor c=3.52298e-18
    ciZN_1 (ZN_84 VSS) capacitor c=9.31905e-18
    ciZN_0 (ZN_86 VSS) capacitor c=2.21571e-18
    cinet012_5 (net012_3 VSS) capacitor c=5.18024e-17
    cinet012_4 (net012_4 VSS) capacitor c=1.10396e-16
    cinet012_3 (net012_6 VSS) capacitor c=4.23124e-16
    cinet012_2 (net012_7 VSS) capacitor c=1.16417e-17
    cinet012_1 (net012_10 VSS) capacitor c=6.10931e-17
    cinet012_0 (net012_11 VSS) capacitor c=1.12511e-16
    ciVDD_32 (VDD_2 VSS) capacitor c=5.88751e-17
    ciVDD_31 (VDD_11 VSS) capacitor c=1.32674e-16
    ciVDD_30 (VDD_20 VSS) capacitor c=8.73634e-17
    ciVDD_29 (VDD_30 VSS) capacitor c=1.71804e-16
    ciVDD_28 (VDD_39 VSS) capacitor c=8.34108e-17
    ciVDD_27 (VDD_49 VSS) capacitor c=1.58195e-16
    ciVDD_26 (VDD_58 VSS) capacitor c=7.94583e-17
    ciVDD_25 (VDD_68 VSS) capacitor c=1.40952e-16
    ciVDD_24 (VDD_82 VSS) capacitor c=7.35146e-17
    ciVDD_23 (VDD_85 VSS) capacitor c=3.58509e-18
    ciVDD_22 (VDD_86 VSS) capacitor c=3.58509e-18
    ciVDD_21 (VDD_87 VSS) capacitor c=3.58509e-18
    ciVDD_20 (VDD_88 VSS) capacitor c=3.58509e-18
    ciVDD_19 (VDD_94 VSS) capacitor c=1.11099e-18
    ciVDD_18 (VDD_95 VSS) capacitor c=1.55387e-18
    ciVDD_17 (VDD_96 VSS) capacitor c=3.34937e-18
    ciVDD_16 (VDD_99 VSS) capacitor c=3.30731e-17
    ciVDD_15 (VDD_103 VSS) capacitor c=2.68695e-17
    ciVDD_14 (VDD_104 VSS) capacitor c=4.26321e-18
    ciVDD_13 (VDD_105 VSS) capacitor c=5.14579e-18
    ciVDD_12 (VDD_108 VSS) capacitor c=1.11099e-18
    ciVDD_11 (VDD_112 VSS) capacitor c=2.42994e-17
    ciVDD_10 (VDD_113 VSS) capacitor c=1.2229e-18
    ciVDD_9 (VDD_114 VSS) capacitor c=4.16468e-18
    ciVDD_8 (VDD_117 VSS) capacitor c=1.11099e-18
    ciVDD_7 (VDD_121 VSS) capacitor c=1.11099e-18
    ciVDD_6 (VDD_122 VSS) capacitor c=5.15689e-19
    ciVDD_5 (VDD_123 VSS) capacitor c=3.26801e-18
    ciVDD_4 (VDD_126 VSS) capacitor c=1.7205e-17
    ciVDD_3 (VDD_127 VSS) capacitor c=1.95572e-16
    ciVDD_2 (VDD_128 VSS) capacitor c=2.66244e-16
    ciVDD_1 (VDD_129 VSS) capacitor c=2.59934e-16
    ciVDD_0 (VDD_130 VSS) capacitor c=2.3734e-16
    ciVSS_8 (VSS_2 VSS) capacitor c=5.10246e-16
    ciVSS_7 (VSS_29 VSS) capacitor c=8.82129e-17
    ciVSS_6 (VSS_30 VSS) capacitor c=1.20998e-16
    ciVSS_5 (VSS_37 VSS) capacitor c=7.34722e-17
    ciVSS_4 (VSS_40 VSS) capacitor c=3.58509e-18
    ciVSS_3 (MM22_ELT_s VSS) capacitor c=1.06579e-17
    ciVSS_2 (VSS_47 VSS) capacitor c=4.3326e-18
    ciVSS_1 (VSS_53 VSS) capacitor c=6.51372e-18
    ciVSS_0 (VSS_60 VSS) capacitor c=4.9967e-18
    cinet021_6 (net021_3 VSS) capacitor c=1.02155e-17
    cinet021_5 (net021_4 VSS) capacitor c=1.18722e-16
    cinet021_4 (net021_8 VSS) capacitor c=9.93061e-17
    cinet021_3 (net021_12 VSS) capacitor c=1.50829e-17
    cinet021_2 (net021_13 VSS) capacitor c=1.23648e-16
    cinet021_1 (net021_17 VSS) capacitor c=2.58151e-17
    cinet021_0 (net021_18 VSS) capacitor c=3.29057e-17
    cinet024_5 (net024_3 VSS) capacitor c=6.32833e-17
    cinet024_4 (net024_4 VSS) capacitor c=1.13689e-16
    cinet024_3 (net024_6 VSS) capacitor c=4.60349e-16
    cinet024_2 (net024_7 VSS) capacitor c=1.60626e-17
    cinet024_1 (net024_10 VSS) capacitor c=4.95031e-17
